# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N23597688: length 47.4
  TOP w0.305: PR218.1 138.59,183.41 v1(138.26,183.74)
  IN3 w0.203: v1(138.26,183.74) 138.26,183.92 139.3,184.96 148.75,184.96 151.97,181.73 151.97,165.15 146.67,159.84 146.67,153.94 v1(146.87,153.74)
  BOTTOM w0.254: v1(146.87,153.74) 147.24,153.37 PR242.1
N23597706: length 1
  BOTTOM w0.381: PR48.1 137.62,184.51 PC40.1
  vias: v1(136.94,184.09)
N23597754: length 37.9
  IN3 w0.203: v1(138.72,171.98) 138.69,171.95 138.69,170.96 138.13,170.4 134.65,170.4 133.81,169.56 126.96,169.56 122.92,165.53 120.81,165.53 119.06,163.77 118.27,163.77 116.73,162.24 116.73,160.99 115.3,159.56 115.3,154.35 114.89,153.94 114.89,152.62 v1(115.02,152.5)
  BOTTOM w0.305: PR193.1 139.05,171.65 v1(138.72,171.98)
  vias: v1(114.81,151.89)
N23597796: length 1.5
  TOP w0.305: PC19.2 142.12,170 v1(142.02,169.9) PR21.2
N23599146:
  vias: v1(135.74,171.27)
N23599234: length 1
  TOP w0.305: PR23.2 139.02,169.65 PC15.1
N23599240: length 1
  TOP w0.305: PR24.2 PC16.1
N23599296: length 2.2
  TOP w0.127: v1(148.49,175.43) 148.12,175.8 PR34.2
  TOP w0.305: PC26.1 148.12,176.25 PR34.2
N23599379: length 37.5
  TOP w0.305: PR205.1 147.66,180.58 v1(147.66,180.08)
  IN3 w0.203: v1(147.66,180.08) 146.92,180.08 145.57,178.73 145.57,168.8 142.37,165.6 139.32,165.6 133.48,159.76 133.48,152.8 133.86,152.42 v1(133.86,152.24)
  BOTTOM w0.203: PR243.1 134.23,151.85 133.86,152.22 v1(133.86,152.24)
N23599446: length 2.3
  TOP w0.127: v1(148.11,183.48) 148.11,183.37 147.4,182.66 PR41.1
  TOP w0.305: PC34.1 146.65,182.51 146.78,182.64 PR41.1
N23599474: length 1.1
  TOP w0.254: PR199.2 145.99,175.94 PC135.1
N23599495: length 1.4
  TOP w0.305: PR36.2 145.12,177.05 144.32,177.85 PC28.1
N23599502: length 7.8
  TOP w0.305: PR51.1 PC46.2 144.28,185.85 144.37,185.94 PR50.1 144.17,186.61 143.52,186.61 v1(143.47,186.56)
  BOTTOM w0.381: v1(143.47,186.56) 143.23,186.32 PC44.1 PC42.2 142.05,185.32 v1(141.37,184.64) 141.15,184.42 PR217.2
N23599619:
  vias: v1(143.29,184.27)
N23602015: length 43.8
  TOP w0.305: v1(148.72,180.31) 148.7,180.33 PR215.2
  IN3 w0.203: v1(148.72,180.31) 148.67,180.26 148.67,179.95 148.44,179.72 148.44,177.9 146.77,176.22 146.77,168.19 141.59,163.01 138.54,163.01 134.88,159.35 134.88,150.95 135.13,150.69 v1(135.13,150.67)
  BOTTOM w0.254: v1(135.13,150.67) 135.26,150.54 138.16,150.54 138.59,150.97 PL4.3
N23602017: length 42.5
  TOP w0.305: PR214.2 148.26,179.03 v1(147.71,178.48)
  IN3 w0.203: v1(135.21,149.96) 135.16,149.96 134.52,150.59 134.52,159.63 138.41,163.52 141.53,163.52 146.34,168.32 146.34,176.52 147.71,177.9 v1(147.71,178.48)
  BOTTOM w0.254: v1(135.21,149.96) 135.21,149.93 135.31,150.03 138.11,150.03 138.59,149.55 PL4.4
N23602068:
  vias: v1(140.42,154.83)
N23602149: length 41.7
  IN3 w0.203: v1(116.64,151.68) 116.33,152 116.33,158.78 117.84,160.29 117.84,161.72 118.62,162.5 119.56,162.5 121.39,164.33 123.7,164.33 127.69,168.32 135.97,168.32 v1(137.12,167.18)
  BOTTOM w0.254: v1(116.64,151.68) 116.74,151.58 118.95,151.58 119.64,152.27 PL2.3
  BOTTOM w0.305: v1(137.12,167.18) v1(137.74,166.55) PR20.2 139.49,166.55 139.76,166.82 PR19.2
N23602161: length 42
  IN3 w0.203: v1(141.23,169.26) 141,169.03 141,167.56 140.09,166.64 126.88,166.64 124.58,164.35 124.58,151.75 124.39,151.56 v1(124.39,151.61)
  BOTTOM w0.254: PL3.3 128.73,151.96 128.15,151.38 124.62,151.38 v1(124.39,151.61)
  BOTTOM w0.305: v1(141.23,169.26) 141.73,168.76 PR190.2 142.55,168.47 142.64,168.38 v1(142.69,168.38) PR189.2
N23602183: length 48.3
  IN3 w0.203: v1(137.09,168.47) 137.09,168.52 136.87,168.74 127.48,168.74 123.48,164.74 121.21,164.74 119.41,162.94 118.57,162.94 117.46,161.82 117.46,160.6 116.01,159.15 116.01,151.53 116.31,151.23 v1(116.31,151.12)
  IN3 w0.254: v1(142.5,172.13) 142.5,171.83 141.13,170.45 139.88,170.45 137.9,168.47 v1(137.09,168.47)
  BOTTOM w0.254: v1(116.31,151.12) 116.36,151.07 119.03,151.07 119.64,150.46 PL2.4
  BOTTOM w0.305: v1(142.5,172.13) 142.5,172.21 142.44,172.27 PR18.1 ; v1(137.09,168.47) 137.81,169.19 PR17.2
N23602227: length 43.4
  IN3 w0.203: v1(124.8,150.87) 124.9,150.97 124.9,164.03 127.11,166.24 141.23,166.24 142.5,167.51 142.5,168.29 143.19,168.98 v1(143.11,168.98)
  BOTTOM w0.254: v1(124.8,150.87) 125.02,150.64 128.38,150.64 128.73,150.29 PL3.4
  BOTTOM w0.305: PR188.1 142.23,170.6 PR182.2 142.85,168.98 v1(143.11,168.98)
N23602628: length 1.1
  BOTTOM w0.127: PC142.1 v1(123.84,164.42)
N23603098: length 3.4
  BOTTOM w0.127: PC143.1 132.04,165.32 v1(133.94,165.32)
N23603167: length 4.6
  BOTTOM w0.127: PR237.2 138.57,162.65 138.41,162.81 138.41,164.43 v1(138.72,164.74)
  BOTTOM w0.254: PU8.1 138.47,162.35 PR237.2
N23603171: length 2.2
  BOTTOM w0.229: PU8.2 138.97,161.88 v1(139.04,161.95)
  BOTTOM w0.254: v1(139.04,161.95) PR238.2
N23603204: length 1.2
  BOTTOM w0.127: v1(142.63,165.2) 142.63,164.32 PC144.1
N23603280: length 2.2
  BOTTOM w0.254: PR229.2 120.19,162.36 119.39,161.57 PU13.2
N23603284: length 2
  BOTTOM w0.254: PU13.1 118.89,161.81 119.22,162.14 v1(119.22,162.22) PR228.2
N23603328:
  vias: v1(127.36,162.05)
N23603357: length 2
  BOTTOM w0.229: PU7.2 129.08,161.75 v1(128.71,162.12)
  BOTTOM w0.254: v1(128.71,162.12) 128.44,162.39 PR234.2
N23605624: length 2.3
  BOTTOM w0.254: PR239.2 149.82,162.96 149.66,162.81 v1(149.66,162.45) 149.66,162.43 150.04,162.05 150.27,162.05 150.49,161.83 PU9.1
N23605675: length 56.7
  IN3 w0.203: v1(140.65,186.1) 140.67,186.07 149.71,186.07 153.47,182.32 153.47,165.55 148.14,160.22 148.14,158.92 149.13,157.93 149.13,155.06 147.71,153.64 147.71,149.24 v1(148.04,148.91)
  BOTTOM w0.254: v1(148.04,148.91) 148.24,148.71 150.12,148.71 150.78,149.37 PL5.3
  BOTTOM w0.381: PR222.2 140.64,186.09 v1(140.65,186.1)
N23605677: length 59.6
  IN3 w0.203: v1(147.53,148.46) 147.35,148.64 147.35,153.73 148.8,155.18 148.8,157.81 147.82,158.79 147.82,160.46 153.09,165.73 153.09,182.01 149.56,185.54 140.37,185.54 140.16,185.74 140.16,187.22 v1(140.44,187.5)
  BOTTOM w0.254: v1(147.53,148.46) 147.55,148.48 147.78,148.25 150.37,148.25 150.78,147.85 PL5.4
  BOTTOM w0.381: PR221.2 140.39,187.45 v1(140.44,187.5)
N23605728:
  vias: v1(150.58,154.6)
N23605743: length 0.9
  BOTTOM w0.127: v1(154.31,164.23) 153.51,164.23 PC145.1
N23607303: length 1.8
  BOTTOM w0.229: PU9.2 150.99,162.34
  BOTTOM w0.254: 150.99,162.34 v1(150.96,162.38) 150.83,162.5 PR240.2
N24586716: length 2.7
  TOP w0.254: v1(64.14,84.7) 64.1,84.66 PR98.2
  TOP w0.762: PC270.1 64.1,82.06 PR98.2
N24586737: length 1
  BOTTOM w0.127: PC267.1 67.92,78.9 v1(67.8,79.01)
N24589983: length 4.8
  TOP w0.203: PR269.2 40.43,55.87 41.32,55.87 41.78,56.33 v1(41.87,56.33) 42.04,56.16 PU21.4
  TOP w0.305: PR269.2 39.77,56.17 39.77,55.8 40.02,55.54 PC218.1
N24590175: length 4.2
  TOP w0.127: PR281.1 40.48,59.11 v1(40.52,59.15)
  TOP w0.203: PR281.1 40.76,58.14 40.76,58.13 42.32,56.56 PU21.3
N24592825: length 2.7
  TOP w0.127: PC290.1 218.66,172.6 v1(218.9,172.84)
  TOP w0.762: PC290.1 218.62,171.82 PR120.2
N24592843: length 1.1
  BOTTOM w0.127: PC289.1 213.7,171.9 v1(213.47,171.67)
N24594676: length 1
  TOP w0.127: PC202.1 v1(48.77,60.87)
N24594784: length 2.5
  TOP w0.254: PC197.1 59.69,60.53 v1(59.67,60.55)
  TOP w0.762: PR90.2 PC197.1
N25349288: length 1.8
  BOTTOM w0.127: CN95.5 110.25,17.75 R11292.1
N25349292: length 1.9
  BOTTOM w0.127: R11293.1 109.75,17.7 CN95.6
N25349296: length 2
  BOTTOM w0.127: CN95.7 109.25,17.31 R11294.1
N25349300: length 2.2
  BOTTOM w0.127: CN95.8 108.75,16.92 R11295.1
N25382293: length 3.1
  TOP w0.508: C4819.2 R2854.2 v1(115.25,32.54) 114.98,32.54 Q75.2
N27464643: length 5.3
  TOP w0.127: TP4309.1 185.96,121.18 186,121.22 186,123.66 v1(186.38,124.04)
  BOTTOM w0.127: U3002.N8 v1(186.38,124.04)
N27464682: length 1.8
  TOP w0.127: TP4308.1 185.44,123.17 v1(185.54,123.17)
  BOTTOM w0.127: v1(185.54,123.17) 185.54,123.22 U3002.P7
N27464689: length 1.6
  TOP w0.127: v1(184.74,121.54) 184.74,121.53 185.22,121.05 TP4306.1
  BOTTOM w0.127: v1(184.74,121.54) 184.74,121.56 U3002.P5
N27464696: length 2.6
  TOP w0.127: v1(187.23,122.39) 186.78,121.94 186.78,120.95 TP4304.1
  BOTTOM w0.127: U3002.L6 v1(187.23,122.39)
N27464703: length 1.6
  TOP w0.127: v1(187.23,119.94) 187.25,119.91 TP4302.1
  BOTTOM w0.127: v1(187.23,119.94) U3002.M3
N215331000: length 7.6
  TOP w0.127: v1(123.62,66.5) 122.87,67.26 122.87,68.98 TP157.1
  BOTTOM w0.127: JDIM2.165 125.72,64.98 124.2,66.5 v1(123.62,66.5)
N215331770: length 8.9
  TOP w0.127: TP158.1 126.42,47.77 126.42,53.23 v1(125.91,53.74)
  BOTTOM w0.127: JDIM2.162 124.97,54.43 125.66,53.74 v1(125.91,53.74)
N224115173: length 2.6
  BOTTOM w0.127: U1006.4 111.42,24.81 112.44,23.79 TP4396.1
N224115174: length 1.6
  BOTTOM w0.127: U1006.5 111.46,24.41 111.69,24.19 111.69,23.62 TP4397.1
N245985901:
  vias: v1(119.54,155.57)
N245991371:
  vias: v1(128.83,155.19)

## Copper pours and planes (outline as drawn)
3V_LR on TOP (solid shape): 28.02,118.76 28.1,118.73 28.12,118.66 28.29,118.32 28.67,118.29 28.69,118.3 28.71,118.3 28.73,118.29 28.76,118.26 28.76,117.87 28.66,117.62 28.76,117.37 28.76,117.18 28.75,117.17 28.72,116.99 28.75,116.81 28.76,116.8 28.76,116.55 28.75,116.54 28.72,116.36 28.75,116.18 28.76,116.17 28.76,115.97 29.01,115.72 29.01,114.81 28.89,114.7 28.82,114.56 28.81,114.55 28.15,114.55 27.74,114.95 27.74,117.75 27.23,118.26 27.23,118.64 27.36,118.76
3V_LR on IN2 (solid shape): outline of 338 points within 25.33,113.43 35.11,125.24
+1.2VSUS on TOP (solid shape): 69.93,67.46 69.93,65.68 69.63,65.37 67.65,65.37 67.32,65.7 67.32,66.26 67.34,66.29 67.34,67.69 67.47,67.81 69.58,67.81
+1.2VSUS on TOP (solid shape): 44.46,59.46 44.46,57.73 44.44,57.69 44.41,57.68 44.31,57.68 44.27,57.69 44.26,57.73 44.26,58.66 44.25,58.66 44.25,58.72 43.8,59.18 42.65,59.18 42.55,59.28 42.55,60.04 42.63,60.12 43.8,60.12
+1.2VSUS on TOP (solid shape): 71.1,61.41 71.12,61.41 71.14,61.4 71.24,61.3 71.25,61.28 71.25,61.26 71.25,60.06 71.25,60.04 71.24,60.03 70.95,59.74 70.93,59.73 70.91,59.72 70.15,58.96 70.13,58.95 70.11,58.95 67.51,58.95 67.5,58.95 67.48,58.96 67.45,58.99 67.44,59.01 67.44,59.03 67.44,59.69 67.42,59.71 67.42,59.73 67.42,60.91 67.42,60.93 67.43,60.94 67.5,61.02 67.52,61.03 67.54,61.03 67.91,61.4 67.93,61.41 67.95,61.41
+1.2VSUS on TOP (solid shape): outline of 28201 points within 75.37,37.87 147,108.19
+1.2VSUS on BOTTOM (solid shape): 75.24,66.26 77.15,66.26 78.52,64.89 78.52,61.49 76.84,59.81 74.94,59.81 74.43,60.32 71.61,60.32 69.06,57.77 67.34,57.77 67.14,57.97 67.14,68.68 67.34,68.88 72.62,68.88
+1.5V on TOP (solid shape): 34.98,50.06 34.98,48.28 34.85,48.15 32.44,48.15 32.06,48.53 32.06,50.06 32.31,50.31 34.73,50.31
+1.5V on TOP (solid shape): 107.77,25.18 107.75,25.05 107.78,24.93 107.78,23.64 107.68,23.54 106.71,23.54 106.56,23.69 106.56,25.12 106.71,25.27 107.68,25.27
+1.5V on TOP (solid shape): 191.19,50.77 191.55,50.41 192.87,50.41 192.97,50.31 192.97,49.25 192.56,48.84 192.16,48.84 191.95,49.04 191.04,49.04 190.43,49.65 190.43,51.18 190.53,51.28 191.19,51.28
+1.5V on TOP (solid shape): outline of 166 points within 155.76,64.66 160.2,68.47
+1.5V on IN2 (solid shape): 33.71,49.8 33.71,47.9 33.33,47.52 32.82,47.52 32.44,47.9 32.44,49.68 32.82,50.06 33.46,50.06
+1.5V on IN2 (solid shape): 106.75,25.53 107.02,25.42 107.28,25.53 107.64,25.53 107.75,25.42 107.75,24.43 107.68,24.35 105.26,24.35 104.7,24.91 104.7,25.47 104.77,25.53
+1.05V_GFX on TOP (solid shape): outline of 3666 points within 161,128.74 213.92,165.12
+1.05V_GFX on BOTTOM (solid shape): 162.69,146.32 162.69,145.43 162.57,145.31 161.3,145.31 161.17,145.43 161.17,146.32 161.3,146.45 162.57,146.45
+1.05V_GFX on BOTTOM (solid shape): 215.17,165.83 215.17,161.67 214.52,161.02 209.97,161.02 209.96,161.03 208.39,161.03 207.24,162.17 207.24,165.83 207.57,166.16 214.84,166.16
+1.05V_GFX on BOTTOM (solid shape): outline of 763 points within 168.97,128.25 175.88,141.62
+1.05V_GFX on IN2 (solid shape): outline of 2475 points within 164.08,120.03 175.7,140.48
+1.35V_GFX on TOP (solid shape): 219.77,161.82 219.77,160.93 222.56,158.13 222.56,157.55 222.54,157.53 222.53,157.52 222.26,157.12 222.53,156.72 222.54,156.71 222.56,156.69 222.56,155.59 224.41,153.74 224.41,150.39 223.78,149.75 220.27,149.75 219.64,150.39 219.64,152.93 218.93,153.64 216.08,153.64 215.32,154.4 215.32,158.26 215.3,158.28 215.3,158.7 215.1,158.9 215.07,158.9 214.81,159.15 214.81,162.83 215.32,163.34 218.24,163.34
+1.35V_GFX on TOP (solid shape): outline of 6433 points within 176.97,124.23 198.43,149.75
+1.35V_GFX on BOTTOM (solid shape): 223.83,153.44 223.83,150.77 223.32,150.26 220.82,150.26 219.51,151.57 219.51,153.31 219.89,153.69 223.58,153.69
+1.35V_GFX on BOTTOM (solid shape): 225,165.96 225,163.34 224.82,163.16 223.88,163.16 223.73,163.01 223.73,161.89 223.75,161.87 223.75,160.75 223.55,160.55 220.55,160.55 219.59,159.58 215.42,159.58 215.4,159.56 213.67,159.56 213.59,159.63 213.59,160.32 213.77,160.5 214.79,160.5 215.58,161.28 215.58,162.1 216.53,163.05 216.53,165.74 217,166.21 224.75,166.21
+1.35V_GFX on BOTTOM (solid shape): outline of 176 points within 221.04,110.38 226.62,118.51
+1.35V_GFX on BOTTOM (solid shape): outline of 389 points within 173.96,139.41 188.04,141.06
+1.35V_GFX on BOTTOM (solid shape): outline of 208 points within 188.59,124.27 191.08,138.42
+1.35V_GFX on SVCC (solid shape): outline of 512 points within 154.49,106.95 221.67,175.53
+1.35V_GFX on IN2 (solid shape): outline of 35094 points within 162.9,111.78 224.59,173.07
+1V_S5 on TOP (solid shape): 64.06,92.65 64.06,90.75 63.73,90.42 59.8,90.42 59.54,90.67 59.54,92.83 59.75,93.03 63.68,93.03
+1V_S5 on TOP (solid shape): outline of 1352 points within 127.95,110 141.15,127.4
+1V_S5 on BOTTOM (solid shape): outline of 152 points within 59.77,86.15 79.93,99.08
+1V_S5 on IN2 (solid shape): outline of 10343 points within 69.91,77.11 142.3,124.48
+1V_S5 on IN3 (solid shape): outline of 530 points within 132.14,113.43 139.76,115.84
+1V_SUS on BOTTOM (solid shape): 80.04,100.5 80.04,98.62 79.91,98.5 77.65,98.5 76.51,99.64 76.51,100.6 76.89,100.98 79.56,100.98
+1V_VCCST on BOTTOM (solid shape): 106.48,132.19 106.48,131.36 106.86,130.98 106.86,130.7 106.74,130.58 103.73,130.58 103.69,130.59 103.68,130.63 103.68,132.21 103.82,132.35 106.32,132.35
+1V_VCCST on BOTTOM (solid shape): 102.23,131.78 102.23,130.74 102.17,130.68 102.14,130.66 101.83,130.7 101.56,130.58 98.48,130.58 98.35,130.7 98.35,131.21 98.99,131.85 98.99,132.23 99.12,132.35 101.66,132.35
+2.5V on BOTTOM (solid shape): 156.39,42.06 157.28,42.06 157.41,41.93 157.41,39.01 157.16,38.75 155.89,38.75 155.12,39.52 155.12,42.44 155.38,42.69 155.76,42.69
+2.5V_SUS on TOP (solid shape): 153.35,61.87 153.35,49.04 154.75,47.64 154.75,47.49 154.9,47.49 155.38,47.01 155.76,47.01 156.27,46.5 156.27,44.34 155.89,43.96 154.74,43.96 151.42,47.28 151.42,47.3 151.1,48 150.36,48.21 150.25,48.19 150.15,48.15 147.63,48.15 147.5,48.28 147.5,49.42 151.38,53.3 151.38,56.95 151.38,56.96 151.42,57.12 151.38,57.28 151.38,57.29 151.38,59.22 151.38,59.23 151.42,59.5 151.38,59.77 151.38,59.78 151.38,60.28 151.19,60.47 148.16,60.47 148.13,60.5 148.13,60.51 148.06,60.64 147.93,60.7 147.91,60.7 147.88,60.73 147.5,60.73 147.38,60.85 147.38,62.25 148.01,62.88 152.33,62.88
+2.5V_SUS on BOTTOM (solid shape): 148.8,64.54 148.84,64.52 148.85,64.49 148.85,62.72 149.1,62.72 149.1,64.49 149.11,64.52 149.15,64.54 149.41,64.54 149.66,64.28 149.66,63.39 149.92,63.14 150.42,63.14 151.06,62.5 151.06,61.74 150.55,61.23 149.66,61.23 148.6,62.3 148.6,64.49 148.65,64.54
+2.5V_SUS on BOTTOM (solid shape): 148.8,52.34 148.84,52.33 148.85,52.29 148.85,50.52 149.1,50.52 149.1,52.29 149.11,52.33 149.15,52.34 150.3,52.34 150.55,52.09 150.55,49.93 150.3,49.68 149.3,49.68 148.6,50.38 148.6,52.27 148.6,52.29 148.61,52.31 148.65,52.34
+2.5V_SUS on BOTTOM (solid shape): 161.32,49.78 161.68,49.78 161.69,49.77 162.11,49.77 162.13,49.75 162.14,49.73 162.29,49.56 162.51,49.5 162.58,49.47 162.62,49.4 162.62,44.22 162.39,43.99 159.72,43.99 158.17,42.44 156.52,42.44 155,43.96 155,48.15 155.5,48.66 156.39,48.66 156.62,48.58 156.85,48.66 157.59,48.66 158.88,49.96 161.14,49.96
+3V on TOP (solid shape): 35.79,76.22 35.79,75.28 35.72,75.2 34.98,75.2 34.85,75.33 34.85,76.09 35.1,76.33 35.68,76.33
+3V on TOP (solid shape): 191.64,39.06 191.64,38.82 191.09,38.27 191.09,38.14 191.06,38.12 191.06,37.48 190.94,37.36 190.3,37.36 190.05,37.61 190.05,38.88 190.56,39.39 191.3,39.39
+3V on TOP (solid shape): 43.74,45.49 43.74,44.72 43.69,44.67 43.67,44.66 43.15,44.48 42.66,44.22 42.65,44.22 42.22,44.22 41.2,43.2 40.06,43.2 39.93,43.33 39.93,44.85 40.7,45.61 43.62,45.61
+3V on TOP (solid shape): 134.61,182.33 134.8,182.14 134.8,180.23 134.68,180.11 133.41,180.11 133.28,180.23 133.28,181.86 133.29,181.89 133.32,181.91 133.95,182.08 134.56,182.33 134.57,182.34
+3V on TOP (solid shape): 22.03,44.72 22.03,43.58 21.9,43.45 19.74,43.45 19.61,43.58 19.61,43.94 19.63,43.96 19.64,43.97 19.77,44.06 19.85,44.19 19.85,44.2 19.87,44.22 19.87,44.98 20,45.1 21.65,45.1
+3V on TOP (solid shape): 26.66,63.33 29.46,63.33 29.94,62.85 29.94,62.84 30.03,62.7 30.17,62.61 30.18,62.61 30.73,62.06 30.73,61.05 30.79,60.99 30.79,59.2 30.66,59.07 29.9,59.07 28,60.98 25.96,60.98 25.33,61.61 25.33,63.01 25.71,63.39 26.6,63.39
+3V on TOP (solid shape): 53.85,53.25 54.37,53.25 54.5,53.37 54.57,53.41 54.62,53.46 54.62,53.46 55.74,53.46 55.76,53.46 55.78,53.45 57.3,53.45 57.41,53.33 57.41,51.68 56.75,51.02 53.04,51.02 52.69,50.67 51.31,50.67 50.88,51.1 50.88,53.21 51.16,53.49 53.61,53.49
+3V on TOP (solid shape): 18.73,54.76 18.73,53.61 18.65,53.54 18.63,53.53 18.6,53.53 18.41,53.54 18.23,53.49 17.83,53.49 17.58,53.54 17.34,53.49 16.44,53.49 16.31,53.61 16.31,54.63 16.69,55.01 18.47,55.01
+3V on TOP (solid shape): 25.2,56.28 25.2,55.14 24.44,54.38 23.04,54.38 22.79,54.12 22.79,51.33 21.98,50.52 20.66,50.52 20.61,50.57 20.61,51.56 20.71,51.66 20.86,51.66 21.12,51.93 21.12,52.07 21.77,52.72 21.77,53.23 21.52,53.49 21.27,53.49 21.14,53.61 21.14,53.99 20.76,54.38 20.5,54.38 20.25,54.63 20.25,54.88 20.38,55.01 20.76,55.01 22.15,56.41 25.08,56.41
+3V on TOP (solid shape): 151.67,109.62 151.68,109.62 151.8,109.6 151.92,109.61 151.93,109.62 151.96,109.61 152.08,109.49 152.08,108.99 151.82,108.73 150.3,108.73 150.15,108.58 150.13,108.58 150.01,108.54 149.94,108.44 149.93,108.42 149.9,108.41 149.65,108.41 149.19,107.94 148.8,107.94 148.77,107.97 148.77,108.94 148.82,108.99 149.55,108.99 149.56,109 149.96,109.12 150.01,109.53 150.04,109.6 150.11,109.62 151.55,109.62
+3V on TOP (solid shape): 204.91,51.84 204.98,51.84 204.99,51.82 205.12,51.74 205.27,51.72 205.42,51.74 205.54,51.82 205.56,51.84 205.62,51.84 205.64,51.83 205.65,51.82 205.93,51.71 206.21,51.84 207.57,51.84 208.34,51.07 208.34,50.57 208.08,50.31 207.45,50.31 207.07,50.69 204.02,50.69 203.76,50.95 201,50.95 200.66,51.07 200.38,50.86 200.37,50.86 198.94,49.42 198.94,48.66 198.68,48.41 198.05,48.41 197.8,48.66 197.8,50.44 199.57,52.22 204.53,52.22
+3V on TOP (solid shape): outline of 154 points within 107.63,153.44 113.06,162.88
+3V on BOTTOM (solid shape): 203.89,192.17 203.89,190.9 203.85,190.85 203.82,190.84 203.78,190.85 203.53,190.9 203.3,190.78 203.3,190.77 202.37,190.77 202.24,190.9 202.24,192.17 202.37,192.3 203.76,192.3
+3V on BOTTOM (solid shape): 199.67,49.67 199.67,48.65 199.65,48.64 199.63,48.63 199.16,48.63 198.94,48.41 198.89,48.41 198.74,48.38 198.6,48.28 198.58,48.28 198.18,48.28 198.08,48.38 198.08,49.22 198.16,49.3 198.17,49.3 198.54,49.68 199.66,49.68
+3V on BOTTOM (solid shape): 58.12,53.69 58.12,53.6 58.11,53.57 58.07,53.55 57.38,53.55 57.38,53.35 58.07,53.35 58.11,53.34 58.12,53.3 58.12,53.21 57.56,52.65 57.56,51.61 57.36,51.4 57.3,51.39 57.25,51.38 55.3,51.38 54.51,50.59 51.24,50.59 50.78,51.05 50.78,53.16 51.12,53.5 53.08,53.5 53.35,53.23 54.36,53.23 54.5,53.37 54.56,53.41 54.61,53.45 54.62,53.46 57.08,53.46 57.37,53.75 58.06,53.75
+3V on BOTTOM (solid shape): 180.78,93.49 180.78,88.41 180.4,88.03 178.62,88.03 178.24,88.41 178.24,89.11 178.24,89.14 178.26,89.17 178.3,89.21 178.33,89.17 178.63,89.17 178.65,89.18 178.66,89.19 178.98,89.5 178.99,89.52 178.99,89.54 178.99,90.34 178.97,90.38 178.93,90.48 178.84,90.55 178.82,90.62 178.85,90.68 179.24,91.06 179.25,91.08 179.25,91.1 179.25,92.26 179.29,92.3 179.29,93.7 179.44,93.85 180.42,93.85
+3V on BOTTOM (solid shape): 210.88,62.63 210.88,52.22 208.59,49.93 207.57,49.93 207.45,50.06 207.45,50.57 207.07,50.95 207.07,51.33 207.32,51.58 207.7,51.58 208.59,52.47 208.72,52.47 208.72,52.6 208.84,52.72 208.84,52.85 209.86,52.85 209.86,52.8 209.88,52.74 209.9,52.69 209.92,52.64 209.96,52.6 210,52.56 210.04,52.53 210.09,52.5 210.15,52.48 210.2,52.47 210.26,52.47 210.31,52.48 210.36,52.49 210.42,52.51 210.46,52.54 210.51,52.58 210.54,52.62 210.57,52.66 210.6,52.72 210.61,52.77 210.62,52.82 210.62,52.88 210.61,52.93 210.6,52.99 210.57,53.04 210.54,53.09 210.51,53.13 210.46,53.16 210.42,53.19 210.36,53.21 210.31,53.23 210.26,53.23 210.2,53.23 210.15,53.22 210.09,53.2 210.04,53.18 210,53.15 209.96,53.11 209.92,53.06 209.9,53.01 209.88,52.96 209.86,52.91 209.86,52.85 208.84,52.85 208.84,53.74 209.61,54.5 209.61,61.61 208.21,63.01 208.21,64.15 208.34,64.28 209.23,64.28
+3V on BOTTOM (solid shape): outline of 2210 points within 14.79,43.07 43.34,74.37
+3V on IN1 (solid shape): outline of 105 points within 208.08,62.88 220.4,66.57
+3V on IN1 (solid shape): outline of 198 points within 190.18,38.5 199.07,49.8
+3V on IN2 (solid shape): 135.44,182.65 135.44,182.39 134.8,181.76 134.75,181.76 134.35,181.35 133.69,181.35 133.28,181.76 133.28,182.01 134.55,183.28 134.8,183.28
+3V on IN2 (solid shape): 81.64,115.08 81.64,114.83 80.57,113.76 79.86,113.76 79.41,113.3 79.41,113.28 77.98,111.86 77.63,111.86 76.99,112.49 76.99,113.1 79.1,115.21 79.86,115.21 80.5,115.84 80.88,115.84
+3V on IN2 (solid shape): 111.96,154.69 111.96,154.68 111.99,154.56 112.07,154.44 112.07,154.42 112.07,153.7 111.93,153.56 110.17,153.56 110.04,153.69 110.04,154.71 110.17,154.83 111.82,154.83
+3V on IN2 (solid shape): 204.02,192.04 204.02,191.03 203.84,190.85 203.81,190.83 203.55,190.89 203.33,190.79 203.32,190.78 203.3,190.77 202.49,190.77 201.86,191.41 201.86,192.42 201.99,192.55 203.51,192.55
+3V on IN2 (solid shape): 97.72,133.88 97.72,133.51 97.67,133.46 97.66,133.45 97.49,133.38 97.38,133.24 97.36,133.22 97.35,133.21 97.11,132.78 97.5,132.49 97.57,132.47 97.61,132.41 97.65,132.31 97.71,132.23 97.72,132.21 97.72,132.11 97.71,132.1 97.61,131.9 97.64,131.66 97.63,131.63 97.34,131.34 95.69,131.34 95.43,131.59 95.43,133.24 96.58,134.39 97.21,134.39
+3V on IN2 (solid shape): outline of 323 points within 159.44,179.09 184.21,188.23
+3V on IN2 (solid shape): outline of 661 points within 107.37,157.88 122.61,177.31
+3V on IN2 (solid shape): outline of 5066 points within 39.94,34.18 209.48,90.95
+3V on IN3 (solid shape): 134.93,182.01 134.93,181.25 134.55,180.87 132.01,180.87 131.76,181.12 131.76,182.14 131.88,182.26 134.68,182.26
+3V on IN3 (solid shape): 123.88,177.31 123.88,177.06 123.12,176.3 121.34,176.3 121.21,176.42 121.21,177.31 121.34,177.44 122.48,177.44 122.99,177.95 123.25,177.95
+3V3_SATA_N1 on BOTTOM (solid shape): outline of 382 points within 156.17,91.59 180.71,100.35
+3V3_SATA_N1_N on TOP (solid shape): outline of 137 points within 170.94,91.71 181.03,95.65
+3V3_SATA_N1_N on BOTTOM (solid shape): 180.78,96.29 180.78,94.25 180.52,94 179.71,94 179.51,94.2 179.51,96.49 179.52,96.52 179.56,96.54 180.52,96.54
+3V3_SATA_N1_N on BOTTOM (solid shape): 172.14,96.54 172.14,93.24 171.89,92.98 170.74,92.98 170.36,93.36 170.36,95.1 171.85,95.1 171.85,96.65 171.65,96.65 171.65,95.1 171.35,95.1 171.35,96.65 171.15,96.65 171.15,95.1 170.85,95.1 170.85,96.65 170.65,96.65 170.65,95.1 170.36,95.1 170.36,96.67 170.49,96.79 171.89,96.79
+3V3_SD_SW on TOP (solid shape): 37.61,24.95 37.61,24.11 37.52,24.02 35.87,24.02 35.49,23.64 35.49,21.74 35.24,21.48 34.47,21.48 34.35,21.61 34.35,24.78 34.47,24.91 36,24.91 36.12,25.04 37.52,25.04
+3V3_TPM on BOTTOM (solid shape): 165.77,67.96 165.79,67.96 165.81,67.95 165.83,67.93 165.84,67.91 165.84,67.89 165.84,67.08 165.84,67.06 165.87,67.03 165.88,67.03 165.91,67 165.91,66.9 165.92,66.9 165.92,66.59 165.92,66.57 165.93,66.55 166.03,66.46 166.04,66.44 166.05,66.42 166.05,65.7 166.04,65.68 166.03,65.66 165.91,65.55 165.56,65.55 165.54,65.55 165.52,65.54 165.21,65.23 164.37,65.23 164.35,65.24 164.34,65.25 164.14,65.44 164.12,65.46 164.1,65.46 163.05,65.46 163.01,65.47 163,65.51 163,66.17 163,66.19 163.01,66.2 163.11,66.3 163.13,66.31 163.15,66.31 163.74,66.31 163.76,66.32 163.77,66.33 163.89,66.44 163.91,66.45 164.08,66.55 164.18,66.72 164.19,66.75 165.4,67.95 165.41,67.96 165.43,67.96
+3V3_TPM_VSB on BOTTOM (solid shape): 169.98,67.58 169.98,65.42 170.11,65.3 170.11,64.23 170.71,63.63 170.71,63.22 170.51,63.01 169.04,63.01 168.98,63.05 168.9,63.08 168.71,63.27 168.71,66.44 169.09,66.82 169.09,67.84 169.22,67.96 169.6,67.96
+3V_EC on TOP (solid shape): 189.92,38.37 189.92,37.56 189.92,37.56 189.92,35.96 189.79,35.83 188.78,35.83 188.52,36.09 188.52,36.6 188.27,36.85 186.36,36.85 186.28,36.86 186.19,36.85 185.86,36.85 185.8,36.89 185.72,36.91 185.6,36.93 185.47,36.9 185.44,36.89 185.35,36.98 185.35,37.61 186.37,38.63 189.67,38.63
+3V_GFX on TOP (solid shape): 188.52,112.54 188.52,112.29 188.4,112.16 185.99,112.16 185.77,111.95 185.5,111.95 185.35,112.09 185.35,112.54 185.48,112.67 188.4,112.67
+3V_GFX on TOP (solid shape): 182.56,105.43 182.56,104.92 182.43,104.79 182.43,102.89 181.92,102.38 181.89,102.37 180.38,100.86 178.24,100.86 177.98,101.11 177.98,101.42 177.98,101.42 177.98,102 178.36,102.38 179.51,102.38 180.65,103.52 180.65,104.86 180.68,104.93 180.74,104.96 181.17,105.03 181.25,105.47 181.28,105.53 181.35,105.56 182.43,105.56
+3V_GFX on TOP (solid shape): 178.62,128.93 178.62,128.42 178.36,128.16 176.71,128.16 176.21,127.65 174.68,127.65 174.58,127.55 174.52,127.51 174.48,127.46 174.28,127.26 174.07,127.26 173.96,127.15 173.54,127.15 173.53,127.16 173.53,127.75 173.67,127.89 173.69,127.91 173.72,127.91 174.03,127.97 174.18,128.24 174.19,128.26 174.22,128.29 175.32,128.29 175.33,128.28 175.79,128.17 176.01,128.58 176.01,128.59 176.02,128.61 176.46,129.05 178.49,129.05
+3V_GFX on TOP (solid shape): 189.29,124.99 189.29,124.68 189.29,124.68 189.29,123.6 189.25,123.52 189.17,123.5 188.58,123.42 188.78,122.86 188.8,122.8 188.78,122.74 188.74,122.72 188.71,122.7 187.76,122.7 187.55,122.92 187.53,122.95 187.61,123.23 187.51,123.46 187.51,123.78 187.58,123.9 187.61,124.04 187.61,124.17 188.02,124.58 188.02,124.61 188.14,124.73 188.14,125.11 188.4,125.37 188.91,125.37
+3V_GFX on TOP (solid shape): 172.23,110.47 173.5,110.47 173.54,110.46 173.55,110.42 173.55,110.21 174,109.76 175.36,109.76 175.53,109.92 175.56,109.94 175.6,109.92 175.68,109.83 175.68,108.99 173.83,107.13 172.24,107.13 172.16,107.16 172.13,107.24 171.81,107.83 171.52,107.21 171.53,107.16 171.48,107.13 171.4,107.13 170.38,108.16 170.38,110.5 170.38,110.51 170.39,110.53 170.48,110.69 170.48,110.86 170.52,110.91 170.58,110.93 171.77,110.93
+3V_GFX on BOTTOM (solid shape): 189.54,112.54 189.54,112.29 189.41,112.16 187,112.16 186.87,112.29 186.87,112.54 187,112.67 189.41,112.67
+3V_GFX on BOTTOM (solid shape): 184.46,114.57 184.46,113.68 184.33,113.56 183.7,113.56 183.45,113.81 183.44,113.83 183.33,114.08 183.08,114.19 183.06,114.19 182.94,114.32 182.94,114.57 183.06,114.7 184.33,114.7
+3V_GFX on BOTTOM (solid shape): 175.64,127.91 175.64,127.3 175.53,127.2 174.58,127.2 174.42,127.37 173.51,127.37 173.13,127.75 173.13,127.93 173.3,128.09 173.46,128.09 173.48,128.08 173.5,128.07 173.81,127.91 174.11,128.07 174.13,128.08 174.15,128.09 174.69,128.09 174.72,128.11 175.43,128.11
+3V_GFX on BOTTOM (solid shape): 189.48,124.51 189.48,124.38 189.2,124.1 189.2,123.92 189.19,123.91 189.12,123.86 189.06,123.8 189.05,123.78 189.02,123.77 188.77,123.77 188.75,123.78 188.74,123.8 188.48,123.95 188.21,123.8 188.2,123.78 188.17,123.77 187.92,123.77 187.9,123.78 187.85,123.84 187.81,123.89 187.79,123.9 187.79,123.93 187.79,124.15 187.79,124.18 187.81,124.19 187.93,124.41 187.85,124.64 187.85,124.93 188.02,125.09 188.89,125.09
+3V_GFX on IN1 (solid shape): outline of 2754 points within 173.44,107.46 197.67,140.3
+3V_GFX on IN3 (solid shape): outline of 490 points within 173.54,105.05 190.81,114.19
+3V_LAN on TOP (solid shape): 47.81,67.84 47.81,65.55 47.77,65.52 47.76,65.51 47.67,65.44 47.59,65.34 47.59,65.33 47.3,65.04 45.9,65.04 45.78,65.17 45.78,66.19 46.41,66.82 46.41,67.02 46.41,67.02 46.41,67.97 46.54,68.09 47.55,68.09
+3V_LDO_EC on TOP (solid shape): 187.03,52.12 187.03,50.64 187.74,49.93 187.74,48.08 185.68,48.08 185.1,48.66 185.1,50.18 185.98,51.07 185.98,52.09 186.11,52.22 186.92,52.22
+3V_LDO_EC on BOTTOM (solid shape): 187.15,49.07 187.15,48.38 186.81,48.04 185.92,48.04 185.78,48.18 185.78,48.99 185.96,49.17 187.05,49.17
+3V_MAIN on BOTTOM (solid shape): 190.68,112.54 190.68,112.25 190.64,112.17 190.56,112.15 190.14,112 190.14,111.56 190.15,111.45 190.06,111.4 189.67,111.4 189.41,111.65 189.41,111.98 189.43,112.02 189.49,112.04 189.6,112.11 189.66,112.23 189.67,112.25 189.67,112.29 190.05,112.67 190.56,112.67
+3V_MAIN on BOTTOM (solid shape): 187.75,124.62 187.75,124.61 187.76,124.59 187.76,124.31 187.76,124.29 187.7,124.22 187.69,124.15 187.67,124.08 187.67,124.03 187.67,124.01 187.66,123.99 187.6,123.93 187.58,123.93 187.44,123.87 187.36,123.75 187.35,123.74 187.32,123.72 187.15,123.72 187.12,123.73 186.98,123.89 186.81,123.93 186.79,123.94 186.77,123.95 186.75,123.97 186.74,123.99 186.71,124.16 186.62,124.3 186.62,124.32 186.62,124.61 186.75,124.73 187.64,124.73
+3V_PCH_ME on TOP (solid shape): 182.94,57.04 182.94,56.91 183.01,56.75 183.17,56.68 183.26,56.68 183.31,56.67 184.13,55.85 184.13,54.4 184.66,53.87 185.48,53.87 185.73,53.61 185.73,51.2 185.48,50.95 183.7,50.95 183.57,51.07 183.57,52.22 183.44,52.34 183.11,52.34 182.94,52.52 182.94,54.44 182.68,54.7 182.68,55.26 182.3,55.65 182.05,55.65 181.79,55.9 181.79,56.79 182.17,57.17 182.81,57.17
+3V_RTC on TOP (solid shape): 76.13,49.42 76.13,43.96 77.02,43.07 77.02,42.69 76.76,42.44 76.26,42.44 74.35,44.34 74.35,48.05 74.7,48.05 74.7,48 74.71,47.94 74.73,47.89 74.76,47.84 74.79,47.8 74.83,47.76 74.88,47.73 74.93,47.7 74.98,47.68 75.04,47.67 75.09,47.67 75.15,47.68 75.2,47.69 75.25,47.71 75.3,47.74 75.34,47.78 75.38,47.82 75.41,47.86 75.44,47.91 75.45,47.97 75.46,48.02 75.46,48.08 75.45,48.13 75.44,48.19 75.41,48.24 75.38,48.28 75.34,48.33 75.3,48.36 75.25,48.39 75.2,48.41 75.15,48.43 75.09,48.43 75.04,48.43 74.98,48.42 74.93,48.4 74.88,48.38 74.83,48.34 74.79,48.31 74.76,48.26 74.73,48.21 74.71,48.16 74.7,48.11 74.7,48.05 74.35,48.05 74.35,48.79 75.24,49.68 75.88,49.68
+3V_RTC_2 on TOP (solid shape): 78.08,50.87 79.09,50.87 79.16,50.81 79.16,50.42 79.07,50.33 76.97,50.33 76.83,50.46 76.22,50.46 76.22,51.25 76.46,51.49 77.47,51.49
+3V_S5 on TOP (solid shape): 27.49,116.43 27.49,114.93 27.41,114.85 26.47,114.85 26.35,114.98 26.35,116.25 26.57,116.48 27.44,116.48
+3V_S5 on TOP (solid shape): 186.03,55.04 186.47,55.04 187.03,54.48 187.03,52.78 186.98,52.72 186.24,52.72 186.11,52.85 186.11,53.51 185.5,54.12 184.71,54.12 184.31,54.53 184.31,54.86 184.84,55.39 185.68,55.39
+3V_S5 on TOP (solid shape): 52,62.25 52,59.07 53.5,57.58 56.65,57.58 57.11,57.12 57.11,55.6 56.72,55.21 55.2,55.21 55,55.42 50.93,55.42 50.15,56.2 50.15,59.63 50.16,59.65 50.16,61.55 48.57,63.14 46.03,63.14 45.78,63.39 45.78,64.54 46.03,64.79 49.46,64.79
+3V_S5 on BOTTOM (solid shape): 164.01,64.92 164.01,63.77 163.89,63.65 162.87,63.65 162.76,63.76 162.76,64.15 162.74,64.16 162.74,64.79 163,65.04 163.89,65.04
+3V_S5 on BOTTOM (solid shape): 147.88,133.37 147.88,133.24 147.12,132.48 147.12,131.97 146.87,131.72 143.57,131.72 143.44,131.85 143.44,132.35 142.8,132.99 142.8,133.24 142.93,133.37 143.82,133.37 144.46,132.73 145.85,132.73 146.61,133.5 147.76,133.5
+3V_S5 on BOTTOM (solid shape): 140.26,39.9 140.26,39.26 136.45,35.45 136.45,18.13 135.98,17.66 135.98,17.65 135.83,17.5 135.83,15.15 135.69,15.01 134.76,15.01 134.68,15.09 134.68,16.17 134.55,16.3 134.55,36.09 138.61,40.15 140.01,40.15
+3V_S5 on BOTTOM (solid shape): 27.49,115.34 27.49,107.59 30.85,104.22 30.85,101.05 31.55,100.35 31.55,100.22 30.79,99.46 30.54,99.46 29.39,100.6 29.39,103.91 26.35,106.95 26.35,113.56 26.22,113.68 26.22,115.34 26.35,115.46 27.36,115.46
+3V_S5 on BOTTOM (solid shape): 53.65,57.58 57.49,57.58 57.77,57.3 57.77,56.2 58.15,55.82 58.15,55.21 58.07,55.14 58.03,55.14 58.03,55.15 57.38,55.15 57.38,55.14 57.28,55.14 57.07,55.35 58.03,55.35 58.03,55.55 57.38,55.55 57.38,55.35 57.07,55.35 56.95,55.47 50.98,55.47 50.25,56.2 50.25,57.93 50.45,58.14 53.09,58.14
+3V_S5 on BOTTOM (solid shape): 47.81,66.06 47.81,65.55 47.79,65.52 47.78,65.52 47.55,65.17 47.78,64.82 47.84,64.76 49.41,64.76 50.25,63.93 50.25,63.37 49.71,62.83 49,62.83 48.46,63.38 47.26,63.38 47.1,63.55 46.39,63.55 46.16,63.77 46.16,66.19 46.28,66.31 47.55,66.31
+3V_S5 on BOTTOM (solid shape): 183.5,55.6 185.02,55.6 185.73,54.88 185.73,54.42 185.11,54.22 184.57,53.87 183.44,53.87 182.05,55.26 176.59,55.26 173.06,51.73 172.04,51.73 172.01,51.71 169.73,51.71 169.61,51.59 169.58,51.57 169.56,51.57 169.24,51.5 169.09,51.2 169.09,51.07 168.84,50.82 167.96,50.82 167.8,50.82 167.8,50.82 167.23,50.82 167.18,50.82 167.13,50.82 166.81,50.82 166.81,50.72 166.66,50.57 165.45,50.57 165.45,51.45 165.89,51.9 168.06,51.9 169.9,53.74 172.25,53.74 172.7,53.78 172.8,54.22 172.78,54.25 174.94,56.41 182.68,56.41
+3V_S5 on IN2 (solid shape): outline of 3825 points within 49.97,37.48 171.38,64.66
+3V_WLAN on BOTTOM (solid shape): 203.16,190.52 203.19,190.51 203.21,190.48 203.47,190.16 203.88,190.27 203.9,190.27 203.93,190.27 204.11,190.15 204.33,190.15 204.35,190.14 204.38,190.12 204.9,189.81 205.05,190.41 205.08,190.49 205.15,190.52 206.05,190.52 206.18,190.39 206.18,187.47 205.92,187.22 204.91,187.22 203.26,188.87 203.12,188.87 203.11,188.87 202.92,188.92 202.74,188.87 202.24,188.87 202.11,189 202.11,190.27 202.37,190.52
+3VPCU on TOP (solid shape): 49.08,29.99 49.08,28.72 48.95,28.59 47.43,28.59 47.3,28.72 47.3,30.5 47.43,30.63 48.44,30.63
+3VPCU on TOP (solid shape): 70.67,16.15 70.67,14.31 70.64,14.28 69.68,14.28 69.53,14.43 69.53,16.15 69.65,16.28 70.54,16.28
+3VPCU on TOP (solid shape): 51.36,49.93 51.36,49.17 49.84,47.64 48.76,47.64 48.65,47.69 48.52,47.69 48.52,47.7 48.52,49.35 48.71,49.53 49.44,49.53 49.97,50.06 51.24,50.06
+3VPCU on TOP (solid shape): outline of 288 points within 167.95,95.9 178.11,102.46
+3VPCU on TOP (solid shape): outline of 478 points within 172.65,40.53 175.15,62.38
+3VPCU on BOTTOM (solid shape): 76.03,52.83 76.03,51.25 75.84,51.06 74.59,51.06 74.3,50.77 74.3,44.98 73.74,44.42 67.77,44.42 67.54,44.65 67.54,54.99 67.65,55.09 73.77,55.09
+3VPCU on BOTTOM (solid shape): 208.64,180.77 208.64,179.83 210.29,178.18 210.29,176.22 210.17,176.09 208.3,176.09 208.26,176.11 208.24,176.14 208.24,177.15 208.05,177.15 208.05,176.14 208.03,176.11 208,176.09 207.8,176.09 207.76,176.11 207.74,176.14 207.74,177.15 207.73,177.16 207.73,178.99 207.37,179.34 204.37,179.34 203.74,179.98 203.74,182.9 204.02,183.18 206.23,183.18
+3VPCU on BOTTOM (solid shape): 66.96,57.04 66.96,51.02 66.78,50.85 59.72,50.85 59.47,51.1 59.47,53.31 59.49,53.33 60.15,53.33 60.17,53.35 60.18,53.35 60.18,53.55 60.14,53.55 60.13,53.56 59.49,53.56 59.44,53.61 59.44,53.72 59.47,53.74 60.31,53.74 60.32,53.71 60.34,53.66 60.37,53.6 60.4,53.56 60.45,53.52 60.5,53.48 60.52,53.47 60.56,53.44 60.66,53.44 61.55,52.55 62.87,52.55 63.1,52.78 63.1,55.7 62.58,56.22 61.05,56.22 60.33,55.49 60.33,55.33 60.3,55.26 60.2,55.16 59.49,55.16 59.42,55.24 59.42,55.35 60.18,55.35 60.18,55.55 59.53,55.55 59.53,55.35 59.42,55.35 59.42,55.9 59.59,56.08 59.59,57.75 59.8,57.96 66.05,57.96
+3VPCU on IN2 (solid shape): 206.38,180.49 206.38,179.04 204.91,179.04 203.71,180.23 203.71,182.52 203.87,182.67 204.2,182.67
+3VPCU on IN2 (solid shape): 48.32,31.64 48.32,29.61 48.06,29.36 47.3,29.36 47.05,29.61 47.05,31.64 47.17,31.77 48.19,31.77
+3VPCU on IN2 (solid shape): outline of 1259 points within 169.35,60.98 176.87,97.56
+3VPCU on IN2 (solid shape): outline of 9087 points within 46.28,28.85 230.18,156.23
+3VPCU_EC on TOP (solid shape): 168.2,33.17 168.2,32.66 168.08,32.53 165.92,32.53 165.66,32.79 165.66,33.29 165.79,33.42 167.95,33.42
+3VPCU_EC on TOP (solid shape): outline of 183 points within 180.27,41.17 186.49,47.64
+3VPCU_EC on BOTTOM (solid shape): 168.96,33.27 168.96,32.86 168.72,32.62 168.65,32.62 168.64,32.62 167.06,32.62 166.9,32.78 166.9,33.26 167.06,33.41 167.07,33.41 167.27,33.61 168.63,33.61
+3VPCU_EC on BOTTOM (solid shape): 182.88,42.3 182.88,41.79 182.19,41.1 180.81,41.1 180.74,41.17 180.74,41.66 180.94,41.86 182.36,41.86 182.68,42.18 182.68,43.8 182.88,43.8
+3VPCU_EC on BOTTOM (solid shape): 189.01,32.15 189.29,32.15 189.43,32.16 189.51,32.08 189.51,31.32 189.62,31.21 189.62,30.92 189.32,30.62 189.05,30.62 188.79,30.88 188.74,30.92 188.68,30.96 188.34,31.3 186.48,31.3 186.48,31.5 187.98,31.5 188.1,31.5 188.75,32.16 188.98,32.16
+3VPCU_EC on BOTTOM (solid shape): 178.88,26.6 178.89,26.6 178.89,26.22 179.49,25.63 179.49,25.19 179.37,25.07 179.26,25.07 179.25,25.07 179.08,25.12 178.9,25.07 178.89,25.07 177.86,25.07 177.75,25.17 177.75,25.81 177.84,25.9 178.32,25.9 178.65,26.23 178.65,26.55 178.65,26.57 178.68,26.6 178.68,28.1 178.88,28.1
+3VPCU_EC on BOTTOM (solid shape): 170.39,42.46 170.39,41.75 170.38,41.73 170.38,40.72 170.49,40.61 170.49,40.1 170.69,39.9 172.28,39.9 172.28,39.7 170.78,39.7 170.77,39.69 169.88,39.69 169.77,39.81 169.77,39.95 169.69,40.79 169.45,41.6 169.45,41.61 169.45,41.91 169.47,41.93 169.47,42.44 169.6,42.56 170.29,42.56
+3VPCU_EC on BOTTOM (solid shape): 179.92,47.65 180.72,47.65 180.97,47.4 180.97,47.07 180.53,46.63 180.52,46.26 180.53,46.15 180.52,46.15 180.52,44.6 180.02,44.09 179.63,44.09 179.03,44.7 179.03,45.02 179.03,45.03 179.06,45.18 179.05,45.32 179.05,45.33 179.06,45.36 179.25,45.55 179.64,45.55 179.79,45.7 179.79,46.89 179.59,47.08 179.59,47.45 179.79,47.65
+3VPCU_EC on BOTTOM (solid shape): 185.62,48.24 185.62,48.09 185.81,47.9 187.14,47.9 187.17,47.87 187.17,47.17 187.08,47.09 186.72,47.09 186.49,46.86 186.49,46.12 186.11,45.74 185.6,45.74 185.29,46.06 185.29,46.23 185.29,46.26 185.31,46.28 185.54,46.77 185.14,47.13 185.07,47.21 185.07,48.13 185.22,48.28 185.58,48.28
+3VPCU_EC on IN3 (solid shape): outline of 130 points within 167.06,32.66 171.08,41.8
+3VPCU_ECPLL on BOTTOM (solid shape): 187.19,45.42 187.19,44.53 187.02,44.36 187,44.35 186.98,44.34 185.73,44.34 185.28,43.89 185.28,42.3 185.08,42.3 185.08,44.15 185.1,44.17 185.1,44.88 185.15,44.93 185.16,44.93 185.34,45.11 185.41,45.17 185.51,45.33 185.53,45.4 185.54,45.42 185.6,45.49 187.13,45.49
+5V on TOP (solid shape): 21.08,58.63 21.08,57.49 20.82,57.23 19.17,57.23 18.92,57.49 18.92,58.63 19.17,58.88 20.82,58.88
+5V on TOP (solid shape): 117.4,174.11 117.54,174.11 117.58,174.09 117.59,174.06 117.59,173.9 117.91,173.57 117.91,173.37 117.79,173.25 117.37,173.25 117.25,173.13 116.77,172.64 116.76,172.63 116.65,172.63 116.62,172.6 116.62,172.38 116.59,172.36 116.59,171.88 116.46,171.75 115.47,171.75 115.25,171.98 115.25,173.58 115.83,174.16 117.4,174.16
+5V on TOP (solid shape): outline of 289 points within 215.96,83.84 224.21,102.64
+5V on BOTTOM (solid shape): 219.51,47.85 219.51,44.83 219.33,44.65 217.33,44.65 216.97,45 216.97,47.31 215.75,48.53 215.04,48.53 213.87,49.7 213.87,51.25 214.28,51.66 215.7,51.66
+5V on BOTTOM (solid shape): 201.83,52.42 203.6,52.42 203.79,52.23 203.79,51.49 203.44,51.15 201.89,51.15 201.63,50.89 201.63,50.27 201.29,49.93 200.46,49.93 200.21,50.18 200.21,52.12 200.2,52.13 200.2,52.45 200.28,52.53 201.72,52.53
+5V on BOTTOM (solid shape): 63.02,20.06 63.02,18.31 62.82,18.1 62.29,18.1 61.75,17.57 59.39,17.57 58.68,16.86 55.96,16.86 55.68,17.14 55.68,19.7 55.7,19.72 62.91,19.72 62.91,19.92 62.26,19.92 62.26,19.72 55.7,19.72 56.01,20.04 59.01,20.04 59.21,19.83 61.9,19.83 62.19,20.12 62.96,20.12
+5V on BOTTOM (solid shape): 223.07,101.75 223.07,101.19 223.07,100.98 223.2,100.86 226.1,100.86 226.18,100.83 226.21,100.76 226.24,100.57 226.33,100.4 226.33,99.93 226.36,99.91 226.37,99.89 226.37,99.87 226.37,99.33 226.24,99.21 224.85,99.21 224.47,98.83 224.46,98.83 223.93,98.72 223.42,98.57 223.41,98.57 220.91,98.57 220.53,98.95 220.53,100.6 220.78,100.86 221.67,100.86 221.8,100.98 221.8,101.75 221.93,101.87 222.94,101.87
+5V on BOTTOM (solid shape): outline of 90 points within 210.46,30.63 214.05,37.22
+5V on SVCC (solid shape): outline of 336 points within 210.37,31.01 233.59,113.18
+5V on SVCC (solid shape): outline of 85 points within 17.71,2.03 88.47,65.55
+5V on IN2 (solid shape): 27.74,65.93 27.74,64.03 27.49,63.77 26.47,63.77 26.22,64.03 26.22,65.93 26.35,66.06 27.62,66.06
+5V on IN2 (solid shape): 60.37,119.77 60.37,118.75 60.24,118.63 57.45,118.63 56.94,119.13 56.94,119.9 57.07,120.02 60.11,120.02
+5V on IN2 (solid shape): 225.1,155.59 225.1,154.96 224.72,154.58 222.99,154.58 222.98,154.59 222.81,154.59 222.69,154.71 222.69,155.72 222.94,155.98 224.72,155.98
+5V on IN2 (solid shape): 120.71,175.03 120.71,173.63 120.45,173.37 116.9,173.37 116.77,173.5 116.77,173.99 118.81,173.99 118.82,173.94 118.83,173.89 118.85,173.84 118.87,173.79 118.91,173.75 118.95,173.71 118.99,173.68 119.04,173.65 119.09,173.63 119.14,173.63 119.2,173.62 119.25,173.63 119.3,173.64 119.35,173.66 119.4,173.69 119.44,173.73 119.47,173.77 119.5,173.81 119.53,173.86 119.54,173.91 119.55,173.97 119.55,174.02 119.54,174.07 119.53,174.12 119.5,174.17 119.47,174.22 119.44,174.26 119.4,174.29 119.35,174.32 119.3,174.34 119.25,174.36 119.2,174.36 119.14,174.36 119.09,174.35 119.04,174.33 118.99,174.31 118.95,174.28 118.91,174.24 118.87,174.2 118.85,174.15 118.83,174.1 118.82,174.05 118.81,173.99 116.77,173.99 116.77,174.36 116.78,174.37 116.78,174.39 117.66,175.27 117.68,175.27 117.69,175.28 120.45,175.28
+5V on IN2 (solid shape): outline of 6303 points within 82.21,10.56 219.39,51.2
+5V on IN3 (solid shape): 226.24,154.83 226.24,154.58 225.61,153.94 225.47,153.94 224.67,154.74 223.93,154.74 223.32,155.35 223.32,155.85 223.45,155.98 225.1,155.98
+5V on IN3 (solid shape): outline of 187 points within 226.9,109.11 232.09,129.94
+5V_HDD on BOTTOM (solid shape): 230.94,53.23 230.94,50.06 230.82,49.93 229.93,49.93 229.55,49.55 229.55,46.37 227.77,44.6 220.91,44.6 220.27,45.23 220.27,47.39 220.66,47.77 222.56,47.77 223.07,48.28 225.35,48.28 225.86,48.79 225.86,51.84 227.51,53.49 230.69,53.49
+5V_KB on BOTTOM (solid shape): 226.8,128.19 226.8,125.32 226.62,125.14 225.38,125.14 225.33,125.19 225.33,128.19 225.46,128.32 226.68,128.32
+5V_KB_R on BOTTOM (solid shape): outline of 114 points within 221.49,127.1 228.71,134.92
+5V_PVDD on BOTTOM (solid shape): 198.78,47.21 198.78,44.94 198.59,44.75 198.59,44.47 198.59,44.47 198.57,44.34 198.59,44.22 198.59,44.21 198.59,43.59 198.59,43.58 198.57,43.45 198.59,43.33 198.59,43.32 198.59,42.82 198.59,42.82 198.57,42.69 198.59,42.57 198.59,42.56 198.59,42.06 198.59,42.05 198.57,41.93 198.59,41.81 198.59,41.8 198.59,41.62 198.5,41.53 197.97,41.53 197.79,41.72 197.79,46.49 197.64,46.64 197.27,46.64 196.96,46.94 196.96,47.74 197.12,47.9 198.09,47.9
+5V_S5 on TOP (solid shape): outline of 142 points within 23.3,37.48 33.33,41.55
+5V_S5 on BOTTOM (solid shape): 149,164.31 149,162.94 148.82,162.76 148.01,162.76 147.88,162.88 147.88,164.61 148.11,164.84 148.47,164.84
+5V_S5 on BOTTOM (solid shape): 216.08,28.09 216.08,25.67 215.96,25.55 213.29,25.55 213.04,25.8 213.04,28.09 213.16,28.21 215.96,28.21
+5V_S5 on BOTTOM (solid shape): 201.99,65.91 201.99,65.04 201.89,64.94 200.95,64.94 200.95,65 199.89,65 199.85,65.04 199.85,66.03 199.95,66.14 201.76,66.14
+5V_S5 on BOTTOM (solid shape): 62.24,23.72 62.82,23.72 63.02,23.51 63.02,21.58 62.96,21.52 62.26,21.52 62.26,21.51 62.12,21.51 62.1,21.54 62.06,21.58 62.02,21.63 61.97,21.66 61.94,21.68 61.89,21.72 62.91,21.72 62.91,21.92 62.26,21.92 62.26,21.72 61.89,21.72 61.75,21.86 59.62,21.86 59.57,21.81 59.54,21.81 59.49,21.79 59.44,21.77 59.39,21.74 59.35,21.7 59.31,21.66 59.28,21.62 59.26,21.57 59.25,21.51 59.24,21.49 58.45,20.7 55.33,20.7 55.02,21 55.02,23.64 55.23,23.85 59.22,23.85 59.5,24.12 61.83,24.12
+5V_S5 on IN1 (solid shape): outline of 1027 points within 190.3,25.55 215.58,53.04
+5V_S5 on SVCC (solid shape): 45.65,94.3 45.65,80.16 45.69,79.96 45.8,79.8 46.28,79.31 46.28,55.48 42.96,52.15 42.59,52.05 42.49,51.68 42.12,51.31 42,51.14 41.97,50.94 41.97,46.66 41.84,46.37 41.97,46.09 41.97,36.86 42,36.66 42.12,36.49 54.05,24.55 54.22,24.44 54.42,24.4 58.27,24.4 59.62,23.05 59.62,21.54 59.52,21.28 59.62,21.02 59.62,20.93 59.16,20.47 45.79,20.47 45.09,20.77 44.35,20.58 32.4,32.53 32.31,32.66 32.19,32.74 31.04,33.89 31.04,70.11 31.07,70.25 31.04,70.39 31.04,70.88 31.07,71.01 31.04,71.15 31.04,92.9 34.94,96.79 43.15,96.79
+5V_S5 on IN2 (solid shape): outline of 141 points within 54.92,17.42 70.29,23.64
+5V_S5 on IN2 (solid shape): outline of 806 points within 109.78,25.93 164.65,28.59
+5V_S5 on IN2 (solid shape): outline of 820 points within 179.89,33.55 191.95,48.66
+5V_S5_V2 on TOP (solid shape): 36.63,110.13 36.63,107.97 37.52,107.08 37.52,105.05 38.28,104.29 38.28,102.81 38.6,102.5 38.6,99.78 38.58,99.76 38.55,99.71 38.53,99.66 38.52,99.6 38.52,99.55 38.52,99.49 38.53,99.44 38.55,99.38 38.58,99.33 38.6,99.31 38.6,98.13 38.54,98.06 36.12,98.06 36.01,98.18 38.4,98.18 38.4,98.83 38.2,98.83 38.2,98.18 36.01,98.18 36,98.19 36,101.26 35.62,101.65 35.62,102.38 34.85,103.14 34.85,104.41 34.6,104.67 34.6,107.21 34.06,107.75 33.17,107.75 33.08,107.84 33.08,107.93 33.1,107.95 33.13,107.96 33.77,107.96 33.77,108.25 33.13,108.25 33.1,108.26 33.08,108.28 33.08,108.43 33.1,108.45 33.13,108.46 33.77,108.46 33.77,108.75 33.13,108.75 33.1,108.76 33.08,108.78 33.08,108.93 33.1,108.95 33.13,108.96 33.77,108.96 33.77,109.25 33.15,109.25 33.12,109.26 33.11,109.28 33.1,109.39 33.17,109.46 34.18,109.46 34.98,110.26 36.51,110.26
+5VA on TOP (solid shape): 209.19,34.6 209.19,34.58 209.21,34.12 209.65,34.01 209.71,33.97 209.73,33.91 209.73,33.17 207.45,30.88 205.93,30.88 205.89,30.9 205.88,30.91 205.78,30.99 205.66,31.04 205.63,31.05 205.61,31.08 205.61,33.1 205.67,33.17 205.69,33.17 205.94,33.28 206.05,33.53 206.05,33.55 207.19,34.69 209.1,34.69
+5VA on BOTTOM (solid shape): 206.69,32.91 206.69,32.4 206.94,32.15 209.61,32.15 209.73,32.02 209.73,30.75 209.48,30.5 207.57,30.5 207.19,30.88 205.93,30.88 205.89,30.9 205.88,30.91 205.78,30.99 205.66,31.04 205.59,31.06 205.51,31.06 205.49,31.07 205.29,31.26 205.29,32.79 205.54,33.04 206.56,33.04
+5VA on BOTTOM (solid shape): 209.23,38.25 209.23,36.85 209.25,36.83 209.25,36.81 209.31,36.67 209.46,36.6 209.48,36.6 209.86,36.21 209.86,34.76 209.83,34.68 209.75,34.66 209.12,34.36 209.75,34.07 209.83,34.04 209.86,33.96 209.86,33.8 209.61,33.55 207.83,33.55 207.32,34.06 207.32,34.62 207.65,34.94 207.96,34.94 208.08,35.07 208.08,35.67 208.1,35.71 208.1,35.71 208.2,35.96 208.1,36.21 208.1,36.21 208.08,36.25 208.08,38.25 208.34,38.5 208.97,38.5
+5VODD on BOTTOM (solid shape): outline of 155 points within 226.15,102.25 234.5,111.14
+5VPCU on TOP (solid shape): 38.6,96.73 38.6,96.03 38.64,96.02 38.66,96.01 38.66,95.98 38.66,95.49 38.64,95.48 38.58,95.46 38.53,95.43 38.49,95.39 38.45,95.35 38.42,95.3 38.4,95.25 38.38,95.19 38.37,95.13 38.37,95.11 38.03,94.76 37.65,94.76 37.27,94.38 37.27,90.95 37.01,90.7 34.47,90.7 34.09,91.08 34.09,94.36 34.73,94.99 34.73,96.03 38.4,96.03 38.4,96.68 38.2,96.68 38.2,96.03 34.73,96.03 34.73,96.16 35.24,96.67 36.38,96.67 36.51,96.79 38.54,96.79
+5VPCU on TOP (solid shape): 19.9,29.48 20.37,29.48 20.69,29.17 20.82,29.17 21.01,28.98 21.01,27.2 20.5,26.69 19.23,26.69 19.17,26.76 19.17,27.15 19.17,28.28 19.11,28.33 19.11,28.34 19.07,28.38 19.04,28.46 19.07,28.53 19.21,28.86 19.02,29.15 19.01,29.16 18.98,29.2 18.98,29.86 19.11,29.99 19.39,29.99
+5VPCU on BOTTOM (solid shape): outline of 2289 points within 18.98,10.81 76.71,38.6
+5VPCU on IN2 (solid shape): outline of 2925 points within 31.22,32.4 42.73,93.36
+A3VPCU on BOTTOM (solid shape): 172.28,32.5 170.78,32.5 170.71,32.5 170.47,32.26 170.47,31.49 170.24,31.26 169.72,31.26 169.47,31.5 168.59,31.5 168.4,31.69 168.4,31.7 168.36,31.8 168.31,31.88 168.3,31.89 168.29,31.91 168.29,32.33 168.4,32.43 168.42,32.45 168.44,32.45 170.27,32.45 170.52,32.7 170.78,32.7 172.28,32.7
+VCCCORE on TOP (solid shape): outline of 2931 points within 112.67,106.94 146.61,150
+VCCCORE on BOTTOM (solid shape): outline of 341 points within 117.66,106.8 122.87,109.84
+VCCCORE on BOTTOM (solid shape): outline of 2327 points within 112.83,116.99 147.1,149.91
+VCCCORE on IN1 (solid shape): outline of 647 points within 112.55,106.69 123.03,119
+VCCCORE on SVCC (solid shape): outline of 379 points within 111.18,106.83 142.55,149.63
+VCCCORE on IN2 (solid shape): outline of 995 points within 114.84,132.51 142.42,146.12
+VCCEOPIO on BOTTOM (solid shape): 72.83,98.06 72.83,97.05 72.07,96.29 69.4,96.29 69.27,96.41 69.27,98.06 69.91,98.7 72.19,98.7
+VCCEOPIO on BOTTOM (solid shape): 107.49,110.25 107.49,109.23 107.24,108.99 106.1,108.99 105.63,109.45 105.63,110.1 105.67,110.14 105.67,110.37 105.63,110.4 105.63,110.88 105.76,111 106.74,111
+VCCEOPIO on IN2 (solid shape): outline of 2768 points within 69.65,96.55 108.51,110.97
+VCCGT on TOP (solid shape): outline of 8640 points within 87.81,100.1 115.17,150.01
+VCCGT on BOTTOM (solid shape): outline of 147 points within 108.26,134.51 133.91,151.2
+VCCGT on BOTTOM (solid shape): outline of 2068 points within 83.37,106.84 117.28,124.35
+VCCGT on IN1 (solid shape): outline of 153 points within 107.16,108.1 115.37,119.51
+VCCGT on SVCC (solid shape): outline of 82 points within 76.76,107.46 114.99,147.59
+VCCGT on IN2 (solid shape): outline of 392 points within 102.55,108.27 114.99,119.65
+VCCGT on IN2 (solid shape): outline of 394 points within 88.07,114.12 98.89,122.5
