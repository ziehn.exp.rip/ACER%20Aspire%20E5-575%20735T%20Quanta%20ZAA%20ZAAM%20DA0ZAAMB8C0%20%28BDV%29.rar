# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.5V: length 482.3
  TOP w0.508: v1(155.91,88.92) 155.98,88.99 R683.2 ; R712.1 C759.2 204.26,187.72 v1(203.94,187.4)
  TOP w0.762: v1(193.22,43.58) 193.22,44.93 192.41,45.74 192.41,49.35 ; 192.51,50.11 192.97,50.57 197.2,50.57 199.5,52.86 207.31,52.86 208.97,51.2 v1(208.97,49.3) 209.35,49.3 211.51,51.45 211.51,58.8 217.28,64.56 217.28,69.44 216.9,69.82 216.9,76.65 221.54,81.3 v1(221.54,82.06) ; v1(155.78,71.19) 156.82,71.19 157.77,70.25 163.7,70.25 165.98,67.96 172.93,67.96 175.39,65.5 181.67,65.5 188.02,59.15 188.02,58.18 189.46,56.74 189.46,54.06 189.99,53.54 190.62,53.54 190.62,53.54 191.62,53.54 192.11,53.06 192.11,52.5 190.89,51.28 190.89,50.62
  TOP w1.016: 159.35,65.51 159.35,52.51 159.22,52.37 159.22,44.5 158.77,44.05 158.77,40.49 157.79,39.52 157.79,38.63 155.89,36.72 154.37,36.72 149.04,31.39 125.79,31.39 120.2,25.8 114.69,25.8 112.76,23.87 112.76,19.17 111.74,18.16 108.54,18.16 107.68,19.02 107.68,22.32 107.22,22.78 107.22,24.05 ; 155.93,67.71 155.5,67.71 154.74,68.47 154.74,70.17 155.76,71.19 v1(155.78,71.19)
  IN1 w0.762: v1(203.94,187.4) 203.94,185.19 205.24,183.88 205.24,179.76 205.01,179.52 205.01,174.92 207.6,172.33 207.6,160.04 208.71,158.93 224.1,158.93 227.86,155.18 227.86,134.85 229.39,133.32 229.39,120.66 230.18,119.87 230.18,116.47 229.8,116.09 229.8,114.32 230.16,113.96 230.16,104.14 228.28,102.25 225.78,102.25 218.52,95 218.52,88.39 220.02,86.89 220.02,83.71 221.54,82.19 v1(221.54,82.06)
  IN2 w0.508: v1(155.78,71.19) 155.78,71.22 156.52,71.96 156.52,73.81 155.76,74.57 155.76,80.28 156.39,80.92 156.39,84.86 155.91,85.34 v1(155.91,88.92)
  IN2 w1.016: 105.57,25.01 80.17,25.01 77.65,22.5 74.66,22.5 66.27,14.12 57.05,14.12 53.75,17.42 44.25,17.42 39.55,22.12 39.55,25.8 32.92,32.43 32.92,36.24 30.82,38.35 30.82,41.57 33.2,43.96 33.2,47.77
  BOTTOM w0.381: v1(190.63,49.93) 190.56,50.01 190.56,51.33
  BOTTOM w0.508: v1(203.94,187.4) 203.03,187.4 v1(202.98,187.34) ; L18.2 196.18,40.9 195.5,41.58 C541.2 194.87,41.93 v1(193.22,43.58) ; R366.2 v1(208.97,49.3)
  BOTTOM w0.762: v1(203.94,187.4) 203.94,186.66 204.27,186.33 Q38.1
  vias: v1(106.84,24.98) v1(107.47,24.98) v2(33.33,49.6) v2(33.33,48.84)
+1.05V_GFX: length 14.5
  TOP w0.508: L4201.1 168.2,122.45 v1(167.82,122.07) ; v1(173.01,124.15) 173.09,124.23 L4200.1 ; C4005.1 164.81,121.03 v1(164.67,121.18)
  BOTTOM w0.381: 207.63,163.95 206.03,165.55 206.03,169.8 204.66,171.17 204.2,171.17 203.16,172.21 PR311.2
  vias: v1(161.47,146.2) v1(161.47,145.56) v1(169.07,133.42) v1(172.15,139.95) v1(172.45,149.14) v1(173,139.94) v1(173.03,139.11) v1(173.03,138.26) v1(173.82,139.12) v1(173.83,138.26) v1(173.82,136.62) v1(173.83,135.76) v1(173.83,134.13) v1(173.84,133.26) v1(173.82,131.59) v1(173.84,130.77) v1(174.81,129.18) v1(175.44,129.43) v2(209.05,164.56) v2(209.89,164.54) v2(210.72,164.54) v2(211.66,164.54)
+1.5VA: length 6.8
  BOTTOM w0.203: U23.40 200.68,41.18 200.54,41.04
  BOTTOM w0.508: 200.54,41.04 200.13,41.04 199.62,40.53 198.94,40.53 198.56,40.15 v1(198.56,40.02) 198.56,39.27 C520.1 C524.1 197.38,39.18 L18.1
+1.8V_PRIM: length 16.5
  IN2 w0.508: v1(104.7,119.4) 103.94,120.16 103.43,120.16 101.02,122.57 99.24,122.57 98.74,123.08 v1(98.74,123.46)
  BOTTOM w0.254: U35.G61 105.68,119.69 105.18,119.19 U35.H63 105,119.1 v1(104.7,119.4)
  BOTTOM w0.508: R565.1 96.8,129.19 97.35,128.64 C687.1 C686.1 97.47,127.41 97.47,126.77 98.74,125.5 v1(98.74,123.46)
+1.8V_S5: length 142
  TOP w0.508: v1(141.41,123.59) 141.03,123.59 140.52,123.08 v1(140.52,122.22) R775.1 ; R765.2 151.7,110 151.8,110 151.81,109.99 v1(151.81,109.98) ; R180.2 143.64,112.76 R192.2 142.93,113.3 v1(143.57,113.94)
  IN1 w0.508: v1(151.81,109.98) 151.81,109.99 151.8,110 150.93,110 150.3,109.37 v1(149.66,109.37)
  IN2 w0.508: v1(157.28,74.95) 157.03,75.2 157.03,85.36 156.65,85.74 156.65,89.3 155.89,90.06 155.89,91.33 157.54,92.98 157.54,99.46 156.27,100.73 156.27,106.06 155.63,106.7 155.63,110.64 155,111.27 153.1,111.27 v1(151.81,109.98) ; v1(147.63,108.22) v1(147.63,107.08) v1(147.63,105.94) v1(147.63,104.79) ; v1(147.63,108.22) 146.49,109.37 146.49,110.64 143.57,113.56 v1(143.57,113.94) 143.57,114.95 144.2,115.59 144.2,118.89 142.17,120.92 142.17,122.83 v1(141.41,123.59) 141.92,123.59 142.5,124.18 142.5,125.93 140.37,128.06 130.33,128.06 127.82,130.58 119.44,130.58 115.12,134.89 110.93,134.89 110.29,134.26 110.29,132.73 108.36,130.8 104.29,130.8 102.17,128.68 95.71,128.68 v1(95.6,128.57) ; v1(147.63,108.22) 148.01,108.22 149.15,109.37 v1(149.66,109.37)
  BOTTOM w0.508: R615.2 v1(147.63,104.79) R611.2 ; R565.2 v1(95.6,128.57) ; R767.2 v1(147.63,105.94) R613.2 ; R590.2 v1(147.63,108.22) R600.2 ; R607.2 v1(149.66,109.37) ; v1(151.81,109.98) 151.8,109.99 151.55,109.99 151.07,109.5 R593.2 ; R608.2 v1(147.63,107.08) R599.2 ; v1(157.28,74.95) 157.67,74.56 PR1249.2
+1.35V_GFX: length 368.2
  TOP w0.305: VRAM3007.H12 v3(214.18,118.44) ; v3(212.59,125.63) VRAM3007.K3 ; v3(179.29,159.39) VRAM3001.G2 ; v3(206.94,116.82) 206.97,116.82 VRAM3007.T14 ; VRAM3007.P14 v3(208.57,116.82) ; VRAM3007.N10 209.39,120.04 v3(209.39,120.03) ; VRAM3007.R10 207.79,120.04 v3(207.79,120.03) ; VRAM3007.M1 210.58,128.05 v3(210.7,128.16) ; VRAM3004.L14 200.11,160.2 v3(200.11,160.22) ; v3(216.24,123.84) 216.18,123.9 VRAM3007.E5 ; VRAM3001.L1 179.81,162.86 v3(180.25,162.86) ; v3(209.4,136.98) 209.38,136.98 VRAM3002.D1 ; v3(209.01,128.18) 208.98,128.15 VRAM3007.P1 ; v3(216.33,143.91) 216.2,144.04 VRAM3002.N10 ; VRAM3007.L1 211.38,127.97 v3(211.57,128.15) ; VRAM3007.T1 207.38,128.05 v3(207.52,128.19) ; VRAM3001.P11 171.69,165.39 v3(172.09,165.79) ; VRAM3007.G14 v3(214.98,116.84) ; VRAM3001.K12 170.52,162.56 v3(170.52,162.58) ; v3(180.29,165.43) 179.73,165.43 VRAM3001.P1 ; VRAM3007.M14 210.19,116.84 v3(210.19,116.82) ; v3(178.49,158.59) VRAM3001.F3 ; VRAM3001.D3 178.09,157.39 v3(178.49,157.79) ; VRAM3002.G1 211.78,136.98 v3(211.8,136.98) ; VRAM3001.P12 170.89,165.39 v3(171.29,165.79) ; VRAM3001.E5 176.43,158.19 v3(176.04,158.58) ; v3(198.53,160.21) 198.13,160.61 VRAM3004.K12 ; VRAM3002.K3 213.4,139.35 v3(213.4,139.36) ; VRAM3007.C5 218.2,124.02 v3(218.23,124.02) ; v3(171.31,163.37) 171.69,162.99 VRAM3001.L11 ; v3(196.91,158.59) VRAM3004.N10 ; v3(168.89,156.98) 168.89,157.02 169.26,157.39 VRAM3001.D14 ; VRAM3007.F3 215.04,126.38 v3(214.98,126.38) ; VRAM3001.T14 169.26,167.02 v3(168.73,167.02) ; v3(215,119.25) 214.97,119.25 VRAM3007.G11 ; VRAM3001.T12 170.51,167.37 v3(170.51,167.37) ; VRAM3004.P14 v3(200.11,157.8) ; VRAM3004.B14 199.88,167.17 v3(200.31,167.17) ; VRAM3004.F3 190.56,164.19 v3(190.56,164.23) ; v3(199.33,163.43) 199.33,163.41 VRAM3004.G14 ; VRAM3001.D12 171.29,156.99 v3(171.29,156.99) ; VRAM3004.P1 188.71,157.42 v3(188.68,157.38) ; v3(197.74,164.22) 197.74,164.2 VRAM3004.F12 ; v3(211.8,147.36) VRAM3002.G13 ; v3(188.79,167.07) 188.84,167.02 VRAM3004.B1 ; VRAM3007.D12 217.36,119.22 v3(217.38,119.22) ; v3(171.29,160.19) 170.89,160.59 VRAM3001.H12 ; v3(211,147.36) 211,147.36 VRAM3002.G14 ; v3(209.4,138.56) 209.39,138.56 VRAM3002.D3 ; VRAM3002.F3 210.2,138.56 v3(210.2,138.56) ; v3(168.89,159.36) 168.92,159.36 VRAM3001.F14 ; v3(207.8,140.16) VRAM3002.C5 ; VRAM3001.D11 172.09,156.99 v3(172.09,156.99) ; VRAM3007.P11 208.59,119.24 v3(208.59,119.23) ; v3(172.88,165) 172.49,164.6 VRAM3001.N10 ; VRAM3001.G11 171.69,159.79 v3(172.09,159.39) ; v3(209.4,146.56) VRAM3002.D12 ; v3(191.29,158.62) 191.29,158.65 VRAM3004.M3 ; VRAM3001.T3 177.7,167.38 v3(177.69,167.38) ; v3(200.23,156.18) 200.09,156.18 VRAM3004.T14 ; v3(170.54,159.39) 170.49,159.39 VRAM3001.G13 ; VRAM3002.E5 209.8,140.62 v3(210.14,140.97) ; v3(180.25,167.12) 180.12,166.99 VRAM3001.T1 ; v3(206.95,148.17) 206.98,148.17 VRAM3002.B14 ; v3(217,136.76) 217,136.77 VRAM3002.P1 ; v3(170.49,155.39) VRAM3001.B12 ; v3(180.06,160.19) 180.06,160.16 VRAM3001.G1 ; VRAM3007.L14 211.05,116.91 v3(211.05,116.81) ; VRAM3002.K12 213.81,146.16 v3(214.18,146.53) ; VRAM3007.P3 208.59,125.64 v3(208.59,125.63) ; v3(215.8,140.16) 215.8,140.16 VRAM3002.N5 ; VRAM3004.M1 188.79,159.02 v3(188.79,159.02) ; v1(168.74,165.29) 168.84,165.39 VRAM3001.P14 ; v3(190.53,160.21) VRAM3004.L2 ; v3(210.21,144.16) 210.19,144.16 VRAM3002.E10 ; v3(169.74,159.39) 169.69,159.39 VRAM3001.G14 ; VRAM3007.D14 216.59,116.84 v3(216.56,116.84) ; VRAM3002.H12 211.8,145.76 v3(211.8,145.76) VRAM3002.G11 ; VRAM3001.M14 169,163.79 v3(168.75,163.55) ; v3(211.77,124.84) 211.77,124.85 VRAM3007.L4 ; v3(197.74,155.46) 197.77,155.46 VRAM3004.T12 ; v3(197.73,166.62) VRAM3004.B12 ; v3(190.53,166.62) 190.93,167.02 VRAM3004.B3 ; v3(217.39,125.63) VRAM3007.D3 ; v3(176.08,164.2) 176.1,164.2 VRAM3001.N5 ; v3(208.59,118.41) 208.59,118.44 VRAM3007.P12 ; VRAM3002.L11 214.58,145.36 v3(214.18,144.96) ; v3(218.7,136.76) 218.7,137.25 VRAM3002.T1 ; v3(168.75,162.68) 168.98,162.68 VRAM3001.L14 ; VRAM3002.P3 217.4,139.36 v3(217.4,139.36) ; v3(171.34,158.59) 171.29,158.59 VRAM3001.F12 ; v3(206.99,118.43) 206.99,118.44 VRAM3007.T12 ; VRAM3007.G2 v3(214.97,127.22) ; v3(218.18,140.97) 218.18,140.94 VRAM3002.R5 ; v3(197.73,165.82) VRAM3004.D12 ; VRAM3007.D1 216.98,127.97 v3(216.77,128.19) ; v1(193.09,164.69) 193.02,164.62 VRAM3004.E5 ; VRAM3002.G4 211,140.15 v3(211,140.16) ; v3(196.93,165.82) VRAM3004.D11 ; v3(191.34,162.63) VRAM3004.H3 ; v3(208.58,148.18) 208.58,148.17 VRAM3002.D14 ; VRAM3002.F1 211,136.95 v3(211,136.93) ; VRAM3004.G13 198.56,163.39 v3(198.56,163.43) ; v3(198.5,162.59) VRAM3004.H12 ; VRAM3002.M14 215.15,148.01 v3(215.15,148.31) ; VRAM3002.B3 207.79,138.56 v3(207.8,138.56) ; VRAM3002.T12 218.2,145.76 v3(218.2,145.76) ; VRAM3001.D1 180.06,157.76 v3(180.06,157.79) ; VRAM3002.B12 207.79,145.76 v3(207.8,145.76) ; VRAM3007.R5 207.79,124.04 v3(207.79,123.97) ; v3(216.97,148.31) 217,148.29 VRAM3002.P14 ; VRAM3001.C10 172.86,156.97 v3(172.89,156.97) ; VRAM3001.L13 169.71,163.37 v3(169.67,163.37) ; VRAM3004.L4 191.73,159.81 v3(192.13,159.4) ; VRAM3002.T14 218.6,148.27 v3(218.65,148.32) ; v1(214.18,147.34) 214.21,147.34 VRAM3002.L13 ; v3(180.34,163.71) 180.26,163.79 VRAM3001.M1 ; v3(214.32,136.65) 214.6,136.92 VRAM3002.L1 VRAM3002.L2 ; VRAM3002.M12 215,145.77 v3(214.98,145.77) ; v3(215.01,147.34) VRAM3002.L14 ; VRAM3001.L2 v1(178.49,162.59) ; VRAM3002.F14 211.01,148.17 v3(211.01,148.19) ; v3(191.33,161.01) VRAM3004.K3 ; VRAM3007.B12 218.2,119.22 v3(218.18,119.22) ; VRAM3004.M14 v3(200.15,159.43) ; v3(218.2,138.56) 218.2,138.56 VRAM3002.T3 ; VRAM3007.B1 218.66,127.71 v3(218.66,128.24) ; v3(196.91,156.99) VRAM3004.R10 ; v3(217.38,120.03) VRAM3007.D11 ; VRAM3007.F14 v3(215.78,117.63) ; VRAM3002.C10 208.58,144.17 v3(208.58,144.16) ; v3(211.8,137.76) 211.79,137.76 VRAM3002.G2 ; v3(177.69,165.79) VRAM3001.P3 ; v3(210.99,119.23) 210.99,119.24 VRAM3007.L11 ; VRAM3004.G11 197.7,163.38 v3(197.72,163.38) ; VRAM3007.G13 v3(214.98,117.64) ; VRAM3007.H3 213.39,125.64 v3(213.39,125.63) ; VRAM3001.R5 176.11,166.57 v3(176.08,166.57) ; VRAM3001.F1 180.06,159.36 v3(180.06,159.39) ; v3(192.99,158.56) 192.64,158.22 VRAM3004.N5 ; v1(198.52,158.63) VRAM3004.M12 ; VRAM3004.T1 189,155.82 v3(188.73,155.54) ; VRAM3007.L13 v3(210.98,117.63) ; VRAM3004.L11 197.73,159.41 v3(197.77,159.41) ; VRAM3002.L4 215,140.16 v3(215,140.16) ; v3(218.19,126.43) 218.58,126.04 VRAM3007.B3 ; VRAM3007.B14 v3(218.19,116.84) ; VRAM3004.D14 200.24,165.42 v3(200.3,165.48) ; VRAM3007.F12 v3(215.78,118.44) ; v3(210.98,126.44) VRAM3007.L2 ; VRAM3007.F1 215.24,127.78 v3(215.24,128.24) ; v3(216.6,120.84) 216.59,120.84 VRAM3007.E10 ; v3(172.88,166.57) 172.5,166.19 VRAM3001.R10 ; v3(178.49,156.19) 178.09,155.79 VRAM3001.B3 178.09,155.79 v3(177.69,156.19) ; VRAM3001.M3 177.69,163.4 v3(177.69,163.39) 177.69,163.39 VRAM3001.L4 ; VRAM3004.G2 189.77,162.66 v3(189.74,162.66) ; v3(168.9,155.37) 168.9,155.4 VRAM3001.B14 ; v3(218.18,144.17) 218.18,144.17 VRAM3002.R10 ; VRAM3004.C5 v3(193.25,166.22) ; VRAM3004.L13 199.33,159.42 v3(199.33,159.41) ; v3(215.8,139.36) 215.8,139.36 VRAM3002.M3 ; v3(180.06,156.19) 180.06,156.16 VRAM3001.B1 ; v3(176.89,159.39) VRAM3001.G4 ; VRAM3004.C10 v3(196.15,166.6) ; v3(178.51,160.19) 178.48,160.19 VRAM3001.H3 ; VRAM3004.P11 197.71,157.03 v3(197.74,157.03) VRAM3004.P12 ; VRAM3004.E10 v3(196.15,165) ; v1(170.53,163.39) 170.53,163.43 VRAM3001.M12 ; VRAM3004.F1 188.85,163.82 v3(188.72,163.69) ; v3(207.77,136.98) VRAM3002.B1 ; VRAM3007.M12 210.19,118.44 v3(210.19,118.43) ; VRAM3007.M3 210.59,126.04 v3(211,125.62) ; VRAM3002.H3 212.6,139.36 v3(212.6,139.36) ; v3(191.33,165.82) VRAM3004.D3 ; v3(215.32,136.71) 215.4,136.78 VRAM3002.M1 ; VRAM3007.K12 v3(211.77,118.42) ; VRAM3007.N5 210.17,124.05 v3(210.17,123.99) ; v3(217.4,144.96) 217.39,144.96 VRAM3002.P11 ; VRAM3004.D1 188.87,165.42 v3(188.77,165.31) ; v3(190.53,155.41) VRAM3004.T3 ; VRAM3004.R5 192.53,156.56 v3(192.89,156.2) ; v3(192.11,162.64) VRAM3004.G4 ; v3(217.4,145.76) 217.39,145.76 VRAM3002.P12 ; v3(176.89,156.19) VRAM3001.C5 ; v3(209.4,145.76) VRAM3002.D11 ; VRAM3004.P3 190.56,157.04 v3(190.56,156.99) ; VRAM3007.G1 214.61,127.66 v3(214.61,128.23) ; v3(218.11,120.87) 218.11,120.77 VRAM3007.C10 ; VRAM3007.T3 206.99,125.64 v3(206.99,125.63) ; v3(200.12,163.43) VRAM3004.F14 ; VRAM3007.G4 v3(214.2,125.62) ; VRAM3001.E10 v3(172.89,158.59) ; VRAM3004.G1 v3(188.73,163.02) ; v3(211,146.56) VRAM3002.F12 ; v3(178.49,161.79) VRAM3001.K3 ; v3(188.95,160.2) VRAM3004.L1
  TOP w0.508: C4672.2 v1(211.9,132.62) C4678.1 ; v1(209.1,114.32) 209.1,113.95 C4709.1 ; R11101.1 v1(216.21,112.29) ; C4527.2 v1(184.84,159.41) C4522.2 ; C4697.2 v1(217.99,150.34) ; C4680.1 v1(221.93,140.48) ; v1(202.29,159.66) C4526.2 ; C4536.1 v1(184.84,161.45) C4531.1 ; v1(209.86,150.59) C4676.2 ; C4708.1 220.99,131.97 220.76,132.2 v1(220.76,132.63) 220.76,133.07 221.06,133.37 C4670.1 ; v1(189.67,172.59) 189.7,172.59 R4538.2 R4516.1 ; C4533.1 v1(189.03,170.58) ; C4667.1 v1(207.84,132.62) C4696.1 ; C4544.1 v1(169.35,170.45) ; R11086.2 223.73,129.05 224.08,128.7 v1(224.08,128.57) ; C4707.1 v1(222.05,126) ; C4542.1 165.88,162.45 v1(166.3,162.45) ; C4675.2 v1(222.05,119.15) ; C4690.2 v1(219.25,132.62) C4679.2 ; C4693.2 v1(209.87,132.62) C4703.2 ; v1(184.84,164.26) 185.22,164.26 185.48,164 R4551.1 ; R11071.1 223.45,137.43 224.01,136.88 v1(224.01,136.57) ; C4699.1 v1(219.39,114.32) ; v1(221.93,136.47) 221.98,136.42 C4685.1 ; C4702.1 v1(215.19,132.62) C4700.1 ; R4514.1 v1(204.55,161.69) ; C4514.1 v1(184.84,157.38) C4518.2 ; R11072.2 223.33,139.47 v1(223.83,139.97) ; C4541.1 v1(184.84,167.02) C4546.1 ; C4529.1 v1(164.22,159.4) ; C4706.1 221.8,135.02 v1(221.06,134.28) ; C4539.1 v1(170.49,170.45) ; C4673.1 222.31,130.07 v1(222.05,130.32) ; v1(202.49,167.02) 202.62,166.9 C4107.2 ; C4694.1 v1(222.05,117.11) ; R4557.1 183.06,172.49 v1(183.06,172.74) ; C4682.1 v1(222.05,118.13) ; C4551.1 v1(184.84,164.98) C4555.1 ; C4668.2 v1(220.02,151.27) ; v1(202.29,158.64) C4521.2 ; C4691.2 208.21,114.19 v1(208.34,114.32) 207.45,114.32 205.67,116.1 200.72,116.1 v1(198.3,113.68) ; C4681.1 v1(217.22,132.62) C4677.1 ; C4540.1 v1(201.48,170.83) ; R11096.1 214.08,131.97 214.53,132.43 v1(214.53,132.61) ; R11074.1 v1(224.08,120.16) ; R4520.1 v1(171.63,172.61) ; R4518.1 v1(164.27,167.53) ; C4537.1 198.59,171.25 v1(198.18,170.83) ; C4545.1 v1(202.49,168.93) ; C4519.2 v1(168.2,170.45) ; C4534.1 v1(164.22,160.55) ; C4517.2 184.71,169.05 v1(184.84,169.17) 184.97,169.05 C4513.2 ; C4530.1 v1(202.49,167.91) ; R4541.2 v1(176.71,172.61) ; C4692.2 v1(221.93,147.72) ; C4554.1 v1(185.6,170.58) ; C4698.1 v1(222.05,127.02) ; R11104.1 v1(223.96,144.55) ; v1(205.63,132.57) C4119.2 ; R11099.1 v1(214.94,152.8) ; C4524.2 v1(177.98,170.45) ; C4684.2 v1(222.05,116.1) ; C4549.1 v1(182.05,170.58) ; C4550.1 v1(200.34,170.83) ; C4552.1 v1(204.55,160.67) ; C4671.1 v1(221.93,141.5)
  IN2 w0.381: v1(223.88,164.79) 224.06,164.97 224.06,177.03 v1(222.84,178.25)
  BOTTOM w0.203: v1(183.69,146.98) 183.62,146.92 183.62,145.49 U3002.T33 ; U3002.W33 181.11,145.47 v1(181.11,146.81) ; U3002.AB33 178.35,145.47 178.35,146.69 v3(178.49,146.84)
  BOTTOM w0.254: v1(196.57,131.08) 195.24,131.08 U3002.B16 ; v1(196.72,133.7) 196.57,133.85 195.29,133.85 U3002.B19
  BOTTOM w0.305: VRAM3007.B1 218.66,127.71 v3(218.66,128.24) ; v3(172.88,165) 172.52,164.63 172.49,164.6 VRAM3001.N10 ; v3(190.56,164.23) 190.56,164.19 VRAM3004.F3 ; VRAM3007.H12 v3(214.18,118.44) ; VRAM3007.L4 211.77,124.85 v3(211.77,124.84) ; VRAM3001.M12 170.53,163.43 v1(170.53,163.39) ; v3(216.97,148.31) 217,148.29 VRAM3002.P14 ; v1(192.33,130.78) 192.33,130.8 U3002.E16 ; VRAM3004.P1 188.72,157.42 188.68,157.37 v3(188.68,157.38) ; VRAM3004.L14 200.11,160.2 v3(200.11,160.22) ; U3002.E13 192.33,129.08 v1(192.33,129.15) ; VRAM3004.N5 192.64,158.22 v3(192.99,158.56) ; VRAM3002.C10 208.2,144.55 208.58,144.17 v3(208.58,144.16) ; v3(218.11,120.87) 218.11,120.77 VRAM3007.C10 ; VRAM3007.H3 213.39,125.64 v3(213.39,125.63) ; VRAM3002.D11 v3(209.4,145.76) 209,146.16 VRAM3002.D12 v3(209.4,146.56) ; v3(196.91,158.59) VRAM3004.N10 ; v3(172.89,156.97) 172.51,156.59 VRAM3001.C10 172.09,156.99 v3(172.09,156.99) 171.69,157.39 VRAM3001.D11 v3(171.29,156.99) 170.89,157.39 VRAM3001.D12 ; VRAM3001.G2 178.89,159.79 178.89,159.79 v3(179.29,159.39) ; VRAM3007.R10 207.79,120.04 v3(207.79,120.03) ; VRAM3002.D14 208.58,148.17 v3(208.58,148.18) ; v3(199.33,163.43) 199.33,163.41 VRAM3004.G14 ; v3(200.31,167.17) 199.88,167.17 VRAM3004.B14 ; v3(176.04,158.58) 176.43,158.19 VRAM3001.E5 ; v3(168.9,155.37) 168.9,155.4 VRAM3001.B14 ; v3(170.51,167.37) VRAM3001.T12 ; v3(216.24,123.84) 216.18,123.9 VRAM3007.E5 ; VRAM3002.P11 217.39,144.96 v3(217.4,144.96) ; v3(196.93,165.82) VRAM3004.D11 ; VRAM3004.L13 199.33,159.42 v3(199.33,159.41) ; v3(210.98,126.44) VRAM3007.L2 ; VRAM3007.T3 206.99,125.64 v3(206.99,125.63) ; v3(176.08,166.57) 176.11,166.57 VRAM3001.R5 ; v3(178.49,161.79) VRAM3001.K3 ; v3(214.18,146.53) 213.81,146.16 VRAM3002.K12 ; VRAM3001.L14 168.98,162.68 v3(168.75,162.68) ; v3(180.06,157.79) 180.06,157.76 VRAM3001.D1 ; v3(180.25,162.86) 179.81,162.86 VRAM3001.L1 ; v3(189.74,162.66) 189.77,162.66 VRAM3004.G2 ; VRAM3004.G11 197.7,163.38 v3(197.72,163.38) ; v3(214.98,145.77) 215,145.77 VRAM3002.M12 ; v3(200.23,156.18) 200.09,156.18 VRAM3004.T14 ; v3(197.73,166.62) VRAM3004.B12 ; v3(218.2,138.56) 218.2,138.56 VRAM3002.T3 ; v3(180.25,167.12) 180.02,167.12 179.89,166.99 VRAM3001.T1 ; VRAM3002.B1 v3(207.77,136.98) ; VRAM3002.G14 211,147.36 v3(211,147.36) ; v3(218.18,119.22) 218.2,119.22 VRAM3007.B12 ; VRAM3002.H3 212.2,138.96 v3(212.6,139.36) ; VRAM3002.L2 VRAM3002.L1 214.54,137.31 214.54,136.87 v3(214.32,136.65) ; v3(197.74,155.46) 197.77,155.46 VRAM3004.T12 ; v3(188.79,167.07) 188.84,167.02 189.32,167.02 VRAM3004.B1 ; VRAM3004.B3 190.93,167.02 v3(190.53,166.62) ; v3(212.59,125.63) VRAM3007.K3 ; VRAM3004.L4 191.73,159.81 v3(192.13,159.4) ; v3(211,140.16) 211,140.15 VRAM3002.G4 ; v3(207.8,145.76) 207.79,145.76 VRAM3002.B12 ; VRAM3002.P3 217.39,138.56 v3(217.4,138.56) ; VRAM3002.T14 218.6,148.27 v3(218.65,148.32) ; v3(197.74,164.22) 197.74,164.2 VRAM3004.F12 ; v3(170.54,159.39) 170.49,159.39 170.09,159.79 VRAM3001.G13 ; VRAM3007.G11 214.97,119.25 v3(215,119.25) ; v3(218.2,145.76) 218.2,145.76 VRAM3002.T12 ; v3(180.29,165.43) 179.73,165.43 VRAM3001.P1 ; VRAM3001.M14 169,163.79 v3(168.75,163.55) ; VRAM3007.F12 v3(215.78,118.44) ; VRAM3004.P12 v3(197.74,157.03) 197.71,157.03 VRAM3004.P11 ; VRAM3007.M3 210.59,126.04 v3(211,125.62) ; VRAM3001.H12 170.89,160.59 v3(171.29,160.19) ; VRAM3002.E5 209.8,140.62 v3(210.14,140.97) ; VRAM3002.D1 209.38,136.98 v3(209.4,136.98) ; v1(198.52,158.63) VRAM3004.M12 ; v3(197.77,159.41) 197.73,159.41 VRAM3004.L11 ; v3(211.05,116.81) 211.05,116.91 VRAM3007.L14 ; VRAM3002.L11 214.58,145.36 v3(214.18,144.96) ; v3(208.59,118.41) 208.59,118.44 VRAM3007.P12 ; VRAM3007.L11 210.99,119.24 v3(210.99,119.23) ; v3(188.95,160.2) VRAM3004.L1 ; v3(198.56,163.43) 198.56,163.39 VRAM3004.G13 ; VRAM3004.E10 v3(196.15,165) ; v3(172.88,166.57) 172.5,166.19 VRAM3001.R10 v3(172.09,165.79) ; v3(168.73,167.02) 169.26,167.02 VRAM3001.T14 ; v3(206.94,116.82) 206.97,116.82 VRAM3007.T14 ; v3(180.06,156.19) 180.06,156.16 VRAM3001.B1 ; VRAM3001.T3 177.7,167.38 v3(177.69,167.38) ; VRAM3004.C5 v3(193.25,166.22) ; VRAM3004.P3 190.56,157.04 v3(190.56,156.99) ; VRAM3001.G1 180.06,160.16 v3(180.06,160.19) ; v3(215.8,140.16) 215.8,140.16 VRAM3002.N5 ; v1(179.69,142.52) 179.69,142.58 U3002.AA30 ; VRAM3004.D3 191.33,165.81 v3(191.33,165.82) ; U3002.W30 v1(181.36,143.33) ; VRAM3007.T1 207.38,128.05 v3(207.52,128.19) ; v3(169.74,159.39) 169.69,159.39 VRAM3001.G14 ; v3(191.33,161.01) 191.33,161.01 VRAM3004.K3 ; v3(218.18,140.97) 218.18,140.94 VRAM3002.R5 ; VRAM3002.P12 217.39,145.76 v3(217.4,145.76) ; v3(192.89,156.2) 192.53,156.56 VRAM3004.R5 ; VRAM3002.H12 v3(211.8,145.76) VRAM3002.G11 ; v3(176.08,164.2) 176.1,164.2 VRAM3001.N5 ; v3(190.53,160.21) VRAM3004.L2 ; v3(188.73,155.54) 189,155.82 VRAM3004.T1 ; VRAM3007.C5 218.2,124.02 v3(218.23,124.02) ; v3(177.69,165.79) VRAM3001.P3 ; VRAM3007.G1 214.61,127.66 v3(214.61,128.23) ; v3(214.98,126.38) 215.04,126.38 VRAM3007.F3 ; v3(176.89,159.39) VRAM3001.G4 ; VRAM3001.D14 169.26,157.39 168.89,157.02 v3(168.89,156.98) ; VRAM3001.M1 180.26,163.79 v3(180.34,163.71) ; VRAM3001.L11 171.69,162.99 v3(171.31,163.37) ; VRAM3007.P11 208.59,119.24 v3(208.59,119.23) ; VRAM3007.P3 208.59,125.64 v3(208.59,125.63) ; VRAM3002.M1 215.4,136.78 v3(215.32,136.71) ; VRAM3007.M12 210.19,118.44 v3(210.19,118.43) ; VRAM3004.P14 v3(200.11,157.8) ; v3(209.01,128.18) 208.98,128.15 VRAM3007.P1 ; v3(217.39,125.63) VRAM3007.D3 ; v3(211.8,137.76) 211.4,138.16 VRAM3002.G2 ; v3(210.7,128.16) 210.58,128.05 VRAM3007.M1 ; VRAM3002.R10 218.18,144.17 v3(218.18,144.17) ; VRAM3001.F12 171.29,158.59 v3(171.34,158.59) ; v3(210.21,144.16) 210.19,144.16 VRAM3002.E10 ; VRAM3002.D3 209.39,138.56 v3(209.4,138.56) ; VRAM3007.G14 v3(214.98,116.84) ; v3(211.8,136.98) 211.78,136.98 VRAM3002.G1 ; VRAM3007.F1 215.24,127.78 v3(215.24,128.24) ; v3(211.77,118.42) VRAM3007.K12 ; VRAM3001.P11 v3(171.29,165.79) 170.89,165.39 VRAM3001.P12 ; VRAM3004.C10 v3(196.15,166.6) ; PR108.1 221.49,179.27 222.19,178.57 PC274.2 ; VRAM3002.K3 213.4,139.35 v3(213.4,139.36) ; VRAM3002.M14 215.15,148.01 v3(215.15,148.31) ; VRAM3002.T1 218.65,137.31 218.65,136.81 v3(218.7,136.76) ; VRAM3007.D11 217.38,120.03 v3(217.38,120.03) ; v3(191.29,158.62) 191.29,158.65 VRAM3004.M3 ; v3(209.39,120.03) 209.39,120.04 VRAM3007.N10 ; v3(210.17,123.99) 210.17,124.05 VRAM3007.N5 ; v3(217,136.76) 217,136.77 VRAM3002.P1 ; v3(168.89,159.36) 168.92,159.36 VRAM3001.F14 ; VRAM3007.L1 211.38,127.97 v3(211.57,128.15) ; VRAM3007.G4 v3(214.2,125.62) ; VRAM3002.M3 215.8,139.36 v3(215.8,139.36) ; VRAM3007.E10 216.18,120.44 216.59,120.84 v3(216.6,120.84) ; VRAM3002.B14 206.98,148.17 v3(206.95,148.17) ; VRAM3004.E5 193.02,164.62 v1(193.09,164.69) ; VRAM3001.G11 171.69,159.79 v3(172.09,159.39) ; v3(200.15,159.43) VRAM3004.M14 ; v1(214.18,147.34) 214.21,147.34 VRAM3002.L13 ; v3(207.79,123.97) 207.79,124.04 VRAM3007.R5 ; v3(211.8,147.36) VRAM3002.G13 ; VRAM3007.B3 218.19,126.43 v3(218.19,126.43) ; v3(216.33,143.91) 216.2,144.04 VRAM3002.N10 ; v3(170.49,155.39) VRAM3001.B12 ; v3(169.67,163.37) 169.71,163.37 VRAM3001.L13 ; VRAM3001.H3 178.48,160.19 v3(178.51,160.19) ; v3(211,136.93) 211,136.95 VRAM3002.F1 ; v3(207.8,140.16) VRAM3002.C5 ; v3(170.52,162.58) 170.52,162.56 VRAM3001.K12 ; v3(180.06,159.39) 180.06,159.36 VRAM3001.F1 ; v3(188.77,165.31) 188.87,165.42 VRAM3004.D1 ; v3(190.53,155.41) VRAM3004.T3 ; v3(215,140.16) 215,140.16 VRAM3002.L4 ; VRAM3007.G2 v3(214.97,127.22) ; VRAM3004.F1 188.85,163.82 v3(188.72,163.69) ; VRAM3001.M3 177.69,163.39 v3(177.69,163.39) VRAM3001.L4 ; v1(168.74,165.29) 168.84,165.39 VRAM3001.P14 ; VRAM3001.C5 176.49,156.59 v3(176.89,156.19) ; v3(207.8,139.36) VRAM3002.B3 ; v3(217.38,119.22) 217.36,119.22 VRAM3007.D12 ; VRAM3001.L2 v1(178.49,162.59) ; VRAM3007.D1 216.98,127.97 v3(216.77,128.19) ; v3(196.91,156.99) VRAM3004.R10 ; VRAM3007.T12 206.99,118.44 v3(206.99,118.43) ; VRAM3001.E10 v3(172.89,158.59) ; VRAM3007.L13 v3(210.98,117.63) ; VRAM3007.P14 v3(208.57,116.82) ; VRAM3004.D14 200.24,165.42 v3(200.3,165.48) ; VRAM3004.G1 v3(188.73,163.02) ; v3(197.73,165.82) VRAM3004.D12 ; VRAM3007.M14 210.19,116.84 v3(210.19,116.82) ; v3(188.79,159.02) VRAM3004.M1 ; v3(192.11,162.64) VRAM3004.G4 ; v3(211,146.56) VRAM3002.F12 ; U3002.T30 183.09,142.55 v1(183.09,142.54) ; VRAM3002.F14 211.01,148.17 v3(211.01,148.19) ; v3(177.69,156.19) 178.09,155.79 VRAM3001.B3 ; VRAM3001.D3 178.09,157.39 v3(178.49,157.79) ; VRAM3007.B14 v3(218.19,116.84) ; v3(200.12,163.43) VRAM3004.F14 ; v1(196.55,128.67) 196.45,128.57 195.25,128.57 U3002.B13 ; v3(191.34,162.63) VRAM3004.H3 ; v3(198.5,162.59) VRAM3004.H12 ; VRAM3002.L14 v3(215.01,147.34) ; v3(210.2,138.56) VRAM3002.F3 ; v3(216.56,116.84) 216.59,116.84 VRAM3007.D14 ; VRAM3007.G13 v3(214.98,117.64) ; v3(178.49,158.59) VRAM3001.F3 ; VRAM3007.F14 v3(215.78,117.63) ; v3(198.53,160.22) VRAM3004.K12 ; U3002.E19 193.1,134.06 v1(193.1,134.13)
  BOTTOM w0.381: C4666.1 210.23,113.69 209.86,114.07 v1(209.86,114.32) ; v1(222.84,178.25) 222.76,178.33 PC274.2
  BOTTOM w0.508: R4512.1 v1(204.55,156.48) ; C4692.2 v1(221.93,147.72) ; R11101.1 v1(216.21,112.29) ; C4547.1 v1(172.56,170.49) ; C4553.1 C4515.2 165.8,157.2 v1(166.3,157.2) ; C4107.2 202.62,166.9 v1(202.49,167.02) ; C4544.1 v1(169.35,170.45) ; R4522.1 164.89,161.05 164.39,160.55 v1(164.22,160.55) ; C4687.1 v1(211.64,112.29) ; C4525.2 v1(175.06,170.45) ; C4675.2 v1(222.05,119.15) ; R11104.1 v1(223.96,144.55) ; v1(208.34,114.32) 208.21,114.19 C4691.2 ; C4707.1 v1(222.05,126) ; R4518.1 v1(164.27,167.53) ; C4530.1 v1(202.49,167.91) ; C4545.1 v1(202.49,168.93) ; C4519.2 v1(168.2,170.45) ; C4552.1 v1(204.55,160.67) ; v1(209.1,154.71) 209.1,154.08 R11095.1 ; C4528.1 v1(166.3,168.68) ; C4111.2 177.82,171 177.98,170.83 v1(177.98,170.45) ; C4516.2 v1(166.3,169.82) ; C4535.1 v1(202.39,165.75) ; C4539.1 v1(170.49,170.45) ; C4686.1 v1(212.78,112.29) ; v1(198.3,113.68) 197.67,113.05 196.02,113.05 195.26,113.81 195.26,114.06 R4115.2 ; C4548.1 202.74,169.56 v1(202.49,169.56) ; C4674.1 v1(207.1,153.34) ; C4709.1 209.1,113.95 v1(209.1,114.32) ; C4689.1 v1(221.96,123.5) ; R11074.1 v1(224.08,120.16) ; C4698.1 v1(222.05,127.02)
  vias: v1(178.1,140.03) v1(178.95,140.02) v1(179.73,140.83) v1(179.71,140.02) v1(180.55,140.05) v1(181.39,140.07) v1(182.22,140.83) v1(183.01,140.83) v1(183.9,140.81) v1(183.95,139.97) v1(184.71,139.97) v1(185.48,139.97) v1(186.37,139.97) v1(187.22,140.83) v1(188.75,148.46) v1(188.87,136.19) v1(189.08,127.22) v1(189.67,129.5) v1(189.72,127.35) v1(189.68,124.89) v1(190.63,137.43) v1(190.63,134.94) v1(190.63,132.43) v1(190.62,129.94) v1(190.58,128.26) v1(190.63,127.44) v1(190.61,125.78) v1(190.66,136.62) v1(215.37,162.63) v1(221.42,116.1) v1(221.42,115.46) v1(221.42,114.83) v1(221.42,114.19) v1(222.05,115.46) v1(222.05,114.83) v1(222.05,114.19) v1(223.04,117.04) v2(216.11,161.94) v2(216.21,161.18) v2(216.54,162.71) v2(216.85,161.94) v2(216.97,161.18) v2(217.35,162.66) v2(217.61,161.92) v2(217.73,161.18) v2(218.5,161.18) v2(220.27,152.67) v2(220.27,151.91) v2(220.63,150.59) v2(221.39,150.59) v2(222.15,150.59)
+1V_S5: length 87.1
  TOP w0.381: R512.2 120.24,124.27 120.58,124.61 v3(120.71,124.61) ; PC235.2 PR86.1
  TOP w0.508: 63.94,91.71 65.46,91.71 67.54,89.63 67.54,79.62 69.04,78.12 69.04,70.17 67.24,68.37 63.96,68.37 63.2,69.13 PC235.2
  IN2 w0.381: v3(120.71,124.61) 120.71,124.23 121.34,123.59 121.34,119.78 122.74,118.38 122.74,118 123.12,117.62 125.02,117.62 125.91,116.73 127.69,116.73
  IN3 w0.508: v1(150.2,117.62) 149.79,117.22 149.79,116.48 148.01,114.7 139.38,114.7
  BOTTOM w0.254: U35.P16 131.71,116.09 v3(131.71,116.15) 131.39,116.48 U35.N17 ; U35.K15 132.69,118.14 v3(132.4,117.86) 132.69,117.57 U35.L15 ; U35.AK20 129.02,108.64 128.45,108.64 128.24,108.84 v3(128.24,109) ; v3(133.23,123.87) 133.23,123.61 U35.A14 ; v3(132.36,116.15) 132.36,116.09 U35.P15 ; v3(128.47,117) 128.45,117 128.42,117.03 128.42,117.08 U35.L21 ; U35.A10 v1(135.49,124.23)
  BOTTOM w0.305: v3(131.11,117.86) 131.11,118 U35.K17 ; v3(130.42,114.51) 130.42,114.54 130.27,114.69 130.27,114.74 U35.T19 129.94,115.07 129.58,115.07 U35.T20 129.09,114.58 v1(129.09,114.5) ; v3(130.41,116.99) 130.74,116.67 U35.N18 ; v3(132.39,114.5) 132.69,114.2 U35.V15 ; v3(130.41,116.18) 130.58,115.97 U35.P18 ; v1(129.09,114.5) 128.79,114.2 U35.V21 ; v1(129.09,114.5) 129.09,114.43 U35.V20 ; v3(129.11,117.02) 129.11,116.93 U35.N20 ; v3(129.76,117.85) 129.76,117.95 U35.K19 ; v3(129.76,117.02) 129.76,117.11 U35.L19 ; v3(129.76,111.99) 130.09,112.31 U35.AB19 130.5,112.95 130.5,113.01 U35.Y18 ; v3(129.76,111.99) 131.06,111.99 U35.AB17 ; v3(129.76,111.99) U35.AB20 ; U35.AF21 v3(129.11,111.15) U35.AF20 ; U35.N16 132.36,116.27 v3(132.36,116.15) ; U35.AF19 130.09,110.64 v3(130.41,110.31) U35.AF18 ; U35.L15 U35.N15
  BOTTOM w0.381: R11131.2 146.79,118.13 148.18,119.52 C672.1 C695.2 149.56,119.52 150.2,118.88 v1(150.2,117.62)
  vias: v1(135.49,125.24) v2(60.46,91.71) v2(61.7,91.74) v2(62.92,91.97) v2(74.1,97.3) v2(74.1,96.54) v2(74.1,95.78) v2(74.86,97.3) v2(74.86,96.54) v2(74.86,95.78) v2(75.62,97.3) v2(75.62,96.54) v2(75.62,95.78) v2(79.46,91.21) v2(79.46,90.44) v2(79.46,89.68)
+1V_S5_ON: length 148.5
  TOP w0.127: v1(65.12,69.86) 65.54,70.28 PR83.2 66.04,70.47 v1(66.27,70.71)
  IN1 w0.089: v1(83.24,32.4) 83.47,32.18 147.77,32.18 148.51,32.91 157.05,32.91 159.21,35.07 167.37,35.07 171.13,38.83 171.13,39.42 172.87,41.17 v1(172.95,41.17)
  IN3 w0.114: v1(83.24,32.4) 83.24,37.1 79.81,40.53 79.81,65.81 77.4,68.22 71,68.22 68.97,70.25 65.51,70.25 v1(65.12,69.86)
  BOTTOM w0.127: U45.95 172.79,41 v1(172.95,41.17)
+1V_SUS: length 187.3
  TOP w0.508: v2(78.67,99.87) v2(78.67,100.6) 78.67,102.13 77.31,103.48 v1(77.31,104.36) PR139.1 v1(78.16,105.66) ; v1(158.55,143.15) 158.55,141.82 156.07,139.34 154.11,139.34 144.58,129.81 144.58,129.52 R112.1 142.88,129.95 137.08,129.95 135.4,128.28 R550.1
  IN2 w0.508: v1(76.61,113.34) 76.61,116.43 76.9,116.72 80.27,116.72 81.25,117.7 81.25,118.71 84.11,121.57 84.11,124.07 87.8,127.76 87.8,129.8 95.62,137.62 95.62,138.38 103.17,145.93 103.17,147.15 105.16,149.15 105.16,149.53 105.67,150.04 105.67,150.04 105.83,150.21 105.83,151.83 109.57,155.57 110.01,155.57 111.18,156.74 111.18,158 111.69,158.51 111.69,161.33 117.42,167.05 119.67,167.05 120.33,166.39 124.9,166.39 127.82,169.31 133.41,169.31 134.64,170.54 145.6,170.54 147.01,171.96 148.88,171.96 153.64,167.2 155.02,167.2 157.39,164.84 157.39,145.45 158.55,144.29 v1(158.55,143.15)
  BOTTOM w0.508: v1(78.16,105.66) 78.16,111.79 v1(76.61,113.34)
+1V_VCCST: length 183.7
  TOP w0.254: v1(130.49,172.36) 130.49,172.75 130.99,173.26 PC6228.1 131.25,173.76 131.11,173.89 PR341.1 PR340.1 ; v1(131.02,126.03) 131.02,126.49 132.7,128.16 R550.2 134.24,128.16 134.51,128.43 134.51,128.67 134.66,128.82 135.23,128.82 136.87,130.46 143.82,130.46 148.39,135.03 148.39,135.54 v1(149.54,136.68) 150.54,136.68 153.96,140.1 v1(154.74,140.1) ; v1(104.83,131.46) R529.1 R788.1
  IN1 w0.254: v1(129.93,165.75) 130.49,166.31 v1(130.49,172.36)
  IN1 w0.508: v1(101.4,131.46) v1(103.05,131.46) v1(104.83,131.46)
  IN2 w0.254: v1(104.83,131.46) 106.86,133.5 106.86,134.72 107.02,134.87 107.02,145.09 109.11,147.19 109.98,147.19 111.87,149.08 111.87,151.71 114.61,154.46 114.61,156.36 113.96,157 113.96,161.7 116.09,163.82 119.03,163.82 120.01,164.8 128.98,164.8 v1(129.93,165.75) 130.32,166.14 133.41,166.14 134.64,164.9 135.25,164.9 135.98,164.17 136.97,164.17 138.43,162.72 150.22,162.72 152.35,164.85 154.44,164.85 155.1,164.19 156.25,164.19 156.62,163.82 156.62,144.58 154.74,142.7 v1(154.74,140.1)
  IN2 w0.508: v1(101.66,136.04) 101.66,131.72 v1(101.4,131.46)
  IN3 w0.508: v1(95.94,136.04) 96.7,135.27 100.89,135.27 v1(101.66,136.04)
  BOTTOM w0.203: v1(131.02,126.03) 130.53,125.54 U35.A18
  BOTTOM w0.254: R85.2 v1(149.54,136.68) ; v1(131.02,126.03) 131.02,126.4 C677.2
  BOTTOM w0.279: Q31.3 88.32,132.15 88.78,132.61 91.11,132.61 R488.2 v1(91.74,133.29) 91.74,133.37 92.77,134.4 U33.5 94.01,134.89 93.9,135 C628.1
  BOTTOM w0.508: v1(95.94,136.04) 95.56,136.42 v1(94.92,136.42) 94.42,136.42 93.9,135.9 C628.1 ; R134.1 v1(103.05,131.46) C814.2
  vias: v1(105.64,131.72)
+2.5V: length 25
  TOP w0.508: v1(155.45,61.89) 155.45,61.92 155.77,62.24 R11174.2 ; v1(156.52,52.72) 156.02,52.72 R11170.2
  IN1 w0.508: v1(156.52,52.72) 155.5,51.71 155.5,48.03 155,47.52 155,43 v2(155.58,42.41)
  IN2 w0.508: v1(156.52,52.72) 157.03,52.72 157.54,53.23 157.54,57.12 156.6,58.06 156.01,58.06 155.5,58.57 155.5,60.78 155.45,60.84 v1(155.45,61.89)
  BOTTOM w0.127: v1(156.57,38.15) 156.66,38.23 PR6298.1
+2.5V_SUS: length 9.6
  TOP w0.508: v1(162.39,45.59) 163.3,46.5 v1(169.05,46.5) 169.73,46.5 v1(169.86,46.63)
  BOTTOM w0.508: PR273.2 170.93,47.29 170.11,47.29 169.86,47.04 v1(169.86,46.63)
  vias: v1(148.44,62.07) v1(149.41,50.06) v1(149.92,62.38) v1(149.92,61.72) v1(150.04,50.69) v1(150.04,50.06) v1(150.55,62.12) v1(154.79,44.77) v1(156.42,44.06) v2(155.66,46.5) v2(155.66,45.74) v2(155.66,44.98)
+3V: length 902.1
  TOP w0.203: v1(22.94,71.52) 23.08,71.38 U13.14 ; U13.26 22.68,65.19 22.54,65.04 C4752.2
  TOP w0.254: 172.21,82.82 172.63,82.82 172.98,83.18 172.98,84.02 ; 172.21,82.82 171.91,83.12 171.91,83.44 171.91,83.44 171.91,83.46 171.39,83.97 U4512.2 U4512.1 ; 172.21,82.82 172.21,82 v1(172.5,81.71) ; v1(134.55,82.62) 134.55,83.31 133.89,83.97 U16.2 U16.1 ; U17.1 82.06,83.97 81.54,83.46 81.54,82.37 v1(81.59,82.32)
  TOP w0.279: U18.18 17.73,45.25 16.95,44.47 16.95,43.84 C4784.2 ; Q2.5 121.09,175.03 121.22,175.16 R12.2 ; Q2.2 117.31,175.03 117.18,174.89 R9.2 ; U18.22 19.73,45.12 20.12,44.72
  TOP w0.381: v1(57.13,80.41) 57.32,80.61 PR293.2 ; 172.98,84.02 172.98,87.19 172.46,87.71 172.46,88.65 173.26,89.45 173.26,90.74 173.28,90.76 ; R11286.2 v1(23.4,74.09) ; v1(151.69,99.84) 151.69,99.98 151.45,100.22 R234.2 R618.2 ; R257.1 v1(149.66,103.4) ; R223.2 151.57,102.38 v1(151.69,102.25) ; R11285.2 v1(24.36,74.09) ; R227.2 v1(149.66,102.38) ; R228.2 v1(151.69,101.37) ; R215.2 v1(151.69,103.4) ; v1(41.31,52.14) 41.42,52.02 PR107.2
  TOP w0.508: R426.2 v1(50.72,19.21) ; v1(178.49,88.92) 177.35,88.92 175.51,90.76 167.13,90.76 166.3,89.94 166.3,87.52 165.66,86.89 164.65,86.89 163.12,85.36 v1(161.91,85.36) 161.91,86.96 160.71,88.16 160.71,91.84 159.95,92.6 158.93,92.6 158.55,92.22 156.9,92.22 ; R789.2 156.01,91.33 156.9,92.22 ; v1(162.36,63.52) 162.36,64.24 162.85,64.73 173.27,64.73 174.55,63.44 v1(175.11,63.44) ; v1(223.45,82.06) 222.69,82.82 220.68,82.82 216.46,87.04 216.46,87.86 214.21,90.11 214.21,94.1 213.71,94.61 213.71,105.52 v1(213.54,105.68) ; v1(109.78,35.07) 110.68,35.07 R11297.2 ; v1(146.23,120.49) 146.15,120.41 R781.2 ; 35.13,75.61 34.1,76.64 32.61,76.64 31.3,75.33 31.3,75.08 30.41,74.19 27.38,74.19 26.96,73.76 v1(26.96,73.76) 26.63,73.43 R11187.1 ; v1(154.74,39.62) 154.74,41.93 v1(151.76,44.91) ; v1(156.52,53.36) 156.02,53.36 R11133.2 155.89,53.99 154.99,54.89 R10940.1 154.59,55.54 154.59,56.77 R10924.1 154.99,57.3 155.16,57.47 C1316.1 155.16,58.9 154.99,59.07 C1326.1 154.99,60.47 R11134.2 ; R10923.1 131.37,51.45 130.74,50.82 130.74,47.77 129.84,46.87 R10889.1 v1(128.83,46.02) ; C4784.2 C4608.1 v1(15.55,43.72) ; 156.9,92.22 156.9,93.38 156.28,94 154.35,94 151.94,96.41 v1(151.19,96.41) ; v1(178.62,181.27) 178.88,181.01 R245.2 ; R533.1 99.5,128.81 v1(99.5,129.31) ; R722.1 v1(26.98,52.83) ; v1(154.63,49.61) 154.95,49.3 C1276.1 155.24,48.79 155.29,48.74 C1268.1 ; v1(117.53,172.87) 117.15,172.49 R19.1 ; C4752.2 22.54,64.29 v1(23.17,64.92) ; v1(116,174.89) R9.2 ; R216.2 R209.2 v1(230.94,106.18) ; R204.2 v1(153.23,105.56) ; PR318.2 v1(202.46,174.77) ; R11.1 119.29,167.57 v1(120.08,168.36) ; v1(121.72,175.79) R12.2 ; 30.41,59.46 30.79,59.07 32.95,59.07 33.58,59.71 R277.1 34.36,62.37 35.62,61.11 36.25,61.11 36.76,61.61 R11263.1 ; R10880.1 R10872.1 v1(145.95,37.87)
  IN1 w0.508: v1(57.13,80.41) 55.56,80.41 53.52,78.38 50.48,78.38 48.06,80.79 48.06,83.1 v1(46.82,84.35) ; v1(97.08,131.97) 97.08,131.46 97.97,130.58 98.99,130.58 99.5,130.07 v1(99.5,129.31) ; v1(155.5,118.38) 152.91,120.97 v1(151.92,120.97) ; 219.64,66.44 219.64,72.51 220.53,73.4 220.53,79.04 223.45,81.96 v1(223.45,82.06)
  IN2 w0.381: v1(149.66,100.1) 149.41,100.1 149.03,99.71 146.11,99.71 v1(145.6,99.21)
  IN2 w0.508: v1(179.13,88.92) 179.13,92.06 177.89,93.29 177.89,102.72 176.97,103.64 v1(176.97,104.54) 177.22,104.54 177.89,105.21 177.89,108.01 v1(179.25,109.37) ; v1(151.69,103.4) 151.69,103.91 153.23,105.44 v1(153.23,105.56) 152.84,105.95 152.84,108.31 v1(151.81,109.34) 151.33,109.34 150.98,109.68 150.98,113.74 152.84,115.59 152.84,116.86 151.92,117.77 v1(151.92,120.97) 151.21,121.69 147.76,121.69 146.56,120.49 v1(146.23,120.49) 146.11,120.49 145.22,121.38 145.22,123.95 v1(144.46,124.71) ; v1(151.69,103.4) v1(151.69,102.25) v1(151.69,101.37) v1(151.69,99.84) ; v1(151.69,103.4) v1(149.66,103.4) v1(149.66,102.38) ; v1(160.84,131.46) 160.84,130.07 158.81,128.04 158.81,121.69 v1(155.5,118.38) ; v2(42.6,44.6) 42.6,39.13 41.71,38.24 41.71,29.48 50.72,20.48 v1(50.72,19.21) ; v1(203.64,191.79) 205.11,193.27 227.41,193.27 229.75,190.93 229.75,180.44 228.22,178.91 219.64,178.91 218.8,178.07 216.9,178.07 216.06,177.24 v1(215.04,177.24) ; v1(149.66,100.1) 150.55,100.1 150.81,99.84 v1(151.69,99.84) ; v1(151.69,99.84) 151.69,99.21 151.19,98.7 v1(151.19,96.41) 151.19,94.38 150.68,93.87 150.68,92.09 147.63,89.05 v1(147.63,87.4) 147.63,86.89 150.3,84.22 150.3,75.94 v1(149.03,74.67) ; v1(141.66,91.84) 138.24,91.84 v1(136.72,93.36) ; v1(128.83,46.02) 128.83,44.72 129.88,43.67 144.63,43.67 144.87,43.91 150.75,43.91 v1(151.76,44.91) 152.84,45.99 152.84,47.82 v1(154.63,49.61) 154.63,51.98 156.01,53.36 v1(156.52,53.36) ; 120.72,168.93 124.27,168.93 v1(124.91,168.29) ; 50.68,71.32 51.19,71.32 52.13,70.38 56.06,70.38 56.93,71.24 57.16,71.24 57.18,71.25 57.69,71.25 57.71,71.24 67.95,71.24 v1(68.18,71.01) ; 202.75,191.15 201.86,190.27 201.86,187.6 203.28,186.18 203.28,179.5 202.75,178.96 202.75,176.17 202.46,175.88 v1(202.46,174.77)
  IN2 w0.635: 89.52,124.61 89.52,124.63 91.19,126.31 91.19,127.12 92.49,128.42 92.61,128.42
  IN2 w0.762: 49.79,74.65 48.82,73.68 48.82,70.45
  IN2 w1.016: 183.57,180.72 191.42,180.72 192.78,182.07 194.05,182.07 198.56,186.58 198.56,191.28 199.32,192.04 202.24,192.04 ; 92.61,128.42 93.64,127.39 93.64,126.02 92.23,124.61 90.96,124.61 ; 49.79,74.65 50.68,73.76 50.68,71.32 48.82,69.46 ; 159.9,186.41 158.35,186.41 157.79,186.96 153.73,186.96 153.22,187.47 149.66,187.47 147.17,184.98 137.27,184.98 134.93,182.65
  IN2 w1.524: 49.79,74.65 49.79,75.66 45.66,79.79 45.66,83.19 v1(46.82,84.35) 46.79,84.37 46.79,98.19 52.25,103.65 52.25,108.22 55.89,111.86 76.84,111.86 77.88,112.9 ; 42.42,53.23 40.23,55.43 40.23,58.19 42.53,60.48 42.53,62.88 45.26,65.62 45.26,65.68 47.32,67.74 48.11,67.74 48.82,68.46 48.82,70.45 ; 92.61,128.42 92.61,131.08 94.04,132.51 95.84,132.51 ; 96.86,133.88 102.43,139.45 102.81,139.45 104.54,141.19 104.54,146.34 106.51,148.31 106.51,148.84 107.32,149.65 107.32,151.35 110.09,154.12 110.65,154.12 ; 80.68,114.95 81.41,115.69 81.44,115.69 82.61,116.86 82.61,118.15 85.46,121.01 85.46,122.62 87.45,124.61 90.96,124.61
  IN3 w0.508: 133.66,181.25 133.66,180.61 133.03,179.98 133.03,178.96 134.68,177.31 134.68,176.17 135.18,175.66 135.18,172.54 v1(134.65,172) ; v1(230.94,106.18) 229.81,105.05 222.18,105.05 221.16,106.06 220.17,106.06 219.77,105.66 v1(219.77,105.41) 218.26,105.41 217.99,105.68 v1(213.54,105.68) ; v1(207.96,51.07) 208.28,51.07 209.99,49.36 209.99,48.54 211.52,47.01 v1(211.52,45.75)
  IN3 w1.016: 123.12,177.18 125.53,179.6 128.66,179.6 130.56,181.5 132.64,181.5
  BOTTOM w0.279: C376.1 135.74,81.81 134.94,82.62 v1(134.55,82.62) ; R576.2 150.31,125.23 149.92,125.62 Q32.5 Q32.2 146.1,125.62 145.85,125.38 R572.2 ; U4001.5 213.19,106.55 213.29,106.45 C4024.2 ; C4025.2 219,106.05 218.99,106.04 U4002.5 ; v1(178.62,181.27) 178.87,181.02 Q23.5
  BOTTOM w0.305: C332.2 162.61,85.99 163.11,86.49 U14.5
  BOTTOM w0.381: PR296.2 215.1,177.18 v1(215.04,177.24) ; R573.2 R574.2 145.66,120.49 v1(146.23,120.49) 146.81,120.49 R575.2 ; PR197.1 PR196.1 134.55,172.1 v1(134.65,172) ; v1(172.5,81.71) 172.32,81.71 171.65,81.04 C4735.1 171.45,80.98 170.29,80.98 C4733.1 C4734.1 ; v1(176.97,104.54) 176.92,104.59 176.84,104.59 176.79,104.54 176.31,104.54 176.31,104.54 170.87,104.54 170.35,105.06 R11284.1 170.35,106.76 169.99,107.12 R961.1 ; R227.2 R257.1 v1(149.66,103.4) R619.1 ; R631.2 v1(145.6,99.21) R629.1 ; v1(190.71,60.47) 191.04,60.14 PR259.2 ; v1(149.66,100.1) 149.16,100.1 R220.2 ; v1(81.59,82.32) 81.73,82.45 C356.1 82.36,82.44 C353.1 C360.1 ; PR295.2 67.97,71.22 v1(68.18,71.01)
  BOTTOM w0.508: v1(179.25,109.37) 177.22,109.37 176.68,108.83 R4201.2 ; v1(219.77,105.41) 219.77,105.93 C4025.2 ; C360.1 83.49,84.43 84.82,85.76 84.82,90.75 83.88,91.69 83.88,108.99 v1(79.24,113.62) ; v1(158.76,37.99) 160.66,36.09 R374.2 ; Q20.2 151.87,120.97 v1(151.92,120.97) ; v1(147.63,87.4) 146.87,87.4 142.42,91.84 v1(141.66,91.84) R630.1 ; R561.1 145.22,126.5 R572.2 145,125.38 144.46,124.84 v1(144.46,124.71) ; U1.6 109.46,160.35 109.9,160.79 C41.1 109.9,162.19 v1(109.91,162.2) ; PR314.2 170.11,50.45 v1(170.11,51.2) ; R58.2 111.31,154.32 111.41,154.43 111.64,154.43 111.66,154.4 111.69,154.43 111.72,154.43 v2(111.74,154.4) ; R448.1 122.35,168.93 121.71,168.29 121.44,168.29 121.03,167.88 R444.2 120.54,167.88 120.28,168.13 120.28,168.16 v1(120.08,168.36) ; v1(134.6,181.93) 134.6,181.29 134.43,181.12 R7.2 ; C376.1 C371.1 C373.1 135.81,78.51 137.15,77.17 141.6,77.17 144.1,74.67 v1(149.03,74.67) ; U1.4 108.63,158.45 108.44,158.26 v2(107.96,158.26) ; v1(213.54,105.68) 213.92,106.06 C4024.2 ; R449.1 v1(124.91,168.29) ; v1(160.84,131.46) 161.21,131.84 R4205.2 ; v1(79.18,114.32) 79.18,115.77 76.64,118.31 76.64,119.93 77,120.3 R609.1 R218.1 ; v1(161.91,85.36) C332.2 ; R318.1 v1(219.1,64.12) ; R639.1 v1(136.72,93.36) ; PR73.2 v1(162.36,63.52) ; R378.1 v1(211.52,45.75) ; R485.1 v1(97.08,131.97)
  vias: v1(16.69,54.38) v1(17.46,54.38) v1(21.01,44.34) v1(21.14,54.76) v1(21.65,44.34) v1(22.03,54.5) v1(22.48,55.6) v1(22.66,54.5) v1(23.68,55.65) v1(25.84,62.12) v1(25.84,61.49) v1(107.98,158.95) v1(110.48,158.9) v1(121.6,177.06) v1(122.23,177.06) v1(133.94,181.81) v1(178.49,88.28) v1(179.13,88.28) v1(179.81,89.22) v1(190.68,38.98) v1(191.32,38.98) v1(198.34,49.12) v1(198.35,48.48) v1(202.24,51.43) v1(203.64,191.15) v1(207.32,51.07) v1(208.46,63.9) v1(208.46,63.27) v1(209.1,63.9) v1(209.1,63.27) v2(41.84,45.36) v2(41.84,44.6) v2(42.6,45.36) v2(51.39,53.11) v2(51.39,52.27) v2(51.42,51.33) v2(52.13,51.71) v2(52.15,52.78) v2(54.79,53.11) v2(55.56,53.11) v2(56.34,53.11) v2(57,52.78) v2(111.66,153.64)
+3V3_SATA_N1:
  vias: v1(177.15,94.79)
+3V3_SATA_N1_N:
  vias: v1(171.19,94.7) v1(171.53,94.14) v1(171.53,93.5) v1(177.63,94.81) v1(179.79,94.71) v1(180.21,94.23) v1(180.63,94.71)
+3V3_SD_SW: length 62.1
  TOP w0.203: v2(34.14,75.66) 34.14,75.06 34.33,74.86 U15.13
  IN2 w0.762: v2(34.14,75.66) 35.01,74.8 35.01,69.11 33.89,67.99 33.89,65.86 33.2,65.17 32.31,65.17 31.55,64.41 31.55,61.74 30.68,60.87 30.68,44.36 27.49,41.17 27.49,39.01 28.5,37.99 28.5,32.28 30.6,30.18 33.52,30.18 37.27,26.44 v2(37.27,24.66)
  vias: v1(35.11,23.96)
+3V3_TPM: length 26.2
  TOP w0.508: v1(168.74,74.95) 170.49,74.95 v1(170.5,74.94) 172.05,73.39 v1(172.05,72.8)
  IN2 w0.508: v1(165.54,66.59) 164.39,67.74 164.39,70.63 162.85,72.18 v1(162.36,72.18) 162.36,72.66 163,73.3 167.09,73.3 v1(168.74,74.95)
  BOTTOM w0.305: C768.1 168.45,73.8 168.19,73.54 U44.22 ; U44.14 163.15,70.87 C774.1
  BOTTOM w0.508: v1(172.05,72.8) 171.76,72.51 R744.1 ; v1(162.36,72.18) 162.62,72.18 163.13,71.66 C774.1 ; v1(168.74,74.95) 168.45,74.66 C768.1
+3V3_TPM_VSB:
  vias: v1(170.49,63.44)
+3V_EC: length 1.7
  BOTTOM w0.203: v1(185.6,37.21) 185.8,37.4 U45.11
  vias: v1(187.28,37.71)
+3V_GFX: length 188.3
  TOP w0.279: v1(173.15,114.2) C4013.1 171.89,114.83 171.38,115.34 171.38,115.97 171.13,116.22 Q4301.5 169.48,116.22 169.35,116.09 169.35,116.09 R4319.2
  TOP w0.508: 170.87,108.35 R4001.1 168.19,108.38 168.19,112.64 R4000.1 ; R4318.2 185.6,114.06 v1(185.6,113.84) ; v1(185.98,125.11) C4029.2 C4028.2 C4026.2 ; v1(167.43,30.74) 167.43,30.49 167.8,30.12 168.56,30.12 169.47,31.03 169.47,34.57 172.52,37.62 172.52,38.55 172.88,38.91 174.61,38.91 176.1,40.41 176.1,45.56 175.71,45.96 175.71,47.15 175.8,47.24 175.8,61.13 175.32,61.61 v1(174.5,61.61) ; R4302.2 190.46,112.25 v1(190.46,111.78) ; R4301.2 v1(195.89,111.78)
  IN1 w0.381: 192.08,117.37 191.12,116.4 191.12,115.26 190.3,114.45 190.3,113.3 190.46,113.15 v1(190.46,111.78)
  IN2 w0.508: v1(174.5,61.61) 174.43,61.61 174.2,61.84 174.2,66.16 173.54,66.82 173.54,73.3 173.67,73.43 173.67,75.64 174.02,76 174.02,76.52 173.54,77 173.54,82.58 176.05,85.1 176.05,91.43 177.27,92.65 177.27,102.46 174.17,105.56 v1(174.17,109.37) 174.17,109.39 173.15,110.42 v1(173.15,114.2)
  IN3 w0.508: v1(195.89,111.78) 195.89,110.38 200.34,105.94 206.94,105.94 208.2,107.19 209.85,107.19 211.64,108.99 217.48,108.99 218.19,108.27 219.72,108.27 220.19,108.74 v1(220.19,108.97) ; v1(162.74,133.93) 163.12,133.93 163.53,134.34 166.35,134.34 168.28,132.4 168.28,131.31 169.56,130.03 169.56,127.44 170.36,126.64 172.78,126.64 173.6,127.46 v1(173.83,127.46)
  BOTTOM w0.279: v1(193.22,108.35) 193.48,108.1 193.48,106.32 193.1,105.94 Q4300.5 Q4300.2
  BOTTOM w0.508: v1(162.74,133.93) 162.48,133.67 R4204.2 R4008.2 ; v1(182.94,107.84) R4342.2 ; R4303.2 187.25,110.89 187.77,110.37 R4321.2 188.27,110 v1(188.78,109.49) ; v1(183.06,111.78) 183.19,111.91 R4322.2 ; v1(167.43,30.74) 167.43,30.02 R740.2 R382.2 ; v1(185.6,113.84) 185.6,114.06 R4318.2 ; R4341.2 185.09,110.9 v1(184.21,111.78) R4316.1 ; v1(220.19,108.97) 220.54,108.62 R4004.2 ; v1(189.92,109.62) 189.92,109.87 189.41,110.37 R4320.2 ; v1(182.28,105.3) 182.28,105.81 181.17,106.92 R4200.2
  vias: v1(174.81,109.37) v1(175.47,127.85) v1(180.14,102.05) v1(181.64,105.3) v1(184.26,113.81) v1(185.6,112.21) v1(188.03,124.04) v1(188.88,124.04)
+3V_LAN:
  vias: v1(47.33,65.48)
+3V_LDO_EC: length 244.6
  TOP w0.508: v1(190.68,43) 190.68,42.11 189.9,41.32 187.1,41.32 186.52,41.9 186.52,44.01 187.51,45 187.51,49.3 ; 185.45,48.64 184.84,48.03 179.3,48.03 v1(178.61,48.72) 178.61,46.76 v1(178.49,46.64) ; R11287.2 114.61,34.82 v1(115.12,34.31) v1(115.12,33.6)
  IN1 w0.508: v1(172.27,48.79) 160.58,48.79 159.95,48.15 159.95,38.32 156.82,35.2 152.86,35.2 152.35,34.69 148.64,34.69 147.55,33.6 v1(115.12,33.6) 114.41,33.6 114.15,33.34 84.53,33.34 84.02,33.84 81.33,33.84 80.63,33.14 v1(79.86,33.14)
  IN2 w0.508: v1(190.68,43) 190.68,44.18 191.55,45.04 191.55,45.97 196.91,51.33 206.69,51.33 209.1,53.74 214.03,53.74 214.59,53.18 215.25,53.18 220.02,48.41 220.02,43.71 217.23,40.91 215.96,40.91 214.71,39.67 214.71,39.16 215.25,38.63 v1(215.45,38.63) ; v1(178.49,46.64) 176.37,46.64 v1(176.36,46.63)
  IN3 w0.508: v1(77.15,40.41) 76.64,39.9 76.64,34.18 77.68,33.14 v1(79.86,33.14)
  BOTTOM w0.508: R11119.2 176.36,46.03 v1(176.36,46.63) 176.61,46.88 176.61,48.51 176.07,49.05 R741.2 173.42,49.05 173.16,48.79 v1(172.27,48.79) ; R730.2 178.75,48.58 v1(178.61,48.72) ; PR6295.2 75.88,49.84 75.88,41.68 v1(77.15,40.41) 76.13,39.39 64.39,39.39 63.2,38.2 PR6296.2 ; R753.2 v1(215.45,38.63) ; v1(190.68,43) 191.78,43 193.86,40.91 193.86,35.83 192.72,34.69 192.72,34.18 192.33,34.18 191.71,34.81 R368.2 ; v1(178.49,46.64) R732.2 R731.2
  vias: v1(186.06,48.91) v1(186.06,48.28) v1(186.42,50.77)
+3V_MAIN: length 135.3
  TOP w0.508: v1(176.28,126.56) 176.75,127.02 C4032.2 176.93,127.4 C4033.1 ; Q4000.3 171.03,112.03 v1(171.29,111.78) 171.3,111.77 R4003.1 ; v1(189.71,111.74) 189.71,111.99 R4305.2 ; v1(187.23,124.04) 187.23,124.32 187.64,124.73 C4035.2 C4034.2 ; v1(183.44,109.87) 186.49,109.87 v1(187.76,108.6) 190.68,108.6 191.34,109.27 194.39,109.27 196.91,111.78 R4306.2 ; v1(169.6,114.83) 167.85,114.83 166.86,115.82 Q4002.2 164.98,115.82 164.6,116.2 164.6,117.42 164.09,117.93 159.39,117.93 155.45,121.86 155.45,126.18 160.2,130.93 v1(160.2,131.46) ; L4206.2 v1(163.63,139.85)
  IN1 w0.508: v1(187.76,108.6) 187.76,109.54 189.71,111.49 v1(189.71,111.74)
  IN2 w0.508: v1(160.2,131.46) 160.2,132.61 163.63,136.04 v1(163.63,139.85) ; v1(176.28,126.56) 176.28,126.49 174.17,124.38 174.17,122.19 172.52,120.54 172.52,119.53 170.11,117.11 170.11,116.22 169.6,115.72 v1(169.6,114.83) 169.6,114.19 171.29,112.51 v1(171.29,111.78)
  IN3 w0.508: v1(187.23,124.04) 187.23,125.14 186.62,125.75 184.71,125.75 183.19,127.27 177,127.27 v1(176.28,126.56) ; v1(187.76,108.6) 187.76,107.97 183.7,103.91 176.59,103.91 173.35,107.14 173.35,107.94 171.29,110 v1(171.29,111.78)
  BOTTOM w0.279: v1(183.44,109.87) 183.57,109.75 183.57,109.11 183.83,108.86 Q4302.2 ; Q4302.5 187.51,108.86 v1(187.76,108.6)
  BOTTOM w0.508: R4203.2 173.17,110.63 172.01,111.78 v1(171.29,111.78) ; R4331.1 R4330.1 161.83,127.4 160.2,129.03 v1(160.2,131.46)
+3V_MAIN_EN: length 42.2
  TOP w0.127: v1(188.91,111.78) 188.91,111.77 187.52,110.38 183.19,110.38 181.69,108.88 175.85,108.88 173.79,106.83 170.36,106.83 169.7,107.49 167.77,107.49 167.43,107.83 R4001.2 165.92,108.35 v1(165.49,108.78) 165.16,109.11 Q4001.2
  IN1 w0.089: v1(187.23,123.2) 187.23,122.98 188.47,121.74 188.47,120.22 189.79,118.9 189.79,114.82 188.91,113.94 v1(188.91,111.78)
  BOTTOM w0.127: v1(188.91,111.78) 188.91,111.53 R4320.1
  BOTTOM w0.152: v1(187.23,123.2) 187.23,123.24 U3002.L7
+3V_PCH_ME: length 7
  TOP w0.508: R649.1 179.84,51.29 v1(179.84,51.84)
  IN1 w0.508: v1(179.84,51.84) 179.84,51.51 180.14,51.2 182.78,51.2 183.22,51.63 v1(183.22,52.6)
  BOTTOM w0.508: U41.8 182.56,57.17 v1(182.3,56.92)
  vias: v1(183.32,55.01)
+3V_RTC: length 263.3
  TOP w0.635: v2(220.66,69.11) R719.1 219.9,70.36 R756.2 ; v2(90.86,39.19) 90.86,38.63 92.89,36.6 116.52,36.6 120.45,32.66 148.9,32.66 153.98,37.74 155.5,37.74 156.65,38.88 156.65,39.9 157.13,40.38 157.13,42.92 157.82,43.61 157.82,44.75 158.26,45.2 158.26,52.97 158.4,53.11 158.4,64.73 156.56,66.57 155.25,66.57 153.6,68.22 153.6,70.38 155.38,72.16 158.32,72.16 v2(160.1,73.93) 160.89,73.15 164.42,73.15 165.44,72.13 168.81,72.13 171.12,69.82 172.42,69.82 175.78,66.45 182.34,66.45 v1(185.52,63.27) ; R249.2 129.7,101.38 129.7,99.87 135.06,94.51 135.06,92.86 139.51,88.4 142.04,88.4 142.43,88.02 142.79,88.02 145.29,85.52 158.2,85.52 v2(158.68,86) ; R252.2 v2(159.44,91.84)
  IN1 w0.635: v2(90.86,39.19) 90.86,39.52 90.2,40.18 80.42,40.18 78.92,41.68 77.78,41.68 v2(76.64,42.82)
  IN2 w0.635: v2(160.1,73.93) 159.34,74.7 159.34,85.34 v2(158.68,86) 159.44,86.76 v2(159.44,91.84)
  IN3 w0.635: v1(185.52,63.27) 186.23,62.56 186.23,61.65 189.95,57.93 193.73,57.93 194.47,57.2 207.98,57.2 216.59,65.81 217.73,65.81 219.64,67.71 219.64,68.09 v2(220.66,69.11)
