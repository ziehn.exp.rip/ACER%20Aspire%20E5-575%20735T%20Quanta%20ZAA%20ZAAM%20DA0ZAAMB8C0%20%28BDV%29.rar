# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCGT on IN3 (solid shape): outline of 1880 points within 87.71,107.72 125.32,119.32
+VCCHDA on IN1 (solid shape): outline of 563 points within 124.94,99.4 130.14,109.1
+VCCIO on TOP (solid shape): 116.47,110.68 116.48,110.66 116.48,110.12 116.8,109.8 116.8,109.47 116.68,109.35 115.62,109.35 115.03,109.94 115.03,110.62 115.13,110.72 116.43,110.72
+VCCIO on TOP (solid shape): outline of 173 points within 122.78,106.81 125.75,109.48
+VCCIO on BOTTOM (solid shape): 80.35,96.9 80.35,93.22 80.22,93.09 76.99,93.09 76.92,93.16 76.92,96.53 77.41,97.02 80.23,97.02
+VCCIO on BOTTOM (solid shape): 93.15,105.18 93.15,104.41 92.26,103.52 89.8,103.52 89.72,103.53 89.63,103.52 88.83,103.52 88.32,104.03 88.32,104.79 88.83,105.3 93.02,105.3
+VCCIO on IN1 (solid shape): outline of 198 points within 110.42,118.26 112.71,121.81
+VCCIO on IN2 (solid shape): outline of 5286 points within 77.91,94.25 125.79,110.26
+VCCOPC on TOP (solid shape): 95,110.8 95.01,110.8 95.05,110.76 95.05,110.55 95.03,110.52 95,110.52 94.99,110.52 94.9,110.53 94.8,110.51 94.4,110.51 94.39,110.51 94.28,110.53 94.17,110.51 94.16,110.51 94,110.51 93.9,110.4 93.9,109.81 92.48,108.38 92.48,108.22 92.27,108.01 89.95,108.01 89.77,108.2 89.77,108.53 90.1,108.86 90.13,108.86 90.39,109.11 91.45,109.11 92,109.67 92,110.64 92.12,110.75 92.14,110.75 92.18,110.79 92.2,110.81 92.22,110.81 94.99,110.81
+VCCOPC on BOTTOM (solid shape): 74.48,104.41 74.48,98.95 74.35,98.83 72.32,98.83 71.94,99.21 71.94,100.98 71.43,101.49 71.43,104.16 72.07,104.79 74.1,104.79
+VCCOPC on BOTTOM (solid shape): 106.78,116.82 106.78,113.21 105.94,112.38 105.78,112.38 105.69,112.46 105.69,112.61 106.27,113.19 106.27,114.05 106.12,114.2 105.79,114.2 105.69,114.3 105.69,114.43 105.8,114.53 105.96,114.53 106.27,114.85 106.27,115.83 106.06,116.03 105.79,116.03 105.7,116.12 105.7,116.28 106.32,116.9 106.69,116.9
+VCCOPC on IN2 (solid shape): outline of 1395 points within 70.92,102.13 107.33,115.67
+VCCOPC_SW on BOTTOM (solid shape): 59.26,88.46 59.26,85.44 59.06,85.24 55.3,85.24 54.01,83.94 53.99,83.94 53.98,83.93 53.98,83.21 54.01,83.19 54.01,82.44 53.96,82.39 53.73,82.39 53.7,82.42 53.7,83.19 53.73,83.21 53.73,83.93 53.72,83.93 53.22,84.42 53.22,88.16 53.78,88.72 59.01,88.72
+VCCOPC_VBST on BOTTOM (solid shape): 56.33,84.99 56.33,84.19 56.29,84.14 55.12,84.14 54.51,83.54 54.51,83.26 54.49,83.23 54.28,83.23 54.24,83.25 54.23,83.28 54.23,83.89 54.24,83.93 54.28,83.94 54.39,83.94 55.45,85.01 56.32,85.01
+VCCPRIM_3P3 on IN1 (solid shape): outline of 537 points within 128.58,109.24 138.36,111.78
+VCCPRTC on IN1 (solid shape): 129.72,107.84 129.72,107.46 129.66,107.4 129.63,107.39 129.61,107.4 129.29,107.39 129.11,107.12 129.11,107.1 128.75,106.74 128.72,106.73 128.69,106.73 128.31,106.68 128.2,106.31 128.2,106.3 128.2,105.87 128.19,105.8 128.07,105.68 127.69,105.68 127.56,105.81 127.56,106.83 127.61,106.87 127.63,106.88 127.87,106.98 127.97,107.21 127.97,107.23 128.07,107.33 128.45,107.33 128.59,107.47 128.6,107.48 128.74,107.56 128.82,107.69 128.82,107.7 129.09,107.97 129.6,107.97
+VCCSA on TOP (solid shape): outline of 1291 points within 124.14,107.59 153.12,147.24
+VCCSA on BOTTOM (solid shape): 152.75,148.01 155.54,148.01 155.86,147.7 155.86,143.33 154.76,142.22 148.48,142.22 147.38,143.33 147.38,147.09 147.61,147.31 150.09,147.31 150.5,146.91 150.5,145.24 151.06,145.24 151.06,145.56 151.09,145.59 151.09,147.37 151.75,148.03 152.74,148.03
+VCCSA on BOTTOM (solid shape): outline of 84 points within 125.32,107.96 127.44,109.84
+VCCSA on BOTTOM (solid shape): outline of 253 points within 123.37,117.24 127.82,120.29
+VCCSA on SVCC (solid shape): 146.16,149.42 146.16,148.16 146.19,147.96 146.31,147.79 146.81,147.29 146.98,147.17 147.18,147.14 147.85,147.14 148.05,147.17 148.22,147.29 149.23,148.3 149.35,148.47 149.38,148.67 149.38,149.36 149.64,149.63 152.37,149.63 153.47,148.53 153.47,139.17 144.12,129.81 136.46,129.81 136.26,129.78 136.1,129.67 129.87,123.44 129.76,123.27 129.72,123.08 129.72,120.92 129.79,120.67 129.98,120.48 129.98,107.82 129.62,107.46 127.91,107.46 127.63,107.59 127.35,107.46 126.99,107.46 126.71,107.59 126.44,107.46 126.02,107.46 125.84,107.51 125.65,107.46 125.03,107.46 124.74,107.44 124.56,107.23 124.16,106.83 124.1,106.83 123.98,106.85 123.86,106.83 123.36,106.83 123.32,106.87 123.4,107.24 123.12,107.49 123.12,108.24 123.45,108.62 123.12,109 123.12,120.87 123.41,121.23 123.12,121.59 123.12,121.86 123.45,122.13 123.31,122.53 123.88,123.1 124.32,123.19 124.52,123.59 124.52,130.24 131.2,136.93 139.75,136.93 139.95,136.96 140.12,137.07 143.42,140.38 143.53,140.54 143.57,140.74 143.57,148.53 144.43,149.39 144.84,149.29 145.09,149.63 145.95,149.63
+VCCSTG on TOP (solid shape): outline of 191 points within 127.82,119.21 130.23,124.73
+VDDQ on TOP (solid shape): 41.59,56.97 41.59,56.64 41.08,56.13 40.52,56.13 40.42,56.23 40.42,57.55 40.49,57.63 40.93,57.63
+VDDQ on IN2 (solid shape): 115.33,59.96 115.49,59.92 115.64,59.96 115.65,59.96 116.64,59.96 117.15,59.46 117.15,58.69 117.02,58.57 116.13,58.57 116.01,58.69 116.01,59.07 115.88,59.2 115.79,59.2 115.77,59.21 115.75,59.22 115.52,59.32 115.24,59.23 115.21,59.24 115.12,59.33 115.12,59.84 115.25,59.96 115.32,59.96
+VDDQ on IN3 (solid shape): 41.73,56.95 41.73,55.4 41.64,55.32 40.98,55.32 40.93,55.37 40.93,56.99 40.98,57.04 41.64,57.04
+VDDQC on TOP (solid shape): 117.95,108.97 117.95,108.42 117.95,108.4 117.94,108.39 117.59,108.04 117.54,108.04 117.52,108.02 117.52,107.41 117.7,107.41 117.84,107.27 117.84,107.03 117.72,106.9 117.7,106.89 117.68,106.89 117.37,106.89 117.06,107.19 117.06,108.42 116.97,108.52 116.24,108.52 116.17,108.59 116.17,108.97 116.3,109.1 117.82,109.1
+VIN_VCCGT on TOP (solid shape): 135.44,161.01 135.44,159 135.31,158.87 132.24,158.87 132.01,159.1 128.91,159.1 128.9,159.09 128.57,159.09 128.48,159.18 128.48,160.55 128.53,160.6 130.92,160.6 131.68,161.36 135.08,161.36
+VIN_VCCGT on TOP (solid shape): 125.46,160.7 125.46,159.54 125.38,159.42 125.35,159.25 125.34,159.24 125.25,159.15 118.88,159.15 118.79,159.24 118.79,160.4 119.02,160.62 121.27,160.62 122.13,161.49 124.67,161.49
+VIN_VCCGT on BOTTOM (solid shape): 125.44,160.71 125.44,159.52 125.38,159.41 125.35,159.27 125.35,159.24 125.25,159.15 118.83,159.15 118.79,159.17 118.78,159.2 118.78,159.53 118.67,159.63 118.6,159.63 118.6,159.64 118.06,159.64 118.04,159.66 118.04,159.85 118.05,159.88 118.09,159.9 118.61,159.9 118.78,160.07 118.78,160.57 118.79,160.61 118.83,160.62 121.27,160.62 122.15,161.51 124.64,161.51
+VIN_VCCGT on BOTTOM (solid shape): 135.86,161.77 135.86,160.74 135.54,160.42 135.54,159.05 135.39,158.9 132.24,158.9 132.04,159.1 128.5,159.1 128.47,159.11 128.45,159.15 128.45,159.51 128.35,159.61 127.77,159.61 127.73,159.62 127.72,159.66 127.72,159.81 127.73,159.84 127.77,159.86 128.29,159.86 128.29,159.86 128.38,159.86 128.45,159.94 128.45,160.55 128.47,160.58 128.5,160.6 130.89,160.6 132.19,161.89 135.73,161.89
+VIN_VCCGT on IN1 (solid shape): outline of 300 points within 118.6,158.95 133.38,164.13
AVCC33 on TOP (solid shape): 26.33,66.96 26.33,66.16 26.47,66.01 26.47,65.3 26.6,65.17 26.6,64.03 26.35,63.77 25.71,63.77 25.46,64.03 25.46,64.86 25.46,64.87 25.6,65.08 25.64,65.3 25.64,66.25 25.57,66.53 25.36,66.74 25.3,66.79 25.3,67.03 25.32,67.04 26.26,67.04
DVDD_IO on BOTTOM (solid shape): 207.31,50.45 207.31,47.09 207.29,47.02 207.22,46.98 207.01,46.9 206.89,46.72 206.89,46.71 206.41,46.23 206.13,46.23 205.98,46.38 205.98,46.48 206.01,46.53 206.02,46.53 206.12,46.61 206.16,46.72 206.16,46.74 206.38,46.96 206.38,48.53 206.51,48.81 206.38,49.1 206.38,49.8 205.92,50.26 205.92,50.44 206.12,50.63 207.13,50.63
GND on TOP (solid shape): 18.22,40.66 18.22,38.75 18.09,38.63 16.19,38.63 15.8,39.01 15.8,40.41 16.19,40.79 18.09,40.79
GND on TOP (solid shape): 45.14,78.25 45.14,77.49 44.89,77.24 42.86,77.24 42.73,77.36 42.73,78 43.11,78.38 45.01,78.38
GND on TOP (solid shape): 60.86,73.63 60.86,72.03 60.13,71.29 57.71,71.29 57.38,71.62 57.38,73.38 57.74,73.73 60.76,73.73
GND on TOP (solid shape): 66.76,67.69 66.76,66.16 66.6,66.01 64.37,66.01 64.12,66.26 64.12,67.71 64.27,67.86 66.58,67.86
GND on TOP (solid shape): 123.73,31.31 123.73,30.3 120.02,26.59 119.11,26.59 118.62,27.07 118.62,30.86 119.21,31.44 123.6,31.44
GND on TOP (solid shape): 130.87,141.12 130.87,140.35 130.36,139.85 125.91,139.85 125.66,140.1 125.66,140.99 125.91,141.24 130.74,141.24
GND on TOP (solid shape): 148.75,30.27 148.75,29.89 147.76,28.9 125.35,28.9 125.15,29.1 125.15,29.71 125.89,30.45 148.57,30.45
GND on TOP (solid shape): 200.74,60.75 200.74,59.48 200.64,59.38 199.12,59.38 198.94,59.56 198.94,60.78 199.12,60.95 200.54,60.95
GND on TOP (solid shape): 84.51,86.89 84.51,86.02 83.93,85.44 82.09,85.44 81.93,85.6 81.93,87.21 82.38,87.65 83.75,87.65
GND on TOP (solid shape): 71.71,58.34 71.71,56.61 71.41,56.31 67.6,56.31 67.39,56.51 67.39,58.44 67.6,58.64 71.41,58.64
GND on TOP (solid shape): 87.94,81.05 87.94,66.95 87.69,66.69 84.38,66.69 80.19,70.89 80.19,75.46 82.35,77.62 82.35,80.92 83.24,81.81 87.18,81.81
GND on TOP (solid shape): 175.44,117.24 175.44,110.02 175.31,109.89 174.05,109.89 173.79,110.15 173.79,116.23 173.86,116.29 173.86,117.18 174.05,117.37 175.32,117.37
GND on TOP (solid shape): 43.44,50.77 43.44,46.25 43.16,45.97 38.59,45.97 38.33,46.22 38.33,46.91 38.44,47.01 40.6,47.01 40.6,50.79 40.75,50.95 43.26,50.95
GND on TOP (solid shape): 63.96,96.31 63.96,94.05 63.2,93.29 59.98,93.29 58.96,94.3 58.96,96.16 59.57,96.77 63.51,96.77
GND on TOP (solid shape): 24.44,53.74 24.95,53.74 25.2,53.49 25.2,52.98 24.12,51.9 23.9,51.9 23.83,51.84 23.17,51.84 23.04,51.96 23.04,53.99 23.17,54.12 24.06,54.12
GND on TOP (solid shape): 26.09,28.16 26.09,24.66 25.96,24.53 24.77,24.53 24.54,24.76 24.54,27.6 24.87,27.93 24.87,28.39 25.05,28.57 25.69,28.57
GND on TOP (solid shape): 38.85,109.68 38.85,108.95 40.82,106.98 40.82,104.54 40.57,104.29 38.79,104.29 38.03,105.05 38.03,106.95 36.89,108.1 36.89,110.13 37.01,110.26 38.28,110.26
GND on TOP (solid shape): 58.6,49.22 59.44,49.22 59.67,49.45 60.61,49.45 60.66,49.4 60.66,46.78 60.13,46.25 58.98,46.25 56.37,48.86 56.37,49.37 56.83,49.83 57.99,49.83
GND on TOP (solid shape): 64.73,81.12 64.73,76.32 64.45,76.04 61.58,76.04 61.37,76.25 61.37,78.99 63.68,81.3 64.55,81.3
GND on TOP (solid shape): 72.28,77 72.55,76.95 73.49,76.02 73.49,73.27 72.98,72.77 69.91,72.77 69.7,72.97 69.7,76.75 70.01,77.06 72.01,77.06
GND on TOP (solid shape): 222.71,172.87 223.91,172.87 223.96,172.82 223.96,171.9 222.61,170.56 219.59,170.56 219.41,170.73 219.41,172.38 220.38,173.35 222.23,173.35
GND on TOP (solid shape): 112.83,141.12 112.83,134.39 113.09,134.13 113.09,133.37 112.96,133.24 110.8,133.24 110.55,133.5 110.55,133.75 111.05,134.26 111.05,141.12 111.44,141.5 112.45,141.5
GND on TOP (solid shape): 117.4,158.64 117.4,156.69 117.21,156.5 115.87,156.5 115.63,156.74 115.63,158.64 115.88,158.9 117.15,158.9
GND on TOP (solid shape): 35.74,99.97 35.74,98.04 35.9,97.89 40.54,97.89 40.65,97.78 40.65,97.07 40.57,97 36.35,97 36.28,96.92 35.11,96.92 34.35,97.68 34.35,99.84 34.6,100.1 35.62,100.1
GND on TOP (solid shape): 115.12,132.73 115.12,129.81 114.99,129.69 112.45,129.69 111.82,129.05 111.44,129.05 111.18,129.31 111.18,132.61 111.31,132.73 113.09,132.73 113.72,133.37 114.48,133.37
GND on TOP (solid shape): 145.93,36.24 146.72,36.24 146.94,36.01 146.94,34.67 146.72,34.44 120.78,34.44 119.89,35.32 119.89,35.76 119.97,35.83 128.35,35.83 129.62,37.1 145.07,37.1
GND on TOP (solid shape): 148.9,172.1 148.9,171.72 148.39,171.22 148.39,170.33 147.63,169.56 147.63,168.04 147.5,167.91 146.41,167.91 146.31,168.02 146.31,172 146.54,172.23 148.77,172.23
GND on TOP (solid shape): 85.73,84.17 85.73,82.54 85.63,82.44 82.28,82.44 81.84,82.87 81.84,83.36 82.84,83.36 83.19,83.71 83.19,84.17 83.22,84.2 84.38,84.2 84.56,84.37 84.56,84.6 84.71,84.75 85.15,84.75
GND on TOP (solid shape): 139.25,133.24 139.25,133.05 139.23,133.02 139.2,133 133.57,133 132.86,132.29 132.44,132.29 132.41,132.31 132.39,132.34 132.39,133.24 132.52,133.37 139.12,133.37
GND on TOP (solid shape): 169.83,181.55 169.83,179.9 169.73,179.8 168.81,179.8 168.69,179.67 168.69,178.12 168.27,177.71 165.3,177.71 165.08,177.92 164.6,177.92 164.37,178.15 164.37,178.53 165.16,179.32 165.89,179.32 165.94,179.37 165.94,179.38 166.17,179.61 166.17,180.79 166.99,181.6 169.78,181.6
GND on TOP (solid shape): 54.23,63.19 54.92,63.19 55.43,62.68 56.7,62.68 57.03,62.35 57.03,61.92 56.89,61.78 56.89,61.21 57.35,60.75 58.12,60.75 58.88,59.99 58.88,58.24 58.59,57.94 53.87,57.94 52.58,59.23 52.58,63.24 52.74,63.39 54.03,63.39
GND on TOP (solid shape): 93.73,108.61 93.73,108.55 93.73,108.54 93.69,108.39 93.73,108.23 93.73,108.22 93.73,106.17 93.56,106 90.23,106 89.45,106.77 89.45,107.4 89.9,107.84 92.49,107.84 92.69,108.05 92.69,108.2 93.17,108.67 93.67,108.67
GND on TOP (solid shape): 156.71,51.84 156.75,51.82 156.76,51.79 156.76,47.7 156.75,47.66 156.71,47.64 156.14,47.64 156.01,47.77 156.01,48.66 155.76,48.91 155.76,51.2 155.63,51.33 155.63,51.79 155.65,51.82 155.68,51.84
GND on TOP (solid shape): 196.54,78.87 196.54,76.51 197.73,75.32 197.73,74.07 197.26,73.6 196.88,73.6 196.51,73.24 196.51,61.09 195.89,60.47 192.59,60.47 192.08,60.98 192.08,69.96 191.76,70.28 191.76,72.27 192.11,72.61 192.65,72.61 193.01,72.97 193.01,75.61 191.89,76.73 191.89,77.77 191.92,77.8 191.92,79.11 192.13,79.32 196.09,79.32
GND on TOP (solid shape): 147.96,158.03 149.13,158.03 149.36,157.8 149.36,154.58 149.28,154.5 146.44,154.5 145.88,153.94 145.88,150.87 145.32,150.31 142.7,150.31 142.02,151 142.02,154.58 141.66,154.93 141.66,156.23 141.23,156.66 138.11,156.66 138.05,156.71 138.05,157.55 138.13,157.63 139.1,157.63 139.38,157.91 139.38,158.54 139.53,158.69 147.3,158.69
GND on TOP (solid shape): 95.83,111.62 95.84,111.61 95.84,111.59 95.84,111.08 95.69,110.93 95.05,110.93 95.04,110.94 92.69,110.94 92.62,110.98 92.54,111 92.24,111 92.19,110.99 92.14,110.98 92.11,110.97 92.09,110.99 91.94,111.13 91.94,111.52 92.25,111.83 95.62,111.83
GND on TOP (solid shape): 100.41,117.75 102.04,117.75 102.11,117.83 102.52,117.83 102.62,117.72 102.62,116.81 102.29,116.48 99.5,116.48 98.48,115.46 96.7,115.46 96.45,115.21 92.64,115.21 92.39,115.46 91.12,115.46 90.86,115.72 90.86,116.48 90.99,116.61 94.42,116.61 94.8,116.99 98.74,116.99 99.75,118 100.16,118
GND on TOP (solid shape): 132.9,130.45 132.9,130.22 132.62,129.94 132.26,129.94 132.01,129.69 132.01,129.18 131.76,128.92 131.5,128.92 131.45,128.88 131.44,128.87 131.34,128.82 131.28,128.72 131.28,128.7 131.25,128.67 131.25,128.54 131.12,128.42 130.87,128.42 130.68,128.61 130.68,130.14 131.11,130.58 132.77,130.58
GND on TOP (solid shape): 203,192.42 203,191.15 203.38,190.77 203.76,190.77 203.87,190.67 203.86,190.64 203.84,190.48 203.89,190.33 203.89,189.67 203.88,189.66 203.88,188.22 203.46,187.8 201.61,187.8 201.61,192.3 201.86,192.55 202.88,192.55
GND on TOP (solid shape): 53.35,81.73 54.59,81.73 54.72,81.6 54.72,80.51 54.67,80.46 52.46,80.46 52.27,80.27 51.2,80.27 51.06,80.13 50.65,80.13 50.3,79.78 50.3,79.37 49.92,78.99 47.94,78.99 47.61,79.32 47.61,80.46 47.86,80.72 49.13,80.72 49.41,80.64 49.67,80.8 51.01,82.14 52.94,82.14
GND on TOP (solid shape): 128.75,113.54 128.75,112.18 128.12,111.56 128.12,111.52 128.11,111.51 128.11,110.75 128.12,110.74 128.12,110.72 128.49,110.35 128.49,109.4 128.43,109.34 128.38,109.34 128.38,109.34 128.14,109.35 127.95,109.22 127.93,109.21 127.91,109.2 127.75,109.2 127.6,109.35 127.6,113.16 127.35,113.42 127.35,113.92 127.48,114.05 128.24,114.05
GND on TOP (solid shape): 142.04,96.67 142.04,95.53 142.04,95.52 141.86,94.33 142.02,93.13 142.02,93.09 142.01,93.07 141.92,92.98 140.46,92.98 140.42,93 140.4,93.03 140.4,96.5 140.4,96.51 140.4,96.55 140.65,96.79 141.92,96.79
GND on TOP (solid shape): 143.19,128.92 143.19,128.04 143.06,127.91 142.42,127.91 141.92,127.4 136.45,127.4 136.2,127.65 136.2,128.53 136.72,129.05 137.04,129.05 137.06,129.05 137.2,128.95 137.34,128.92 138.23,128.92 138.53,129.07 138.6,129.39 138.6,129.4 138.61,129.43 138.74,129.56 142.55,129.56
GND on TOP (solid shape): 12.09,85.36 12.12,85.35 12.14,85.33 12.5,85.06 12.87,85.33 12.89,85.35 12.92,85.36 14.66,85.36 15.04,84.98 15.04,83.97 14.79,83.71 13.52,83.71 13.01,84.22 9.2,84.22 8.95,84.47 8.95,85.11 9.2,85.36
GND on TOP (solid shape): 125.48,158.87 127.97,158.87 128.1,158.74 129.06,158.74 129.09,158.77 132.01,158.77 132.21,158.57 135.59,158.57 136.18,157.98 136.7,157.98 136.77,157.91 136.77,157.89 137.17,157.5 137.17,154.43 136.45,153.72 132.16,153.72 132.04,153.84 132.04,155.77 131.53,156.28 130.46,156.28 130,155.82 127.34,155.82 127.18,155.98 125.53,155.98 125.02,155.47 125.02,155.09 124.44,154.5 122.87,154.5 122.69,154.68 122.69,156.15 122.31,156.53 121.09,156.53 120.86,156.31 119.72,156.31 119.36,156.66 119.36,158.77 119.54,158.95 125.41,158.95
GND on TOP (solid shape): 167.57,122.7 167.57,122.35 167.55,122.34 167.55,121.8 168.09,121.8 168.11,121.81 170.11,121.81 171.13,120.8 171.13,118.64 170.11,117.62 167.82,117.62 167.06,118.38 165.92,118.38 165.54,118.76 165.54,120.8 165.28,121.05 165.28,122.07 165.41,122.19 166.3,122.19 167.06,122.96 167.32,122.96
GND on TOP (solid shape): 134.29,87.15 134.29,85.71 134.07,85.49 132,85.49 131.79,85.71 130.71,85.71 130.19,85.19 130.19,83.25 130.82,82.62 130.92,82.5 131.01,82.43 131.06,82.38 131.24,82.37 131.33,82.38 131.43,82.38 131.69,82.64 131.69,82.97 132.05,83.33 133.92,83.33 134.11,83.14 134.11,82.62 134.12,82.5 134.17,82.39 134.17,81.3 133.41,80.54 131.04,80.54 129.57,82.01 129.57,86.13 131.73,88.28 133.15,88.28
GND on TOP (solid shape): 117.66,117.27 117.66,115.08 116.9,114.32 116.9,113.3 117.15,113.05 117.53,113.05 117.66,112.92 117.66,109.99 117.84,109.81 117.84,109.46 117.75,109.36 117.26,109.36 117,109.62 117,109.82 116.62,110.21 116.62,110.75 116.41,110.95 115.26,110.95 115.25,110.94 114.81,110.94 114.78,110.9 114.78,110.65 114.62,110.5 112.06,110.5 112.06,110.5 111.19,110.5 111.08,110.61 111.08,111.65 111.31,111.88 111.31,111.91 111.44,112.03 114.48,112.03 114.7,112.25 114.7,115.3 114.86,115.46 115.12,115.46 115.37,115.72 115.37,116.73 115.25,116.86 114.93,116.86 114.8,116.99 114.8,117.45 114.88,117.53 115.25,117.53 115.59,117.88 117.05,117.88
GND on TOP (solid shape): 166.93,138.83 166.93,138.81 167.05,138.7 167.05,137.17 167.3,136.92 167.3,136.89 167.32,136.87 167.32,131.97 167.19,131.85 165.16,131.85 164.14,132.86 164.14,133.7 164.29,133.7 164.3,133.64 164.31,133.59 164.33,133.54 164.36,133.49 164.39,133.45 164.43,133.41 164.48,133.37 164.52,133.35 164.58,133.33 164.63,133.32 164.69,133.32 164.74,133.32 164.8,133.34 164.85,133.36 164.9,133.39 164.94,133.42 164.98,133.47 165.01,133.51 165.03,133.56 165.05,133.62 165.06,133.67 165.06,133.73 165.05,133.78 165.03,133.84 165.01,133.89 164.98,133.93 164.94,133.98 164.9,134.01 164.85,134.04 164.8,134.06 164.74,134.08 164.69,134.08 164.63,134.08 164.58,134.07 164.52,134.05 164.48,134.03 164.43,133.99 164.39,133.95 164.36,133.91 164.33,133.86 164.31,133.81 164.3,133.76 164.29,133.7 164.14,133.7 164.14,137.81 165.28,138.96 166.81,138.96
GND on TOP (solid shape): 180.65,116.73 180.65,111.28 180.59,111.02 180.65,110.77 180.65,110.75 180.65,110.65 180.62,110.59 180.61,110.54 180.53,110.47 180.43,110.5 179.89,110.54 179.86,109.99 179.84,109.91 179.76,109.87 179.13,109.87 178.87,110.13 178.87,116.99 179,117.11 180.27,117.11
GND on TOP (solid shape): 120.36,106.76 121.99,106.76 122.08,106.74 122.16,106.74 122.18,106.74 122.2,106.73 122.35,106.58 122.35,105.69 122.19,105.54 122.11,105.54 121.91,105.54 121.76,105.69 121.76,105.97 121.48,106.25 120.67,106.25 120.59,106.18 120.59,104.45 120.44,104.3 120.19,104.3 119.98,104.5 119.98,105.92 119.68,106.23 119.25,106.23 119.12,106.1 119.12,105.89 119.11,105.82 119.04,105.75 118.33,105.75 117.82,106.25 117.49,106.25 117.47,106.27 117.45,106.31 117.43,106.34 117.41,106.36 117.41,106.41 117.39,106.44 117.39,106.59 117.41,106.63 117.41,106.66 117.42,106.69 117.49,106.76 117.69,106.76 120.29,106.76
GND on TOP (solid shape): 134.3,127.27 134.3,126.51 134.8,126 134.8,124.91 134.62,124.73 134.3,124.73 134.27,124.74 134.26,124.77 134.16,124.93 133.99,125.03 133.97,125.08 134.08,125.72 133.5,125.72 133.47,125.72 133.44,125.72 133.23,125.85 133,125.82 132.97,125.82 132.94,125.83 132.91,125.87 132.9,125.9 132.9,127.15 133.15,127.4 134.17,127.4
GND on TOP (solid shape): 10.47,44.83 10.47,44.52 10.65,44.34 12.63,44.34 13.39,43.58 13.39,40.79 14.79,39.39 14.79,37.99 13.9,37.1 12.38,37.1 12.38,38.6 11.58,39.62 10.39,39.11 2.31,39.11 2.31,39.16 2.31,42.24 2.31,42.29 8.75,42.29 9.45,42.69 9.46,43.49 9.46,45 10.3,45
GND on TOP (solid shape): 58.6,28.98 58.6,28.95 59.07,28.48 60.57,28.48 62.76,26.3 62.76,25.2 62.21,24.66 55.17,24.66 54.92,24.91 54.92,27.1 57.14,27.1 57.14,27.03 57.16,26.97 57.17,26.91 57.2,26.85 57.24,26.79 57.28,26.74 57.32,26.7 57.37,26.66 57.43,26.63 57.49,26.6 57.55,26.58 57.62,26.57 57.68,26.57 57.74,26.58 57.81,26.59 57.87,26.61 57.93,26.64 57.98,26.68 58.03,26.72 58.07,26.77 58.11,26.82 58.14,26.88 58.16,26.94 58.18,27 58.19,27.06 58.19,27.13 58.18,27.19 58.16,27.26 58.14,27.32 58.11,27.37 58.07,27.42 58.03,27.47 57.98,27.51 57.93,27.55 57.87,27.58 57.81,27.6 57.74,27.61 57.68,27.62 57.62,27.62 57.55,27.61 57.49,27.59 57.43,27.57 57.37,27.53 57.32,27.49 57.28,27.45 57.24,27.4 57.2,27.34 57.17,27.29 57.16,27.22 57.14,27.16 57.14,27.1 54.92,27.1 54.92,28.39 55.35,28.82 56.5,28.82 56.83,29.15 56.83,29.92 56.95,30.04 57.54,30.04
GND on TOP (solid shape): 14.92,26.31 14.92,20.85 14.53,20.47 12.38,20.47 12.38,22 11.58,23.02 10.39,22.51 9.61,22.51 2.36,22.51 2.31,22.51 2.31,22.56 2.31,24.44 2.31,24.49 10.39,24.49 11.58,23.98 12.38,25 12.38,26.56 14.66,26.56
GND on TOP (solid shape): 140.99,124.73 141.01,124.73 141.03,124.72 141.03,124.35 141.04,124.27 141.06,124.19 141.03,124.12 140.96,124.1 140.77,124.1 140.14,123.46 140.14,123.24 140.14,123.24 140.14,121.56 139.88,121.3 139.88,121.23 139.87,121.19 139.83,121.18 139.57,121.18 139.5,121.21 139.47,121.29 139.45,121.51 139.34,121.7 139.11,121.92 139.01,121.92 139.01,121.93 137.77,121.93 137.7,121.96 137.67,122.03 137.26,122.52 136.76,122.12 136.76,122.1 136.72,122.07 136.58,122.07 136.33,122.32 136.2,122.32 135.82,122.7 135.82,123.21 136.96,124.35 140.26,124.35 140.29,124.38 140.41,124.38 140.58,124.44 140.64,124.6 140.64,124.73 140.65,124.73
GND on TOP (solid shape): 146.74,57.8 146.74,51.71 146.61,51.58 145.6,51.58 145.09,52.09 145.09,52.94 145.1,52.96 145.11,52.98 145.4,52.98 145.78,53.36 145.4,53.74 145.11,53.74 145.1,53.76 145.09,53.78 145.09,56.59 145.13,56.67 145.22,56.69 145.89,56.94 145.22,57.19 145.13,57.21 145.09,57.29 145.09,57.86 145.13,57.94 145.22,57.96 145.71,57.88 145.86,58.36 145.89,58.42 145.96,58.44 146.11,58.44
GND on TOP (solid shape): 6.14,73.56 6.14,72.92 9.7,69.36 13.77,69.36 16.82,66.31 16.82,61.74 12.12,57.04 11.16,57.04 10.12,56 9.47,56 9.47,57.53 9.44,58.32 8.75,58.71 2.36,58.71 2.32,58.72 2.31,58.76 2.31,60.64 2.31,60.66 2.33,60.68 3.78,61.89 6.1,61.89 7.61,63.4 6.1,64.91 3.73,64.91 3.53,65.11 3.53,67.85 3.58,67.94 4.65,67.99 5.13,68.85 5.13,73.54 5.26,73.68 6.03,73.68
GND on TOP (solid shape): 12.27,121.18 12.35,121.15 12.38,121.07 12.4,120.93 12.47,120.8 12.49,120.73 12.47,120.67 12.4,120.28 12.71,120.04 12.74,120.02 12.76,119.99 12.76,119.91 12.74,119.88 12.73,119.87 12.51,119.61 12.6,119.28 12.62,119.21 12.6,119.14 12.51,118.81 12.73,118.54 12.74,118.54 12.76,118.51 12.76,116.49 12.61,116.35 12.59,116.34 12.58,116.35 12.12,115.95 12.62,115.61 12.71,115.59 12.76,115.51 12.76,114.96 12.7,114.82 12.69,114.66 12.69,114.64 12.68,114.62 12.5,114.45 11.36,114.45 11.23,114.57 11.23,120.9 11.23,120.92 11.49,121.18
GND on TOP (solid shape): outline of 98 points within 38.13,54.2 43.77,62.25
GND on TOP (solid shape): 13.31,97.42 13.32,97.4 13.32,97.37 15.93,94.76 15.93,91.08 15.68,90.82 9.84,90.82 8.57,89.55 8.57,86.13 7.68,85.24 6.65,85.24 6.14,84.73 6.14,82.19 6.02,82.06 5.25,82.06 5.13,82.19 5.13,89.45 4.65,90.31 3.58,90.36 3.53,90.45 3.53,93.75 3.23,94.46 2.52,94.76 2.4,94.76 1.7,95.05 1.41,95.75 1.41,96.69 4.89,96.69 4.89,96.5 5.1,96 5.6,95.79 7,95.79 7.5,96 7.71,96.5 7.71,96.69 11.6,96.69 12.1,96.9 12.31,97.4 12.31,97.68 13.04,97.68
GND on TOP (solid shape): outline of 162 points within 167.32,82.19 172.27,87.4
GND on TOP (solid shape): outline of 156 points within 121.41,107.88 125.95,124.03
GND on TOP (solid shape): outline of 186 points within 0.51,111.66 13.52,117.37
GND on TOP (solid shape): outline of 153 points within 17.16,0.51 71.02,9.52
GND on TOP (solid shape): outline of 1046 points within 199.7,171.53 232.41,192.42
GND on TOP (solid shape): outline of 1220 points within 175.49,124.55 190.18,139.16
GND on TOP (solid shape): outline of 5663 points within 0.51,0.51 244.39,198.19
GND on BOTTOM (solid shape): 107.24,143.02 107.24,135.91 106.86,135.53 102.55,135.53 102.29,135.78 102.29,143.28 102.67,143.66 106.61,143.66
GND on BOTTOM (solid shape): 138.11,81.02 138.11,79.83 137.55,79.27 136.43,79.27 136.35,79.34 136.35,81.96 136.45,82.06 137.06,82.06
GND on BOTTOM (solid shape): 158.04,183.1 158.04,180.44 157.79,180.18 155.68,180.18 155.43,180.44 155.43,183.03 155.63,183.23 157.92,183.23
GND on BOTTOM (solid shape): 175.44,116.1 175.44,110.13 175.19,109.87 174.05,109.87 173.79,110.13 173.79,116.73 174.05,116.99 174.55,116.99
GND on BOTTOM (solid shape): 176.33,75.05 176.33,67.53 175.95,67.15 174.66,67.15 174.2,67.61 174.2,74.47 174.91,75.18 176.21,75.18
GND on BOTTOM (solid shape): 34.41,94.76 34.41,92.48 34.16,92.22 31.24,92.22 30.98,92.48 30.98,94.76 31.24,95.02 34.16,95.02
GND on BOTTOM (solid shape): 52.08,96.82 52.08,92.68 51.75,92.35 50.6,92.35 50.2,92.76 50.2,96.69 50.55,97.05 51.85,97.05
GND on BOTTOM (solid shape): 58.55,48.91 59.87,48.91 59.92,48.86 59.92,46.63 59.8,46.5 56.09,46.5 55.96,46.63 55.96,49.22 56.19,49.45 58.02,49.45
GND on BOTTOM (solid shape): 61.14,73.55 61.14,72.54 60.79,72.18 60.79,70.38 60.53,70.12 57.46,70.12 57.05,70.53 57.05,72.97 57.73,73.64 61.05,73.64
GND on BOTTOM (solid shape): 74.62,43.75 74.62,41.27 74.66,41.23 74.66,40.51 74.25,40.1 70.03,40.1 69.55,40.58 69.55,43.78 69.78,44.01 74.35,44.01
GND on BOTTOM (solid shape): 117.4,158.64 117.4,156.64 117.2,156.43 115.75,156.43 115.63,156.56 115.63,158.64 115.88,158.9 117.15,158.9
GND on BOTTOM (solid shape): 184.77,104.11 184.77,99 183.93,98.17 183.93,91.61 183.7,91.38 181.41,91.38 181.03,91.76 181.03,104.06 181.31,104.34 184.54,104.34
GND on BOTTOM (solid shape): 225.48,51.33 225.48,49.04 225.35,48.91 223.07,48.91 222.31,48.15 221.04,48.15 220.53,48.66 220.53,51.2 220.91,51.58 225.23,51.58
GND on BOTTOM (solid shape): 93.28,106.86 93.28,105.65 93.21,105.58 89.68,105.58 89.46,105.8 89.46,107.03 89.46,107.05 89.48,107.07 89.82,107.42 92.72,107.42
GND on BOTTOM (solid shape): 133.56,82.14 133.56,80.46 133.41,80.31 131.93,80.31 131.76,80.49 131.76,82.04 131.68,82.11 131.68,82.63 131.77,82.72 132.97,82.72
GND on BOTTOM (solid shape): 112.32,164.36 112.32,164.1 111.44,163.21 111.44,161.69 110.93,161.18 110.42,161.18 110.29,161.31 110.29,163.47 111.56,164.74 111.94,164.74
GND on BOTTOM (solid shape): 160.06,147.15 160.06,144.28 159.8,144.01 156.57,144.01 156.39,144.19 156.39,147.87 156.52,148 159.21,148
GND on BOTTOM (solid shape): 94.98,125.88 96.87,125.88 96.96,125.79 96.96,124.86 96.83,124.73 83.88,124.73 83.62,124.99 83.62,126.13 84.77,127.27 91.49,127.27 93.59,127.27
GND on BOTTOM (solid shape): 211.77,175.69 211.77,175.18 211.64,175.05 210.67,175.05 209.86,174.24 205.72,174.24 205.54,174.42 205.54,175.71 205.7,175.86 211.59,175.86
GND on BOTTOM (solid shape): 73.72,76.12 73.72,71.22 73.21,70.71 70.31,70.71 69.78,71.24 69.78,72.03 69.04,72.77 69.04,74.62 69.55,75.13 69.55,75.94 70.14,76.52 73.31,76.52
GND on BOTTOM (solid shape): 74.68,59.51 74.68,55.95 74.38,55.65 67.7,55.65 67.34,56 67.34,57.09 67.67,57.42 69.58,57.42 72.01,59.86 74.33,59.86
GND on BOTTOM (solid shape): 141.66,178.86 141.66,178.28 141.05,177.67 141.05,175.33 140.82,175.1 138,175.1 137.6,174.7 136.33,174.7 136.2,174.82 136.2,175.2 137.37,176.37 137.37,178.79 137.62,179.04 141.48,179.04
GND on BOTTOM (solid shape): 148.9,174.14 148.9,173.25 149.41,172.74 149.41,172.23 148.39,171.22 148.39,170.33 147.63,169.56 147.63,168.04 147.5,167.91 146.23,167.91 145.73,168.42 145.73,174.01 146.11,174.39 148.65,174.39
GND on BOTTOM (solid shape): 219,104.65 219,100.86 218.75,100.6 215.45,100.6 215.07,100.98 215.07,103.99 215.08,104.03 215.12,104.05 215.47,104.05 216.24,104.81 218.85,104.81
GND on BOTTOM (solid shape): 66.96,68.78 66.96,66.59 66.43,66.06 64.34,66.06 64.15,66.25 64.15,66.78 64.14,66.8 64.14,68.07 64.6,68.52 65.92,68.52 66.3,68.9 66.83,68.9
GND on BOTTOM (solid shape): 53.27,39.52 53.27,38.75 54.67,37.36 55.55,37.36 55.61,37.3 56.51,37.3 56.57,37.23 56.57,36.6 56.44,36.47 54.41,36.47 53.02,37.87 51.62,37.87 51.49,37.99 51.49,39.52 51.62,39.64 53.14,39.64
GND on BOTTOM (solid shape): 59.44,57.3 59.44,56.23 59.24,56.03 59.24,51.35 59.16,51.28 57.91,51.28 57.82,51.38 57.82,52.52 58.32,53.03 58.32,56 57.99,56.33 57.99,57.32 58.12,57.45 59.29,57.45
GND on BOTTOM (solid shape): 93.15,71.46 93.15,69.74 92.51,69.11 91.8,69.11 91.48,69.43 86.99,69.43 86.79,69.22 80.59,69.22 80.07,69.74 80.07,70.82 80.45,71.21 80.45,74.25 81.53,75.33 85.34,75.33 85.72,75.71 88.89,75.71
GND on BOTTOM (solid shape): 161.4,72.13 161.4,70.63 161.73,70.3 161.73,66.14 161.55,65.96 156.95,65.96 156.88,66.03 156.88,68.73 156.98,68.83 160.31,68.83 160.61,69.13 160.61,71.37 160.59,71.39 160.59,72.14 160.76,72.31 161.22,72.31
GND on BOTTOM (solid shape): 210.62,29.48 210.62,29.1 210.75,28.98 212.53,28.98 212.65,28.85 212.65,28.34 212.53,28.21 209.23,28.21 209.1,28.09 209.1,27.32 208.97,27.2 207.32,27.2 207.19,27.32 207.19,28.72 208.34,29.86 210.24,29.86
GND on BOTTOM (solid shape): 215.52,74.11 215.52,72.69 215.5,72.66 215.5,67.66 215.19,67.36 213.72,67.36 213.52,67.56 213.52,68.6 213.62,68.7 213.62,69.95 213.92,70.25 213.92,73.98 214.18,74.24 215.4,74.24
GND on BOTTOM (solid shape): 12.33,120.59 12.34,120.56 12.33,120.55 12.32,120.36 12.38,120.19 12.38,118.28 12.24,118.14 11.35,118.14 11.23,118.26 11.23,120.54 11.49,120.8 12.12,120.8
GND on BOTTOM (solid shape): 48.06,75.2 48.06,74.7 47.55,74.19 47.55,72.28 47.17,71.9 44.51,71.9 44.38,72.03 44.38,72.41 44.13,72.66 43.87,72.66 43.74,72.79 43.74,73.3 44.38,73.93 44.38,75.58 44.51,75.71 47.55,75.71
GND on BOTTOM (solid shape): 56.83,63.65 56.83,61.11 56.95,60.98 58.65,60.98 58.78,60.85 58.78,58.26 58.45,57.93 53.98,57.93 52.89,59.02 52.89,62.05 54.54,63.7 56.77,63.7
GND on BOTTOM (solid shape): 100.01,101.77 100.26,101.77 100.81,101.22 100.81,100.97 100.68,100.84 100.11,100.84 99.54,100.84 99.28,101.1 99.28,101.34 99.6,101.65 99.64,101.7 99.67,101.75 99.68,101.77 100,101.77
GND on BOTTOM (solid shape): 214.66,178.33 214.66,175.56 214.99,175.23 214.99,174.26 214.84,174.11 212.73,174.11 212.07,174.77 212.07,175.64 210.78,176.93 210.78,178.56 210.88,178.66 214.33,178.66
GND on BOTTOM (solid shape): 64.09,96.29 64.09,92.73 63.99,92.63 63.2,92.63 62.52,93.31 59.57,93.31 59.49,93.39 59.49,94.13 58.73,94.89 58.73,96.06 58.96,96.29 58.96,96.34 59.39,96.77 63.61,96.77
GND on BOTTOM (solid shape): 97.21,112.92 97.21,112.05 97.12,111.96 96.74,111.96 96.59,111.81 96.07,111.81 95.89,111.63 95.89,111.17 95.89,111.17 95.07,111.17 94.81,110.91 92.6,110.91 91.37,109.68 86.93,109.68 86.05,110.56 86.05,112.43 86.67,113.05 97.08,113.05
GND on BOTTOM (solid shape): 167.32,171.98 167.32,170.71 166.99,170.38 164.2,170.38 163.87,170.05 163.87,169.2 163.66,168.98 162.85,168.98 161.6,170.23 161.6,171.27 161.73,171.39 163,171.39 163.28,171.67 164.78,171.67 165.31,172.21 167.09,172.21
GND on BOTTOM (solid shape): 192.72,113.43 194.75,113.43 194.87,113.3 194.87,110.13 194.49,109.75 193.86,109.75 193.22,110.38 191.19,110.38 191.06,110.51 191.06,111.49 191.09,111.52 191.09,112.04 191.06,112.07 191.06,112.79 191.06,112.79 191.06,113.43 191.7,114.07 192.08,114.07
GND on BOTTOM (solid shape): 228.31,182.98 231.6,182.98 232.19,182.39 232.19,176.3 231.76,175.86 226.12,175.86 225.79,175.53 222.99,175.53 222.89,175.64 222.89,176.47 223.04,176.63 223.45,176.63 223.68,176.85 223.68,178.35 220.81,181.22 220.81,184.27 222.13,185.59 225.7,185.59
GND on BOTTOM (solid shape): 137.45,159.15 138.13,159.15 138.16,159.13 138.16,158.95 138.14,158.91 138.11,158.9 137.61,158.9 137.58,158.87 137.57,158.87 137.32,158.62 137.32,158.29 137.19,158.16 136.45,158.16 135.92,158.69 135.92,159.51 135.97,159.56 137.04,159.56
GND on BOTTOM (solid shape): 63.89,24.58 63.89,22.7 64.12,22.47 64.12,19.45 63.91,19.25 63.91,16.05 63.79,15.92 60.97,15.92 60.76,16.12 60.76,17.16 60.92,17.32 61.8,17.32 62.39,17.9 63.02,17.9 63.2,18.08 63.2,23.59 62.82,23.97 62.44,23.97 62.36,24.05 62.36,24.51 62.49,24.63 63.84,24.63
GND on BOTTOM (solid shape): 64.67,79.55 64.67,77.5 64.67,77.5 64.67,76.7 64.42,76.7 64.42,77.5 64.17,77.5 64.17,76.7 63.92,76.7 63.92,77.5 63.67,77.5 63.67,76.7 63.42,76.7 63.42,77.5 63.17,77.5 63.17,76.7 62.92,76.7 62.46,77.16 62.46,79.7 62.62,79.85 64.37,79.85
GND on BOTTOM (solid shape): 160.97,62.63 160.97,62.25 161.22,62 161.73,62 162.36,61.36 162.36,60.89 162.35,60.88 162.01,60.45 161.72,59.99 161.71,59.97 161.68,59.96 160.08,59.96 159.82,60.22 159.82,62.76 159.95,62.88 160.71,62.88
GND on BOTTOM (solid shape): 160.64,159.39 160.64,157.84 159.87,157.08 158.86,157.08 158.1,156.32 154.54,156.32 153.47,157.39 150.2,157.39 150.2,156.93 150.17,156.9 149.66,156.9 149.66,158.02 150.35,158.02 150.91,158.58 150.91,159.01 151.16,159.27 158.15,159.27 158.32,159.44 160.58,159.44
GND on BOTTOM (solid shape): 168.41,180.92 168.41,180.39 168.75,180.04 169.36,180.04 169.37,180.06 169.68,180.06 169.86,179.88 169.86,179.24 169.7,179.09 168.99,179.09 168.84,178.94 168.84,178.3 168.36,177.82 167.09,177.82 166.81,178.1 164.78,178.1 164.32,177.64 164.32,177.39 164.24,177.31 163.05,177.31 163,177.36 163,179.55 163.12,179.67 166.05,179.67 166.25,179.88 166.25,180.87 166.48,181.1 168.23,181.1
GND on BOTTOM (solid shape): 96.83,128.54 96.83,127.4 96.32,126.89 96.32,126.51 96.2,126.38 95.31,126.38 95.18,126.51 95.18,127.91 95.48,128.21 95.48,128.21 95.82,128.26 95.98,128.57 95.98,128.65 95.99,128.67 96.02,128.67 96.7,128.67
GND on BOTTOM (solid shape): 97.21,121.05 97.21,119.7 97.04,119.33 97.1,118.94 97.1,118.92 97.1,118.89 97.08,118.85 97.06,118.8 97.05,118.77 97.02,118.76 88.83,118.76 88.7,118.89 88.7,120.92 88.96,121.18 97.08,121.18
GND on BOTTOM (solid shape): 224.31,171.52 224.31,170.61 223.96,170.25 219.51,170.25 219.41,170.35 219.41,171.39 219.44,171.39 219.44,172.18 219.69,172.18 219.69,171.39 219.94,171.39 219.94,172.18 220.19,172.18 220.19,171.39 220.44,171.39 220.44,172.18 220.69,172.18 220.69,171.39 220.94,171.39 220.94,172.18 222.43,172.18 222.59,172.33 222.59,172.64 222.76,172.82 223.02,172.82
GND on BOTTOM (solid shape): 57.56,30.12 57.56,28.28 57.03,27.74 57.03,26.89 57.44,26.49 57.97,26.49 58.76,27.27 58.76,28.32 58.91,28.47 62.16,28.47 62.59,28.04 62.59,26.87 62.64,26.82 62.64,25.14 61.93,24.43 59.62,24.43 59.57,24.43 59.32,24.18 55.02,24.18 54.9,24.3 54.9,30.17 55.05,30.32 57.36,30.32
GND on BOTTOM (solid shape): 149.05,159.74 149.64,159.74 149.64,159.73 150.12,159.73 150.12,159.48 149.56,159.48 149.26,159.18 149.26,155.85 147.83,154.43 146.39,154.43 146.39,150.59 146.16,150.36 142.78,150.36 142.4,150.74 142.4,155.82 141.41,156.81 138.16,156.81 138.16,156.28 137.62,156.28 137.5,156.41 137.5,157.42 137.57,157.5 137.65,157.5 137.67,157.47 138.69,157.47 138.94,157.73 138.94,158.57 139.07,158.69 145.12,158.69 146.26,159.84 148.95,159.84
GND on BOTTOM (solid shape): 125.53,158.77 127.13,158.77 127.39,158.52 127.39,156.18 127.11,155.9 125.51,155.9 125.15,155.54 125.15,154.91 124.75,154.5 122.87,154.5 122.69,154.68 122.69,156.1 121.72,157.07 118.57,157.07 118.57,156.61 118.56,156.57 118.52,156.56 118.04,156.56 117.99,156.61 117.99,157.65 118.04,157.7 119.21,157.7 119.46,157.96 119.46,158.87 119.54,158.95 125.35,158.95
GND on BOTTOM (solid shape): 134.42,143.15 134.42,139.34 133.53,138.45 132.64,138.45 132.39,138.2 124.64,138.2 124.35,138.48 124.34,138.51 124.34,138.53 124.37,138.67 124.39,139.72 124.14,140.75 124.14,140.76 124.14,141.37 124.52,141.75 130.23,141.75 130.87,142.39 130.87,143.15 131.12,143.4 134.17,143.4
GND on BOTTOM (solid shape): 182.49,114.64 182.49,114.24 182.47,114.21 182.43,114.19 182.14,114.06 182.05,113.74 182.06,113.73 182.05,113.7 181.98,113.64 181.98,113.61 181.97,113.57 181.93,113.56 181.03,113.56 180.9,113.68 180.9,114.57 181.03,114.7 182.43,114.7
GND on BOTTOM (solid shape): 120.81,167.22 120.77,166.99 120.85,166.78 120.85,166.3 120.89,166.26 120.9,166.23 120.89,166.19 118.51,163.81 118.51,163.08 118.45,163.01 117.61,163.01 117.52,163.1 117.52,163.47 117.28,163.71 117.28,163.8 117.28,164.87 117.66,165.25 119.18,165.25 119.31,165.37 119.36,165.37 119.56,165.57 119.56,165.63 119.82,165.88 119.82,167.15 120.05,167.38 120.64,167.38
GND on BOTTOM (solid shape): 115.5,159.66 115.5,158.9 115.37,158.77 115.37,156.82 115.18,156.63 114.21,156.63 114.12,156.72 114.12,156.94 114.46,157.32 114.12,157.7 114.12,158.11 113.85,158.38 113.85,158.77 113.59,159.02 111.18,159.02 111.05,159.15 111.05,159.66 111.18,159.79 115.37,159.79
GND on BOTTOM (solid shape): 194.09,79.52 196.02,79.52 196.3,79.24 196.3,77.77 196.65,77.41 197.74,77.41 197.82,77.34 197.82,74.11 197.69,73.98 196.65,73.98 196.42,73.76 196.42,71.6 196.75,71.27 197.74,71.27 197.87,71.14 197.87,67.86 197.69,67.69 193.33,67.69 193.1,67.91 193.1,70.02 192.77,70.35 191.7,70.35 191.6,70.45 191.6,73.65 191.75,73.81 192.74,73.81 193.05,74.11 193.05,76.32 192.82,76.55 191.75,76.55 191.57,76.73 191.57,79.88 191.67,79.98 193.63,79.98
GND on BOTTOM (solid shape): 117.93,107 117.97,107 118.02,106.97 118.04,106.97 118.12,106.95 118.18,106.89 118.18,106.56 118.05,106.43 117.84,106.43 117.67,106.26 117.47,106.26 117.19,105.97 117.03,105.97 116.93,106.08 116.93,106.34 117.01,106.54 116.96,106.74 116.96,106.89 117.03,106.96 117.34,106.96 117.62,106.83 117.9,106.98
GND on BOTTOM (solid shape): 132.24,158.57 135.26,158.57 135.27,158.55 135.58,158.55 136.18,157.96 136.81,157.96 137.14,157.63 137.14,156.38 136.96,156.2 135.29,156.2 134.68,155.59 134.68,154.2 134.07,153.59 133.74,153.59 133.46,153.31 133.46,151.2 133.46,151.2 133.46,151.15 133.46,151.15 133.46,151.02 133.41,150.97 132.57,150.97 132.3,151.24 132.3,153.68 132.29,153.69 132.29,156.36 131.63,157.02 128.43,157.02 128.28,156.86 128.28,156.59 128.26,156.55 128.23,156.53 127.77,156.53 127.69,156.61 127.69,157.6 127.74,157.65 128.86,157.65 129.24,158.03 129.24,158.85 129.26,158.88 129.29,158.9 131.91,158.9
GND on BOTTOM (solid shape): 53.52,82.77 53.52,80.77 53.04,80.28 52.13,80.28 50.88,79.04 47.94,79.04 47.63,79.34 47.63,80.41 47.91,80.69 48.01,80.69 48.37,80.44 48.73,80.69 49.17,80.69 49.36,80.64 49.55,80.69 49.79,80.69 50.12,81.02 50.98,81.02 51.16,81.2 51.19,81.2 51.5,81.51 51.58,81.54 51.65,81.58 52.86,81.58 53.04,81.76 53.04,82.72 53.14,82.82 53.47,82.82
GND on BOTTOM (solid shape): 130,170.4 130,168.04 129.85,167.89 129.1,167.89 129.09,167.89 128.96,167.91 128.83,167.89 128.82,167.89 128.26,167.89 128.25,167.89 128.12,167.91 127.99,167.89 127.99,167.89 126.35,167.89 126.32,167.86 126.27,167.86 126.02,168.12 126.02,170.07 126.06,170.16 126.57,170.21 126.77,170.58 126.77,170.61 126.78,170.64 126.82,170.66 129.75,170.66
GND on BOTTOM (solid shape): 197.54,191.41 197.54,184.8 197.48,184.74 197.48,183.22 196.91,182.65 196.4,182.65 196.37,182.66 196.37,182.68 196.07,182.9 195.72,182.76 195.7,182.74 195.68,182.74 195.16,182.74 194.11,183.79 193.35,183.79 192.78,184.36 192.78,190.2 192.97,190.39 193.86,190.39 193.93,190.33 194.51,190.29 194.63,190.86 194.62,190.89 194.64,190.92 195.26,191.54 197.41,191.54
GND on BOTTOM (solid shape): 180.51,115.73 180.51,113.51 180.65,113.37 180.65,111.28 180.59,111.02 180.65,110.77 180.65,110.75 180.65,110.65 180.62,110.59 180.61,110.54 180.53,110.47 180.43,110.5 179.89,110.54 179.86,109.99 179.84,109.91 179.76,109.87 179.13,109.87 178.87,110.13 178.87,115.59 179.13,115.84 179.7,115.84 179.71,115.84 180.4,115.84
GND on BOTTOM (solid shape): 229.67,110.89 229.67,107.49 229.67,107.46 229.16,106.95 229.16,106.32 229.04,106.19 228.28,106.19 228.2,106.27 228.18,106.3 228.28,106.6 228.16,106.84 228.15,106.86 228.15,106.88 228.15,107.46 228.28,107.59 228.28,108.84 228.3,108.86 228.66,108.86 229.04,109.24 228.66,109.62 228.29,109.62 228.28,109.64 228.28,109.66 228.28,110.76 228.53,111.02 229.55,111.02
GND on BOTTOM (solid shape): 128.33,133.37 128.33,132.14 128.31,132.1 128.28,132.08 128.14,132.04 128.03,131.94 127.97,131.9 127.9,131.91 127.57,132.1 127.24,131.92 127.23,131.91 127.07,131.74 127.07,131.35 126.55,130.83 126.55,129.12 126.43,129 126.43,128.12 126.43,128.09 126.43,128.06 126.43,127.79 126.17,127.53 126.09,127.53 126.08,127.54 125.78,127.62 125.48,127.53 125.02,127.53 124.79,127.76 124.79,127.93 125.28,128.42 125.28,132.23 124.77,132.73 124.77,133.24 125.02,133.5 128.2,133.5
GND on BOTTOM (solid shape): 10.85,44.34 12.5,44.34 13.39,43.45 13.39,40.79 14.79,39.39 14.79,37.99 14.1,37.3 12.63,37.3 12.63,37.31 12.38,37.31 12.38,38.6 11.58,39.62 10.39,39.11 2.31,39.11 2.31,39.16 2.31,42.24 2.31,42.29 8.75,42.29 9.45,42.69 9.46,43.49 9.46,45.16 9.51,45.21 9.99,45.21
GND on BOTTOM (solid shape): 226.02,162.2 226.02,156.46 225.68,156.13 223.55,156.13 222.18,154.76 211.66,154.76 210.32,156.1 214.18,156.1 214.18,156.04 214.19,155.98 214.21,155.92 214.24,155.86 214.27,155.8 214.32,155.75 214.36,155.71 214.41,155.67 214.47,155.64 214.53,155.62 214.59,155.6 214.65,155.59 214.72,155.59 214.78,155.6 214.84,155.62 214.9,155.64 214.96,155.67 215.01,155.71 215.06,155.75 215.1,155.8 215.13,155.86 215.16,155.92 215.18,155.98 215.19,156.04 215.2,156.1 215.19,156.17 215.18,156.23 215.16,156.29 215.13,156.35 215.1,156.4 215.06,156.45 215.01,156.5 214.96,156.53 214.9,156.56 214.84,156.59 214.78,156.6 214.72,156.61 214.65,156.61 214.59,156.6 214.53,156.59 214.47,156.56 214.41,156.53 214.36,156.5 214.32,156.45 214.27,156.4 214.24,156.35 214.21,156.29 214.19,156.23 214.18,156.17 214.18,156.1 210.32,156.1 209.84,156.59 209.84,157.93 208.64,159.13 208.64,160.65 208.69,160.7 210.98,160.7 211.07,160.79 212.48,160.79 213.21,160.05 213.21,159.66 213.54,159.33 220.02,159.33 220.73,160.04 223.78,160.04 224.08,160.34 224.08,162.83 224.14,162.88 225.33,162.88
GND on BOTTOM (solid shape): 214.33,101.72 214.33,96.24 213.04,94.94 213.04,89.73 213.55,89.22 213.55,89.15 213.59,89.02 213.69,88.94 213.72,88.93 213.72,88.77 213.73,88.77 213.73,88.74 214.16,88.29 214.44,88.85 214.43,88.87 214.44,88.92 214.49,88.93 214.52,88.93 214.56,88.92 214.84,88.92 214.97,88.97 215.05,89.08 215.06,89.11 217.85,89.11 218.04,88.92 218.04,85.01 217.81,84.78 217.81,84.73 209.99,84.73 209.15,85.57 209.19,85.61 209.19,86.6 209.17,86.61 209.17,92.63 209.05,92.76 209.05,101.7 209.48,102.13 213.92,102.13
GND on BOTTOM (solid shape): 98.43,130.45 100.26,130.45 100.52,130.19 100.52,130.05 100.58,129.89 100.74,129.82 100.89,129.82 101.02,129.69 101.02,129.32 101.02,129.31 101.02,128.8 100.64,128.42 100.13,128.42 100.01,128.54 100.01,128.92 99.88,129.05 99.86,129.05 99.83,129.08 99.83,129.12 99.83,129.13 99.75,129.6 99.27,129.61 99.23,129.6 99.2,129.62 98.9,129.77 98.58,129.67 98.55,129.66 98.51,129.67 98.31,129.77 98.08,129.75 98.06,129.75 98.04,129.75 97.97,129.81 97.97,130.32 98.1,130.45 98.43,130.45
GND on BOTTOM (solid shape): 14.86,26.3 14.9,26.28 14.92,26.25 14.92,20.85 14.77,20.7 13.39,20.7 13.39,20.7 12.38,20.7 12.38,22 11.58,23.02 10.39,22.51 9.91,22.51 2.36,22.51 2.31,22.51 2.31,22.56 2.31,24.44 2.31,24.49 10.39,24.49 11.58,23.98 12.38,25 12.38,26.3
GND on BOTTOM (solid shape): 6.09,73.62 9.52,73.62 16.82,66.31 16.82,61.74 12.12,57.04 11.16,57.04 10.12,56 9.46,56 9.46,57.52 9.44,58.32 8.75,58.71 2.36,58.71 2.32,58.72 2.31,58.76 2.31,60.64 2.31,60.66 2.33,60.68 3.78,61.89 6.1,61.89 7.61,63.4 6.1,64.91 3.73,64.91 3.53,65.11 3.53,67.85 3.58,67.94 4.65,67.99 5.13,68.85 5.13,73.54 5.26,73.68 6.03,73.68
GND on BOTTOM (solid shape): 15.8,94.76 15.8,91.21 15.42,90.82 9.58,90.82 8.57,89.81 8.57,87.14 6.15,84.73 6.14,84.73 6.14,82.19 6.02,82.06 5.25,82.06 5.13,82.19 5.13,89.45 4.65,90.31 3.58,90.36 3.53,90.45 3.53,93.75 3.23,94.46 2.52,94.76 2.4,94.76 1.7,95.05 1.41,95.75 1.41,96.64 1.42,96.68 1.46,96.69 4.84,96.69 4.88,96.68 4.89,96.64 4.89,96.5 5.1,96 5.6,95.79 7,95.79 7.5,96 7.71,96.5 7.71,96.64 7.72,96.68 7.76,96.69 11.6,96.69 12.09,96.89 12.31,97.38 12.31,97.4 12.46,97.56 13.01,97.56
GND on BOTTOM (solid shape): 6.41,117.24 6.41,117.04 6.04,116.82 5.84,116.44 5.85,116.13 5.98,115.85 6.8,115.56 7.36,116.22 7.93,116.22 8.44,115.72 8.44,114.83 9.45,113.81 12.25,113.81 13.52,112.54 13.52,111.78 13.4,111.66 12.29,111.66 12.27,111.67 11.99,111.99 11.6,112.11 7.76,112.11 7.72,112.12 7.71,112.16 7.71,112.3 7.5,112.8 7,113.01 5.6,113.01 5.1,112.8 4.89,112.3 4.89,112.16 4.88,112.12 4.84,112.11 1.46,112.11 1.42,112.12 1.41,112.16 1.41,113.1 1.16,113.72 0.52,114.02 0.51,114.06 0.51,114.87 0.52,114.9 0.56,114.92 3.2,114.92 3.23,114.91 3.24,114.89 4.38,114.46 5.11,115.42 5.11,116.7 5.77,117.37 6.28,117.37
GND on BOTTOM (solid shape): 211.17,113.18 211.23,113.16 211.27,113.11 211.26,113.08 211.26,113.05 211.26,112.91 211.26,112.29 211.64,111.91 212.02,112.29 212.02,112.91 212.02,113.05 212.01,113.08 212.01,113.11 212.05,113.16 212.1,113.18 212.32,113.18 212.37,113.16 212.41,113.11 212.41,113.08 212.4,113.05 212.4,112.91 212.4,112.29 212.78,111.91 213.16,112.29 213.16,112.91 213.16,113.05 213.16,113.08 213.15,113.11 213.19,113.16 213.25,113.18 213.46,113.18 213.52,113.16 213.55,113.11 213.55,113.08 213.55,113.05 213.54,112.91 213.54,112.29 213.92,111.91 214.31,112.29 214.31,112.91 214.3,113.05 214.3,113.08 214.29,113.11 214.33,113.16 214.39,113.18 215.75,113.18 215.8,113.16 215.84,113.11 215.83,113.08 215.83,113.05 215.83,112.91 215.83,112.29 216.21,111.91 216.59,112.29 216.59,112.91 216.59,113.05 216.59,113.08 216.58,113.11 216.62,113.16 216.68,113.18 220.15,113.18 220.53,112.8 220.53,111.02 220.02,110.51 209.1,110.51 207.7,111.91 207.7,112.67 208.21,113.18
GND on BOTTOM (solid shape): outline of 386 points within 81.46,64.66 149.15,75.37
GND on BOTTOM (solid shape): outline of 638 points within 190.71,85.39 244.39,198.19
GND on BOTTOM (solid shape): outline of 885 points within 0.51,119.02 188.52,190.29
GND on BOTTOM (solid shape): outline of 1317 points within 5.06,0.51 232.21,97.3
GND on BOTTOM (solid shape): outline of 1150 points within 79.41,26.03 151.64,42.06
GND on SGND (solid shape): outline of 4416 points within 0.51,0.51 244.39,198.19
GND on IN1 (solid shape): 115.12,132.73 115.12,129.81 114.99,129.69 112.45,129.69 111.82,129.05 111.44,129.05 111.18,129.31 111.18,132.61 111.31,132.73 112.96,132.73 113.59,133.37 114.48,133.37
GND on IN1 (solid shape): 192.72,113.43 194.75,113.43 194.87,113.3 194.87,110.13 194.49,109.75 193.86,109.75 193.22,110.38 191.19,110.38 191.06,110.51 191.06,113.43 191.7,114.07 192.08,114.07
GND on IN1 (solid shape): 48.06,75.2 48.06,74.7 47.55,74.19 47.55,72.28 47.17,71.9 44.51,71.9 44.38,72.03 44.38,72.41 44.13,72.66 43.87,72.66 43.74,72.79 43.74,73.3 44.38,73.93 44.38,75.58 44.51,75.71 47.55,75.71
GND on IN1 (solid shape): 229.04,185.19 229.04,177.44 228.59,177 226.51,179.08 218.8,179.08 218.69,179.22 218.54,179.29 218.46,179.37 218.5,179.47 220.05,181.4 220.08,183.87 216.64,186.44 213.02,184.13 212.91,184.07 212.83,184.17 212.83,185.75 209.06,189.52 207.48,189.52 207.01,189.99 206.99,190.09 207.05,190.16 207.13,190.2 207.2,190.25 207.22,190.26 207.24,190.27 223.96,190.27
GND on IN1 (solid shape): 199.62,191.28 199.7,191.25 199.73,191.17 199.76,191 199.88,190.86 199.93,190.77 199.88,190.69 199.73,190.43 199.83,190.15 199.85,190.08 199.73,189.76 199.85,189.44 199.73,189.12 199.85,188.81 199.83,188.73 200.08,188.13 200.34,188.73 200.31,188.81 200.44,189.12 200.31,189.44 200.44,189.76 200.31,190.08 200.34,190.15 200.44,190.43 200.28,190.69 200.23,190.77 200.28,190.86 200.4,191 200.44,191.17 200.46,191.25 200.54,191.28 200.84,191.28 201.48,190.65 201.48,186.96 198.56,184.04 195,184.04 194.49,184.55 194.49,188.11 195.89,189.5 195.89,190.77 196.4,191.28
GND on IN1 (solid shape): outline of 263 points within 123.29,108.34 127.83,117.13
GND on IN1 (solid shape): outline of 437 points within 0.51,111.66 16.82,117.24
GND on IN1 (solid shape): outline of 1021 points within 205.42,170.38 228.39,190.09
GND on IN1 (solid shape): outline of 8994 points within 0.51,0.51 244.39,198.19
GND on SVCC (solid shape): outline of 167 points within 1.41,0.51 37.07,96.69
GND on SVCC (solid shape): outline of 757 points within 92.54,0.51 231.79,74.37
GND on SVCC (solid shape): outline of 3372 points within 0.51,35.83 244.39,198.19
GND on IN2 (solid shape): 142.04,96.67 142.04,93.11 141.92,92.98 140.26,92.98 140.14,93.11 140.14,96.41 140.52,96.79 141.92,96.79
GND on IN2 (solid shape): 115.12,132.73 115.12,129.81 114.99,129.69 112.45,129.69 111.82,129.05 111.44,129.05 111.18,129.31 111.18,132.61 111.31,132.73 112.96,132.73 113.59,133.37 114.48,133.37
GND on IN2 (solid shape): 192.72,113.43 194.75,113.43 194.87,113.3 194.87,110.13 194.49,109.75 193.86,109.75 193.22,110.38 191.19,110.38 191.06,110.51 191.06,113.43 191.7,114.07 192.08,114.07
GND on IN2 (solid shape): 48.06,75.2 48.06,74.7 47.34,73.97 47.34,72.38 46.86,71.9 44.51,71.9 44.38,72.03 44.38,72.41 44.13,72.66 43.87,72.66 43.74,72.79 43.74,73.3 44.38,73.93 44.38,75.58 44.51,75.71 47.55,75.71
GND on IN2 (solid shape): 6.28,117.11 6.31,117.06 6.31,117.01 5.88,116.02 6.87,115.58 6.9,115.54 6.91,115.5 6.91,115.21 8.44,113.68 12.63,113.68 13.52,112.8 13.52,111.91 13.26,111.66 12.33,111.66 12.17,111.82 12.17,111.82 11.92,112.03 11.6,112.11 7.71,112.11 7.71,112.3 7.5,112.8 7,113.01 5.6,113.01 5.1,112.8 4.89,112.3 4.89,112.11 1.41,112.11 1.41,113.1 1.16,113.72 0.52,114.02 0.51,114.06 0.51,114.92 3.2,114.92 3.23,114.91 3.24,114.89 4.38,114.46 5.11,115.42 5.11,116.58 5.77,117.24 6.15,117.24
