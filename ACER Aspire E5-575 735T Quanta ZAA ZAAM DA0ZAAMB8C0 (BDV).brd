# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDI_0+: length 11.8
  TOP w0.127: U15.1 40.1,76.18 40.57,76.65 v1(40.57,76.85)
  BOTTOM w0.127: v1(40.57,76.85) 40.57,78.95 40.18,79.34 39.75,79.78 37.07,79.78 35.93,78.63 34.25,78.63 34.02,78.4 U42.11
MDI_0-: length 11.8
  TOP w0.127: U15.2 39.7,75.77 39.7,76.26 40.01,76.58 40.01,76.78 v1(39.93,76.85)
  BOTTOM w0.127: U42.12 34.17,77.4 34.29,77.52 34.29,78.1 34.42,78.23 36.1,78.23 37.24,79.37 39.58,79.37 39.89,79.05 40.16,78.78 40.16,77.08 v1(39.93,76.85)
MDI_1+: length 11.4
  TOP w0.127: v1(38.87,77.41) 39.16,77.12 39.16,76.57 38.9,76.31 U15.4
  IN1 w0.089: v1(38.87,77.41) 38.63,77.41 38.42,77.62 38.42,80.78 38.06,81.14 37.81,81.14 v1(37.5,81.45)
  BOTTOM w0.127: v1(37.5,81.45) 37.22,81.17 34.31,81.17 34.08,81.4 U42.8
MDI_1-: length 11.4
  TOP w0.127: U15.5 38.5,76.36 38.59,76.45 38.72,76.45 38.93,76.66 38.93,76.86 38.82,76.98 38.63,76.98 v1(38.53,76.88)
  IN1 w0.089: v1(37.5,80.56) 37.5,80.72 37.65,80.87 37.95,80.87 38.16,80.67 38.16,77.51 38.53,77.13 v1(38.53,76.88)
  BOTTOM w0.127: U42.9 34.08,80.4 34.45,80.77 37.29,80.77 v1(37.5,80.56)
MDI_2+: length 13.3
  TOP w0.127: U15.6 38.1,77.37 38.36,77.63 38.36,82.81 36.91,84.27 v1(35.36,84.27)
  BOTTOM w0.127: v1(35.36,84.27) 35.2,84.1 34.38,84.1 34.08,84.4 U42.5
MDI_2-: length 13.3
  TOP w0.127: v1(35.36,83.51) 35.72,83.15 35.87,83.15 36,83.28 36,83.71 36.15,83.86 36.74,83.86 37.95,82.65 37.95,77.79 37.7,77.54 U15.7
  BOTTOM w0.127: U42.6 34.08,83.4 34.38,83.7 35.17,83.7 v1(35.36,83.51)
MDI_3+: length 15
  TOP w0.127: v1(36.83,77.1) 36.71,76.98 36.71,76.8 36.9,76.61 U15.9
  IN1 w0.089: v1(35.36,87.27) 35.48,87.15 35.86,87.15 36.47,86.54 36.47,78.41 36.83,78.05 v1(36.83,77.1)
  BOTTOM w0.127: U42.2 34.08,87.4 34.35,87.13 35.22,87.13 v1(35.36,87.27)
MDI_3-: length 15
  TOP w0.127: U15.10 36.5,76.58 36.3,76.78 36.3,77 v1(36.2,77.1)
  IN1 w0.089: v1(35.36,86.51) 35.36,86.76 35.49,86.89 35.75,86.89 36.2,86.43 36.2,78.3 36.56,77.94 36.56,77.47 v1(36.2,77.1)
  BOTTOM w0.127: v1(35.36,86.51) 35.15,86.72 34.4,86.72 34.08,86.4 U42.3
ME_WR#: length 90.6
  IN3 w0.114: v1(167.54,78.05) 168.08,77.52 168.08,74.31 168.28,74.11 168.28,66.45 171.25,63.49 171.25,61.28 171.88,60.64 171.88,57.19 172.88,56.19 172.88,53.14 175.68,50.33 175.68,45.78 176.61,44.85 176.61,41.68 v1(177.32,40.96)
  BOTTOM w0.127: U45.109 177.98,41.62 v1(177.32,40.96) ; v1(167.54,78.05) 165.9,78.05 165.38,77.53 160.89,77.53 160.71,77.35 156.77,77.35 155.6,76.18 145.51,76.18 138.31,83.38 136.19,83.38 134.5,85.07 131.72,85.07 129.72,87.06 R737.1
MIC2-VREFO: length 14
  TOP w0.381: v1(205.8,37.61) 205.67,37.48 205.67,34.56 204.65,33.55 204.65,28.21 v1(204.98,27.88)
  BOTTOM w0.203: U23.29 205.38,38.36 205.8,37.94 v1(205.8,37.61)
  BOTTOM w0.381: R424.1 204.27,27.43 204.73,27.88 v1(204.98,27.88) 205.25,27.88 205.67,27.46 R407.1
MOD_EN_5V: length 14.1
  TOP w0.508: v1(220.78,103.02) 221.54,103.78 221.54,108.35 222.43,109.24 v1(223.3,109.24) 223.7,109.24 223.83,109.37 v1(224.03,109.37) C752.1 225.22,108.73 225.49,108.46 R686.1
  BOTTOM w0.279: Q37.6 223.57,109.51 v1(223.3,109.24)
  BOTTOM w0.508: v1(220.78,103.02) 220.78,102.61 221.23,102.16 Q34.3
MPHY_EXT_PWR: length 14.1
  TOP w0.102: 139.9,108.37 139.73,108.54 135.73,108.54 v1(135.17,107.98)
  TOP w0.127: 139.9,108.37 141.03,107.23 v1(143.13,107.23) 143.97,107.23 144.89,108.15 144.89,108.52 145.36,108.99 146.24,108.99 R195.2
  BOTTOM w0.127: v1(135.17,107.98) 135.17,107.96 135.41,107.72 U35.AM10
MULTISTRAP_REF_GND: length 5.9
  BOTTOM w0.127: R4345.2 R4344.2
  BOTTOM w0.14: R4345.2 189.76,114.91 189.76,116.47 189.33,116.9 U3002.J1
MX0: length 64.6
  IN3 w0.114: v1(175.11,25.34) 176.12,24.33 178.39,24.33 178.85,23.87 184.89,23.87 186.39,25.37 191.83,25.37 195.91,29.45 197.45,29.45 199.45,27.45 v1(200.13,27.45)
  BOTTOM w0.127: v1(175.11,25.34) 175.11,26.07 175.58,26.55 U45.58 ; CN20.1 178.42,15.51 178.68,15.77 181.67,15.77 182.43,16.53 197.03,16.53 199.98,19.47 CN2019.1 199.98,22.24 200.26,22.52 200.26,23.23 C4804.1 199.78,23.71 199.78,24.89 200.41,25.52 v1(200.41,26.51) 200.41,27.17 v1(200.13,27.45) RP1.4
MX1: length 64.7
  IN3 w0.114: v1(174.24,25.08) 174.24,24.85 174.99,24.1 178.29,24.1 178.75,23.64 184.98,23.64 185.63,24.29 189.92,24.29 190.75,25.12 191.9,25.12 195.99,29.2 197.06,29.2 199.53,26.73 v1(199.53,26.18)
  BOTTOM w0.127: RP1.5 199.57,26.82 199.7,26.69 199.7,26.35 v1(199.53,26.18) 199.52,26.18 v1(199.52,25.42) 199.52,23.72 199.5,23.69 199.5,23.68 C4805.1 199.07,22.47 198.98,22.38 CN2019.2 198.98,19.47 196.29,16.78 182.3,16.78 181.54,16.02 177.93,16.02 177.42,15.51 CN20.2 ; U45.59 175.18,26.6 174.71,26.12 174.71,25.55 v1(174.24,25.08)
MX2: length 66.5
  IN1 w0.089: v1(200.11,28.09) 198.51,26.49 v1(198.51,25.19)
  IN3 w0.114: v1(174.25,25.76) 174.54,26.05 175.67,26.05 176.43,25.29 176.7,25.29 177.1,24.89 178.21,24.89 179,24.1 184.79,24.1 186.34,25.65 191.79,25.65 195.83,29.69 197.57,29.69 199.17,28.09 v1(200.11,28.09)
  BOTTOM w0.127: v1(198.51,25.19) 198.41,25.19 197.49,24.28 197.49,23.71 C4806.1 197.98,23.22 CN2019.3 197.98,19.47 195.54,17.04 182.17,17.04 181.41,16.28 177.09,16.28 176.42,15.61 CN20.3 ; RP1.3 v1(200.11,28.09) ; U45.60 174.78,26.56 174.25,26.03 v1(174.25,25.76)
MX3: length 69.9
  IN1 w0.089: v1(200.11,29.36) 199.07,28.32 199.07,28.09 198.05,27.07 v1(198.05,25.72)
  IN3 w0.114: v1(173.28,25.17) 173.79,25.67 173.79,25.95 174.32,26.48 178.19,26.48 179.13,25.55 181.16,25.55 182.37,24.34 183.67,24.34 184.75,25.42 185.64,25.42 186.11,25.89 191.71,25.89 195.75,29.93 197.66,29.93 198.23,29.36 v1(200.11,29.36)
  BOTTOM w0.127: CN20.4 175.42,15.5 176.46,16.53 181.29,16.53 182.05,17.29 194.81,17.29 196.98,19.46 CN2019.4 196.98,22.35 196.78,22.55 C4807.1 197.21,23.68 197.21,23.69 197.24,23.72 197.24,24.4 198.05,25.22 v1(198.05,25.72) ; U45.61 174.38,26.53 173.74,25.89 173.74,25.62 v1(173.28,25.17) ; RP1.1 v1(200.11,29.36)
MX4: length 66.8
  IN3 w0.114: v1(196.49,28.72) 194.16,26.4 194.16,24.71 193.5,24.05 185.71,24.05 185.08,23.41 178.64,23.41 178.19,23.87 174.53,23.87 173.74,24.66 173.03,24.66 172.85,24.84 172.85,25.41 v1(173.29,25.85)
  BOTTOM w0.127: CN20.5 174.42,15.64 175.57,16.78 181.03,16.78 181.79,17.55 194.05,17.55 195.98,19.47 CN2019.5 195.98,22.31 195.66,22.63 C4788.1 196.14,23.73 196.14,24.58 v1(197.19,25.63) 197.87,26.31 198.05,26.31 198.35,26.61 198.35,28.54 198.18,28.72 RP1.9 v1(196.49,28.72) ; v1(173.29,25.85) 173.98,26.55 U45.62
MX5: length 67.5
  IN3 w0.114: v1(172.19,25.19) 172.19,24.55 172.85,23.9 173.67,23.9 174.15,23.41 177.86,23.41 178.57,22.7 178.57,22.35 179.46,21.46 192.13,21.46 194.62,23.95 194.62,25.57 v1(196.5,27.45)
  BOTTOM w0.127: CN20.6 173.42,15.53 174.94,17.04 180.9,17.04 181.67,17.8 193.3,17.8 194.98,19.47 CN2019.6 194.98,22.19 194.52,22.65 C4789.1 194.06,23.71 194.06,24.45 194.95,25.34 194.95,26.51 v1(195.6,27.16) 195.89,27.45 v1(196.5,27.45) RP1.7 ; v1(172.19,25.19) 172.7,25.7 172.7,25.9 173.11,26.31 173.38,26.31 173.58,26.51 U45.63
MX6: length 66.4
  IN3 w0.114: v1(196.5,28.09) 194.39,25.98 194.39,24.58 193,23.18 178.54,23.18 178.09,23.64 174.3,23.64 173.54,24.4 172.95,24.4 172.62,24.74 172.62,25.49 v1(172.19,25.92)
  BOTTOM w0.127: U45.64 173.18,26.74 172.99,26.55 172.82,26.55 v1(172.19,25.92) ; C4790.1 193.35,23.24 ; 193.35,23.24 193.35,22.58 193.98,21.95 CN2019.7 193.98,20.68 193.96,20.66 193.96,19.46 192.68,18.18 181.67,18.18 180.78,17.29 174.05,17.29 172.42,15.67 CN20.7 ; 193.35,23.24 193.81,23.69 v1(193.81,25.39) 193.81,26.28 195.61,28.09 v1(196.5,28.09) RP1.8
MX7: length 73.7
  IN1 w0.089: v1(191.65,22.4) 192.06,22.4 196.47,26.82 v1(196.49,26.82) ; v1(172.4,12.72) 178.75,12.72 182.68,16.66 189.52,16.66 v1(191.62,18.77)
  IN3 w0.114: v1(170.62,25.17) 171,24.78 171.63,24.78 172.9,23.51 173.54,23.51 173.97,23.08 177.09,23.08 177.53,22.65 177.53,22.35 178.64,21.23 192.23,21.23 194.85,23.85 194.85,25.18 v1(196.49,26.82)
  BOTTOM w0.127: U45.65 170.79,29 170.49,28.7 v1(170.49,25.97) 170.49,25.29 v1(170.62,25.17) ; v1(191.62,18.77) 192.97,20.11 192.97,20.47 192.98,20.47 CN2019.8 192.98,21.93 192.51,22.4 192.51,22.95 C4791.1 191.65,22.69 v1(191.65,22.4) ; RP1.6 v1(196.49,26.82) ; CN20.8 171.42,13.69 v1(172.4,12.72)
MY0: length 46.6
  TOP w0.127: v1(183.6,29.23) 180.89,26.52 180.89,25.66 179.1,23.87 176.81,23.87 v1(176.36,23.41) 175.71,22.77 175.71,22.36 175.34,21.99 174.4,21.99 v1(173.95,22.45) ; v1(173.52,17.77) 172.29,16.53 170.7,16.53 168.48,14.31 159.51,14.31 158.81,15.01 154.82,15.01 v1(153.42,13.61)
  BOTTOM w0.127: v1(173.95,22.45) 173.92,22.47 C4795.1 174.43,22.74 174.43,22.17 174.98,21.62 CN2019.26 174.98,19.22 v1(173.52,17.77) ; CN20.26 v1(153.42,13.61) ; v1(183.6,29.23) 184.38,28.45 U45.36
MY1: length 45.1
  TOP w0.127: v1(154.42,13.61) 155.57,14.75 158.68,14.75 159.38,14.05 168.59,14.05 170.74,16.21 173.09,16.21 174.52,17.64 v1(174.52,17.77) ; v1(174.96,22.45) v1(174.96,23.18) 175.99,24.21 177.92,24.21 179.13,25.42 180.27,25.42 180.64,25.79 180.64,26.63 182.89,28.88 v1(182.89,29.23)
  BOTTOM w0.127: v1(174.52,17.77) 175.98,19.22 CN2019.25 175.98,21.87 175.47,22.37 175.47,22.85 C4794.1 175.06,22.55 v1(174.96,22.45) ; v1(182.89,29.23) 183.98,28.14 U45.37 ; CN20.25 v1(154.42,13.61)
MY2: length 42.9
  TOP w0.127: v1(155.42,13.61) 155.42,13.61 156.31,14.5 158.43,14.5 159.12,13.8 168.69,13.8 170.79,15.9 173.66,15.9 v1(175.52,17.77) ; v1(176.15,22.45) 177.09,23.39 180.57,23.39 181.6,24.42 181.6,25.74 181.84,25.98 181.84,26.36 182.17,26.69 v1(183.23,26.69) 183.32,26.69 v1(183.93,26.08)
  BOTTOM w0.127: v1(176.15,22.45) 176.15,23.2 C4793.1 176.64,22.82 176.64,22.22 176.98,21.88 CN2019.24 176.98,19.22 v1(175.52,17.77) ; U45.38 183.58,26.43 v1(183.93,26.08) ; CN20.24 v1(155.42,13.61)
MY3: length 42.3
  TOP w0.127: v1(176.52,17.77) 174.4,15.64 170.89,15.64 168.8,13.55 159,13.55 158.3,14.24 157.06,14.24 v1(156.42,13.61) ; v1(183.93,25.45) 183.93,24.63 183.19,23.9 v1(183.02,23.9) 182.25,23.9 179.84,21.48 178.06,21.48 v1(177.09,22.45)
  BOTTOM w0.127: v1(177.09,22.45) 177.09,23 C4792.1 177.58,23.02 177.58,22.24 177.98,21.85 CN2019.23 177.98,19.22 v1(176.52,17.77) ; U45.39 183.18,26.19 v1(183.93,25.45) ; CN20.23 v1(156.42,13.61)
MY4: length 39.1
  TOP w0.127: v1(178.03,22.45) 178.54,21.94 v1(178.59,21.94) 179.91,21.94 182.38,24.4 v1(182.38,25.42) ; v1(157.42,13.61) 157.74,13.29 168.9,13.29 171,15.39 175.14,15.39 v1(177.52,17.77)
  BOTTOM w0.127: U45.40 182.78,25.82 v1(182.38,25.42) ; v1(178.03,22.45) 178.03,22.79 C4799.1 178.49,22.37 178.98,21.89 CN2019.22 178.98,19.22 v1(177.52,17.77) ; CN20.22 v1(157.42,13.61)
MY5: length 40.9
  TOP w0.127: v1(156.9,12.34) 157.54,12.34 158.24,13.04 169.23,13.04 171.32,15.13 175.89,15.13 v1(178.52,17.77) ; v1(179.08,22.45) 179.38,22.75 v1(179.96,22.75) 180.32,22.75 181.86,24.29 181.86,25.58 v1(182.33,26.05)
  BOTTOM w0.127: v1(178.52,17.77) 179.98,19.22 CN2019.21 179.98,22.91 C4798.1 179.08,22.69 v1(179.08,22.45) ; v1(156.9,12.34) 158.42,13.86 CN20.21 ; U45.41 182.38,26.11 v1(182.33,26.05)
MY6: length 37.7
  TOP w0.127: v1(158.17,12.34) 158.17,12.47 158.49,12.78 169.33,12.78 171.43,14.88 177.22,14.88 180.28,17.94 v1(180.28,18.78)
  BOTTOM w0.127: U45.42 181.98,26.44 181.79,26.25 181.79,25.88 181.36,25.45 181.36,23.84 C4797.1 180.78,22.27 180.98,22.07 CN2019.20 180.98,19.47 v1(180.28,18.78) ; CN20.20 159.42,13.59 v1(158.17,12.34)
MY7: length 38.5
  TOP w0.127: v1(159.44,12.34) v1(163.01,12.34) 169.25,12.34 171.53,14.62 177.38,14.62 181.28,18.53 v1(181.28,18.78)
  IN1 w0.089: v1(181.49,22.45) 181.49,23.34 181.34,23.49 v1(181.34,26.18)
  BOTTOM w0.127: v1(181.49,22.45) 181.41,22.52 181.41,23.01 181.66,23.25 C4796.1 181.92,22.73 181.98,22.67 CN2019.19 181.98,19.47 v1(181.28,18.78) ; U45.43 181.58,26.43 v1(181.34,26.18) ; CN20.19 160.42,13.32 v1(159.44,12.34)
MY8: length 41
  TOP w0.127: v1(182.28,18.78) 182.01,18.78 177.6,14.37 171.64,14.37 169.35,12.08 165.41,12.08 v1(164.65,11.32)
  IN1 w0.089: v1(181.54,29.23) 181.54,27.58 181.93,27.19 181.93,24.75 182.5,24.18 v1(182.5,22.45)
  BOTTOM w0.127: U45.44 181.18,28.87 v1(181.54,29.23) ; v1(182.28,18.78) 182.98,19.47 CN2019.18 182.98,21.83 183.06,21.91 C4803.1 182.75,23.25 182.5,23.01 v1(182.5,22.45) ; CN20.18 161.42,13.91 163,12.34 163.63,12.34 v1(164.65,11.32)
MY9: length 43.6
  TOP w0.127: v1(165.35,11.32) 165.79,11.77 170.05,11.77 170.43,11.39 175.36,11.39 182.18,18.21 182.71,18.21 v1(183.28,18.78)
  IN1 w0.089: v1(180.88,29.24) 180.91,29.21 180.91,27.94 181.74,27.11 181.74,24.66 182.1,24.3 182.1,22.17 182.29,21.98 183.15,21.98 v1(183.62,22.45)
  BOTTOM w0.127: v1(165.35,11.32) 163.95,12.72 163.63,12.72 162.42,13.93 CN20.17 ; v1(183.28,18.78) 183.98,19.47 CN2019.17 183.98,21.89 184.21,22.12 C4802.1 183.79,23.25 183.62,23.08 v1(183.62,22.45) ; U45.45 180.78,29.13 v1(180.88,29.24)
MY10: length 46
  TOP w0.127: v1(184.28,18.78) v1(183.68,18.18) 183.43,17.93 182.26,17.93 175.47,11.13 170.33,11.13 169.95,11.51 167.18,11.51 v1(165.97,10.31)
  IN1 w0.089: v1(180.9,30.04) 181.73,30.04 182.24,29.53 182.24,27.64 183.14,26.74 183.14,25.64 184.77,24.01 v1(184.77,22.6)
  BOTTOM w0.127: U45.46 180.38,29.52 v1(180.9,30.04) ; v1(184.28,18.78) 184.98,19.47 CN2019.16 184.98,21.87 185.35,22.24 C4801.1 185.06,23.25 184.77,22.96 v1(184.77,22.6) ; CN20.16 163.42,13.94 165.94,11.42 165.94,10.33 v1(165.97,10.31)
MY11: length 52
  TOP w0.127: v1(166.67,10.32) 167.61,11.26 169.84,11.26 170.22,10.88 175.57,10.88 182.37,17.67 184.18,17.67 v1(185.28,18.78)
  IN1 w0.089: v1(186.09,22.45) 186.09,21.61 185.07,20.59 181.47,20.59 181.08,20.99 181.08,23.06 179.63,24.51 179.63,25.17 178.24,26.56 178.24,28.59 v1(178.87,29.23)
  BOTTOM w0.127: U45.51 178.38,28.74 v1(178.87,29.23) ; v1(185.28,18.78) 185.98,19.47 CN2019.15 185.98,21.78 186.14,21.94 186.34,21.94 186.54,22.14 186.54,22.68 186.49,22.73 C4800.1 186.09,22.85 v1(186.09,22.45) ; v1(166.67,10.32) 166.67,11.46 164.42,13.71 CN20.15
MY12: length 54.1
  TOP w0.127: v1(167.37,10.31) 168.06,11.01 169.74,11.01 170.31,10.43 175.49,10.43 182.47,17.42 184.92,17.42 v1(186.28,18.78)
  IN1 w0.089: v1(187.08,22.42) 187.08,21.97 185.45,20.34 181.37,20.34 180.88,20.83 180.88,21.99 177.6,25.27 177.6,28.34 178.23,28.97 v1(178.23,29.23)
  BOTTOM w0.127: v1(178.23,29.23) 178.11,29.11 178.11,28.37 177.98,28.24 U45.52 ; v1(167.37,10.31) 167.37,11.4 165.42,13.34 CN20.14 ; v1(187.08,22.42) 187.08,23.06 187.27,23.25 C4811.1 187.64,22.12 187.48,21.97 187.13,21.97 186.98,21.81 CN2019.14 186.98,19.47 v1(186.28,18.78)
MY13: length 54.5
  TOP w0.127: v1(168.08,10.31) 168.52,10.75 169.63,10.75 170.2,10.18 175.59,10.18 182.58,17.16 185.67,17.16 v1(186.01,17.51) v1(187.28,18.78)
  IN1 w0.089: v1(188.19,22.45) 187.56,23.08 186.8,23.08 186.62,22.91 185.76,22.91 185.02,22.17 184.49,22.17 183.95,22.7 183.95,24.56 182.94,25.57 182.94,26.67 182.05,27.56 182.05,29.36 181.77,29.64 179.96,29.64 v1(179.51,30.09)
  BOTTOM w0.127: v1(179.51,30.09) 178.39,30.09 177.78,29.48 177.78,28.47 177.58,28.27 U45.53 ; v1(187.28,18.78) 187.98,19.47 CN2019.13 187.98,21.8 188.12,21.94 188.55,21.94 188.78,22.17 C4810.1 188.36,23.25 188.19,23.08 v1(188.19,22.45) ; CN20.13 166.42,12.98 168.08,11.32 v1(168.08,10.31)
MY14: length 53.7
  TOP w0.127: v1(168.97,10.31) 169.4,9.88 v1(169.51,9.88) 175.65,9.88 182.66,16.89 186.39,16.89 v1(188.28,18.78)
  IN1 w0.089: v1(189.34,22.42) 188.3,23.46 187.05,23.46 185.48,25.04 185.35,25.04 184.46,25.93 184.46,26.31 182.43,28.34 182.43,29.61 181.54,30.5 178.59,30.5 v1(177.32,29.23)
  BOTTOM w0.127: v1(168.97,10.31) 168.97,12.21 167.42,13.75 CN20.12 ; v1(177.32,29.23) 177.32,28.52 177.18,28.38 U45.54 ; v1(188.28,18.78) 188.98,19.47 CN2019.12 188.98,21.78 189.13,21.94 189.59,21.94 189.92,22.27 C4809.1 189.53,23.25 189.34,23.06 v1(189.34,22.42)
MY15: length 53.6
  IN1 w0.089: v1(189.28,18.78) 189.28,18.68 188.4,17.8 181.67,17.8 178.24,14.37 171.48,14.37 170.11,13 170.11,12.34 v1(170.62,11.83) ; v1(190.46,22.45) 190.46,21.23 189.31,20.09 181.26,20.09 180.68,20.67 180.68,21.91 177.17,25.42 v1(177.17,25.62)
  BOTTOM w0.127: v1(189.28,18.78) 189.98,19.47 CN2019.11 189.98,21.84 190.1,21.97 190.63,21.97 191.06,22.4 C4808.1 190.75,23.25 190.46,22.96 v1(190.46,22.45) ; CN20.11 168.42,14.02 v1(170.62,11.83) ; U45.55 176.78,26.38 176.79,26.38 177.17,25.99 v1(177.17,25.62)
MY16: length 47.2
  IN1 w0.089: v1(176.3,26.05) 176.28,26.05 176.28,25.67 176.89,25.06 177.17,25.06 180.27,21.97 180.27,20.72 181.16,19.83 190.76,19.83 v1(190.96,20.04) ; v1(170.62,12.72) 171.76,13.86 178.36,13.86 181.92,17.42 189.16,17.42 190.23,18.49 v1(190.23,18.78)
  BOTTOM w0.127: U45.56 176.38,26.13 v1(176.3,26.05) ; CN20.10 169.42,13.91 v1(170.62,12.72) ; CN2019.10 190.98,20.52 190.96,20.52 v1(190.96,20.04) 190.96,19.5 190.29,18.83 190.28,18.83 v1(190.23,18.78)
MY17: length 51.3
  IN1 w0.089: v1(172.4,11.83) 171.89,12.34 171.89,13.1 172.27,13.48 178.49,13.48 182.05,17.04 189.24,17.04 v1(190.98,18.78) ; v1(175.75,25.36) 175.75,24.48 176.69,23.54 176.69,22.27 177.22,21.74 178.75,21.74 180.9,19.58 191.17,19.58 v1(191.62,20.04)
  BOTTOM w0.127: CN2019.9 191.98,20.39 v1(191.62,20.04) 191.62,19.42 v1(190.98,18.78) ; U45.57 175.98,26.56 175.75,26.33 v1(175.75,25.36) ; v1(172.4,11.83) 170.42,13.8 CN20.9
NBSWON#: length 177
  TOP w0.127: v1(177.48,38.88) v1(177.48,39.6) 177.48,39.85 178.92,41.29 179.63,41.29 180.02,41.68 180.02,44.22 177.98,46.25 177.98,47.9 177.4,48.48 177.4,49.09 177.67,49.36 v1(178.61,49.36) 177.79,50.17 177.79,50.98 177.27,51.5 177.27,56.19 179.27,58.19 v1(183.83,58.19)
  IN3 w0.114: v1(215.47,39.34) 214.13,40.69 214.13,43.56 213.92,43.76 213.92,46.95 207.77,53.11 194.49,53.11 192.61,54.99 187.69,54.99 185.45,57.23 185.45,57.63 184.56,58.52 184.16,58.52 v1(183.83,58.19) 183.83,58.85 183.3,59.38 181.11,59.38 179.13,61.36 179.13,63.54 175.32,67.35 175.32,71.46 174.33,72.45 174.33,76.55 173.67,77.21 173.67,86.63 172.4,87.9 v1(172.4,89.53)
  BOTTOM w0.127: v1(172.4,89.53) 172.65,89.79 R265.2 ; U45.107 177.18,44.09 177.09,44.17 177.09,46.25 177.65,46.81 178.01,46.81 178.46,47.25 R730.1 178.86,47.25 179.38,47.77 179.38,48.58 v1(178.61,49.36) ; v1(177.48,38.88) 177.98,38.88 178.75,38.12 178.75,32.66 176.59,30.5 175.02,30.5 171.74,27.21 171.74,24.86 170.61,23.73 R11107.2 170.6,23.27 168.96,23.27 167.7,24.53 163.63,24.53 158.93,19.83 150.68,19.83 149.79,18.94 C805.1 R776.2 ; SW2.2 SW2.1 216.77,36.6 217.24,37.06 C785.2 R753.1 216.52,39.34 v1(215.47,39.34)
NGFF1_RST#_SSD: length 3.2
  BOTTOM w0.127: R960.1 163.12,93.62 163.38,93.87 v1(163.38,94.08) 162.52,94.94 162.5,94.94 CN23.50
NGFF3_PEDET: length 23.2
  IN1 w0.089: v1(169.6,101.11) 169.73,101.24 169.73,106.45 v1(169.22,106.95)
  BOTTOM w0.127: CN23.69 157.75,102.42 159.4,100.77 169.26,100.77 v1(169.6,101.11) ; 168.97,108.86 168.97,108.17 169.21,107.93 R961.2 ; R961.2 169.21,106.96 v1(169.22,106.95) R968.2 ; R961.2 169.19,107.56 v1(168.41,107.56)
NGFF_SATA_DET: length 51.8
  TOP w0.127: v1(171.13,105.23) 170.92,105.44 164.83,105.44 160.52,109.75 v1(159.77,109.75) v1(158.93,109.75)
  IN2 w0.114: v1(158.93,109.75) 158.93,109.87 157.54,111.27 157.54,114.45 v1(158.68,115.59)
  BOTTOM w0.127: v1(158.68,115.59) 158.68,116.59 157.13,118.14 156.44,118.14 152.59,121.99 148.34,121.99 146.42,123.91 143.88,123.91 141.59,121.61 141.59,120.72 141.37,120.5 139.16,120.5 U35.G4 ; v1(171.13,105.23) R11284.2 171.13,107.2 170.74,107.59 170.74,108.86 171,109.11 Q59.3
NGFF_SSD_CLK: length 77
  IN1 w0.089: v1(120.83,134.26) 121.09,134 121.09,133.51 121.92,132.67 124.83,132.67 127.49,135.33 139.56,135.33 140.67,134.22 149.45,134.22 150.37,133.29 152.64,133.29 153.28,132.66 155.58,132.66 156.01,132.23 156.09,132.15 156.09,131.92 v1(155.89,131.72)
  BOTTOM w0.127: CN23.55 161.25,104.34 161.37,104.47 161.37,104.72 160.97,105.13 160.97,109.87 163.76,112.67 163.76,118.36 159.19,122.93 159.19,126.91 156.07,130.04 156.07,131.54 v1(155.89,131.72) ; v1(120.83,134.26) 121.09,134 121.09,133.48 120.09,132.48 119.56,132.48 118.93,131.85 118.93,131.22 R11113.1
NGFF_SSD_CLK#: length 76.9
  IN1 w0.089: v1(156.52,131.72) 156.28,131.96 156.28,132.23 156.15,132.36 155.66,132.85 153.36,132.85 152.72,133.48 150.45,133.48 149.53,134.41 140.75,134.41 139.64,135.52 127.42,135.52 124.76,132.86 122,132.86 121.28,133.59 121.28,134.07 v1(121.47,134.26)
  BOTTOM w0.127: R11112.1 119.18,131.22 119.18,131.74 119.67,132.23 120.2,132.23 121.34,133.37 121.34,134.11 121.33,134.12 v1(121.47,134.26) ; v1(156.52,131.72) 156.32,131.52 156.32,130.14 159.44,127.02 159.44,123.04 164.01,118.46 164.01,112.56 161.22,109.77 161.22,105.23 161.63,104.82 161.63,104.47 161.75,104.34 CN23.53
NGFF_SSD_CLK#_C: length 8.4
  BOTTOM w0.076: U35.B42 116.34,123.16 116.67,123.49 116.67,124.4 117.15,124.88 117.15,125.26 117.44,125.55 117.44,125.91 117.59,126.06 117.65,126.06 117.67,126.08
  BOTTOM w0.127: 117.67,126.08 118.01,126.42 118.01,128.26 119.36,129.61 119.36,129.86 R11112.2
NGFF_SSD_CLK_C: length 8.2
  BOTTOM w0.076: U35.A42 116.42,123.71 116.5,123.8 116.5,124.47 116.99,124.95 116.99,125.33 117.28,125.62 117.28,125.98 117.48,126.18 117.48,126.24 117.49,126.26
  BOTTOM w0.127: 117.49,126.26 117.76,126.53 117.76,128.37 119.11,129.71 119.11,130.07 118.93,130.24 118.73,130.24 R11113.2
NV_PLLVDD: length 7.1
  TOP w0.254: C4204.1 173.03,123.21 173.28,123.45 L4200.2 v1(174.55,123.45) 174.81,123.45 174.93,123.34 176.84,123.34 177.23,123.73 v3(177.23,124.04) 177.23,124.61 177.22,124.62 C4205.2
  BOTTOM w0.254: U3002.AD8 177.23,124.04 v3(177.23,124.04)
ODD_EN: length 5.9
  TOP w0.127: v1(223.45,107.46) 224.08,106.83 R692.1 R704.1 R703.1
  BOTTOM w0.127: v1(223.45,107.46) 223.14,107.77 v1(223.14,108.3) 223.7,108.86 Q37.5
ODD_EN_Q: length 5.8
  BOTTOM w0.127: 226.37,106.95 227.13,106.95 v1(227.52,107.34) 227.77,107.59 R695.2 227.39,108.09 227.27,108.21 Q37.3 225.62,108.21 225.48,108.35 225.48,108.6 225.74,108.86 Q37.2
ODD_POWER: length 139.5
  TOP w0.127: v1(175.57,77.87) v1(175.57,78.68) 175.57,78.76 174.81,79.52 173.28,79.52 173.06,79.29 172.5,79.29 170.44,77.24 168.97,77.24 v1(168.18,78.02) ; v1(226.22,105.94) 226.09,105.81 R704.2
  IN1 w0.089: v1(175.57,77.87) 176.21,78.51 176.21,85.74 177.25,86.78 177.25,89.65 178.75,91.14 178.75,95.24 179.04,95.54 179.04,99.88 180.61,101.44 186.72,101.44 187.22,101.94 194.49,101.94 195.4,102.86 204.91,102.86 205.66,102.1 206.94,102.1 207.64,102.8 213.51,102.8 216.52,105.81 226.09,105.81 v1(226.22,105.94)
  IN3 w0.114: v1(173.69,32.46) 175.6,34.36 175.6,39.64 176.38,40.43 176.38,44.76 175.44,45.7 175.44,50.1 171.65,53.89 171.65,60.55 171.02,61.18 171.02,63.39 167.98,66.43 167.98,73.83 167.82,73.98 167.82,76.73 167.06,77.49 167.06,78.25 167.32,78.51 167.7,78.51 v1(168.18,78.02)
  BOTTOM w0.127: U45.71 173.08,31.4 173.26,31.58 173.26,32.02 v1(173.69,32.46)
ODD_PRSNT#: length 113.8
  TOP w0.127: v1(158.68,112.16) 159.12,112.61 v1(159.37,112.61) 160.66,112.61 161.09,112.18 161.09,109.9 165.01,105.98 173.78,105.98 176.15,108.35 181.89,108.35 182.67,109.13 186.22,109.13 187.64,107.72 194.03,107.72 201.52,115.21 205.16,115.21 207.32,113.05 207.32,112.67 207.57,112.41 207.57,111.91 209.1,110.38 217.73,110.38 218.37,111.02 227.69,111.02 228.15,110.56 228.15,107.59 226.93,106.37 226.93,105.48 226.62,105.18 C802.1 R217.2
  BOTTOM w0.127: v1(158.68,112.16) 158.17,112.67 158.17,113.07 157.45,113.8 157.45,116.39 156.85,116.99 154.11,116.99 153.03,115.91 153.03,115.4 152.36,114.73 150.07,114.73 148.96,113.62 146.15,113.62 145.51,112.98 142.6,112.98 141.53,111.91 140.67,111.91 140.33,112.25 U35.AB2
ODD_PRSNT#_C: length 7
  TOP w0.127: R217.1 C330.1 R216.1 v1(230.52,104.15) 230.68,104.15 232.29,105.76 CN9.8
PCBEEP: length 3.3
  BOTTOM w0.127: U23.12 206.98,45.68 207.14,45.84 207.42,45.84 207.52,45.74 v1(208.31,45.74) 208.36,45.74 208.84,46.23 C476.1
PCBEEP_EC: length 49.7
  TOP w0.127: v1(196.53,34.69) 196.27,34.94 196.27,41.55 196.65,41.93 197.54,41.93 198.18,42.56 198.18,44.22 198.94,44.98 204.91,44.98 207.45,47.52 210.5,47.52 213.29,44.72 v1(213.29,44.29) v1(213.29,43.45)
  IN3 w0.114: v1(185.6,26.04) 185.74,26.18 187.64,26.18 188.65,27.2 190.94,27.2 193.22,29.48 193.22,34.44 193.48,34.69 v1(196.53,34.69)
  BOTTOM w0.127: v1(185.6,26.04) 185.18,26.47 U45.34 ; D10.2 v1(213.29,43.45)
PCH_ACPRESENT: length 11.8
  BOTTOM w0.076: 134.18,97.94 133.8,98.32 133.76,98.32 132,100.07 132,101.93 132.21,102.14 U35.AY15
  BOTTOM w0.127: 134.18,97.94 R651.2 134.42,97.68 133.99,97.25 133.99,93.31 v1(134.19,93.11) 134.8,92.5 R676.2
PCH_AZ_CODEC_BITCLK: length 117.9
  IN3 w0.114: v1(172.85,77.9) 172.65,77.9 172.27,77.52 172.27,76.89 172.39,76.77 172.39,76.48 172.78,76.09 172.9,76.09 173.42,75.58 173.42,68.23 178.05,63.6 178.05,59.14 179.47,57.72 181.12,57.72 181.79,57.04 181.79,56.79 187.01,51.58 191.97,51.58 192.55,51 199.29,51 200.25,50.05 200.25,48.92 201.02,48.15 202.75,48.15 203.51,48.91 v1(204.53,48.91)
  BOTTOM w0.127: U23.6 204.58,46.05 204.65,46.12 204.65,46.37 204.53,46.5 C493.2 204.53,46.88 205.01,47.37 205.01,48.43 v1(204.53,48.91) ; R644.1 C739.2 129.16,95.23 129.16,92.46 128.91,92.2 128.91,86.73 131.38,84.26 134.16,84.26 135.85,82.57 137.72,82.57 144.93,75.37 155.93,75.37 157.1,76.54 162.49,76.54 162.66,76.72 165.72,76.72 166.24,77.24 170.49,77.24 171.15,77.9 v1(172.85,77.9)
PCH_AZ_CODEC_RST#: length 114.3
  IN3 w0.114: v1(207.7,46.17) 207.7,46.86 207.42,47.14 201.21,47.14 199.66,48.68 199.66,49.81 199.05,50.42 192.1,50.42 v1(191.67,50.85) 191.53,50.99 186.76,50.99 181.6,56.15 178.21,56.15 177.41,56.95 177.41,58.52 177.46,58.57 177.46,63.36 172.77,68.05 172.77,73.27 171.81,74.24 171.81,74.91 171.23,75.49 171.23,77.99 v1(170.22,78.99)
  BOTTOM w0.127: v1(170.22,78.99) 170.19,79.03 162.38,79.03 v1(162.24,78.89) 162.05,78.7 160.9,78.7 160.37,78.17 156.43,78.17 155.26,76.99 146.03,76.99 138.83,84.2 136.52,84.2 134.71,86.01 131.93,86.01 130.55,87.39 130.55,91.97 130.87,92.28 R660.1 ; Q29.1 192.16,51.33 v1(191.67,50.85) ; U23.11 206.58,45.79 206.97,46.17 v1(207.7,46.17)
PCH_AZ_CODEC_SDIN0: length 118.4
  IN3 w0.114: v1(170.22,79.63) 170.38,79.63 171.52,78.49 171.52,77.22 172.1,76.65 172.1,74.36 173.06,73.39 173.06,68.17 177.76,63.48 177.76,58.92 179.25,57.42 180.14,57.42 181.12,56.45 181.73,56.45 186.89,51.29 191.85,51.29 192.43,50.71 199.17,50.71 199.95,49.93 199.95,48.8 201.24,47.52 205.03,47.52 v1(205.8,48.28)
  BOTTOM w0.076: U35.BA21 129.26,102.02 129.26,100.83 131.78,98.31 131.78,97.94
  BOTTOM w0.127: v1(170.22,79.63) 168.31,79.63 168.01,79.33 161.1,79.33 160.24,78.47 156.3,78.47 155.13,77.3 146.41,77.3 139.21,84.5 136.65,84.5 134.07,87.08 132.05,87.08 130.87,88.26 130.87,91.84 131.41,92.38 131.41,93.65 131.78,94.03 131.78,97.94 ; R359.2 v1(205.8,48.28)
PCH_AZ_CODEC_SDOUT: length 109.9
  IN3 w0.114: v1(204.18,46.21) 201.3,46.21 199.08,48.44 199.08,49.57 198.81,49.84 191.41,49.84 190.84,50.41 186.52,50.41 181.36,55.57 177.97,55.57 176.83,56.71 176.83,58.9 176.88,58.95 176.88,63.11 172.14,67.85 172.14,72.03 171.62,72.55 171.62,73.42 171.22,73.82 171.22,74.67 170.64,75.25 170.64,77.27 v1(170.22,77.7)
  BOTTOM w0.127: R645.1 129.72,92.69 129.22,92.18 129.22,86.85 131.51,84.56 134.29,84.56 135.98,82.87 137.93,82.87 145.13,75.67 155.81,75.67 156.98,76.84 161.44,76.84 v1(161.6,77.01) 161.61,77.02 165.59,77.02 166.11,77.54 170.06,77.54 v1(170.22,77.7) ; U23.5 v1(204.18,46.21)
PCH_AZ_CODEC_SYNC: length 116.3
  IN3 w0.114: v1(207.24,46.62) 207.02,46.84 201.08,46.84 199.37,48.56 199.37,49.69 198.93,50.13 191.54,50.13 190.96,50.7 186.64,50.7 181.48,55.86 178.09,55.86 177.12,56.83 177.12,58.64 177.17,58.69 177.17,63.24 172.48,67.93 172.48,73.15 171.51,74.12 171.51,74.79 170.94,75.37 170.94,77.62 v1(170.22,78.33)
  BOTTOM w0.102: v1(207.24,46.62) 207.03,46.62 206.18,45.77 U23.10
  BOTTOM w0.127: v1(170.22,78.33) 169.32,78.33 169.09,78.56 165.69,78.56 165.17,78.04 160.67,78.04 160.49,77.86 156.56,77.86 155.38,76.69 145.76,76.69 138.56,83.89 136.4,83.89 134.58,85.7 131.8,85.7 130.23,87.27 130.23,92.22 130.38,92.37 130.38,96.3 R667.1
PCH_BATLOW#: length 27.8
  TOP w0.127: R628.2 TP74.1 149.15,89.17 144.33,89.17 143.58,89.92 143.22,89.92 142.83,90.31 140.59,90.31 138.74,92.16 138.74,93.18 137.34,94.57 137.34,96.29 133.91,99.71 133.91,101.11 134.55,101.75 134.55,102.76 134.04,103.27 v3(134.04,103.88)
  BOTTOM w0.127: v3(134.04,103.88) U35.AU13
PCH_BLON: length 116.4
  TOP w0.127: v1(151.31,115.72) 151.31,116.48 151.32,116.48 151.32,116.74 v1(152.17,117.59) 152.58,118 152.58,126.18 157.66,131.26 157.66,131.72 v1(157.16,132.23)
  IN1 w0.089: v1(157.16,132.23) 157.16,132.61 156.27,133.5 153.7,133.5 150.04,137.15 146.26,137.15 145.29,138.13 132.44,138.13 130.8,139.77 130.8,140.4 130.53,140.67 126.77,140.67 122.77,144.67 118.31,144.67 113.87,140.23 107.88,140.23 105.36,142.75 105.36,149.52 107.48,151.64 107.48,152.87 108.69,154.08 108.69,156.7 v1(108.64,156.75) ; v3(135.16,114.28) 135.63,113.81 137.98,113.81 138.46,113.33 145.95,113.33 146.59,113.96 148.29,113.96 149.28,114.95 150.55,114.95 v1(151.31,115.72)
  BOTTOM w0.127: v1(108.64,156.75) 108.53,156.75 108.13,156.36 R67.1 ; U35.R12 133.86,115.41 133.86,114.51 134.1,114.28 v3(135.16,114.28)
PCH_BLON_C: length 4.6
  BOTTOM w0.127: R65.2 R67.2 R66.2 109.2,155.15 v1(109.2,154.58) 108.13,154.58 108.01,154.45 Q3.5
PCH_BLON_R: length 321.6
  IN1 w0.089: v1(173.23,38.25) 172.96,38.25 170.71,36 170.25,36 168.69,34.44 164.95,34.44 163.5,32.99 161.44,32.99 160.59,32.14 160.21,32.14 157.15,29.08 113.8,29.08 113.5,29.38 81,29.38 67.83,16.21 64.56,16.21 64.23,15.89 61.61,15.89 60.96,16.54 59.27,16.54 58.68,15.96 55.58,15.96 47.12,24.42 46.04,24.42 43.25,27.21 43.25,32.3 41.71,33.83 41.71,36 35.25,42.46 35.25,51.29 33.91,52.63 33.91,60.53 35.82,62.44 36.84,62.44 40.57,66.17 40.57,67.28 43.52,70.23 43.52,74.01 43.34,74.19 43.34,78.61 44.63,79.9 44.63,91.8 61.19,108.35 71.43,108.35 75.98,112.9 v1(75.98,113.34)
  IN2 w0.114: v1(109.05,157.25) 108.51,157.25 108.13,156.86 108.13,156.86 108.13,156.57 106.23,154.66 106.23,153.69 104.36,151.83 104.36,151.11 103.42,150.17 103.42,149.84 103.11,149.53 103.11,149.37 102.72,148.99 102.72,148.18 102.13,147.58 102.13,146.55 94.58,139 94.58,138.23 83.52,127.17 83.52,121.59 80.82,118.89 80.82,118.15 79.96,117.29 76.87,117.29 75.98,116.39 v1(75.98,113.34)
  BOTTOM w0.127: v1(109.05,157.25) 109.28,157.02 109.28,156.61 109.02,156.36 R66.1 ; U45.88 173.18,38.2 v1(173.23,38.25)
PCH_BRIGHT: length 147.7
  TOP w0.127: v1(151.95,115.72) 151.95,116.61 152.85,117.51 152.85,126.04 157.92,131.11 157.92,132.1 v1(157.79,132.23)
  IN1 w0.089: v1(157.79,132.23) 157.79,132.35 156.39,133.75 153.73,133.75 150.12,137.36 146.33,137.36 145.37,138.32 132.52,138.32 130.99,139.85 130.99,140.48 130.61,140.86 126.85,140.86 122.85,144.86 118.23,144.86 114.05,140.69 v1(113.59,140.69) 107.8,140.69 105.57,142.92 105.57,149.42 107.68,151.53 107.68,152.8 109.45,154.57 109.45,157.3 109.68,157.52 109.68,159.34 110.91,160.57 110.91,162.17 111.59,162.84 111.59,163.22 114.99,166.62 114.99,168.68 v1(114.74,168.93) ; v3(134.51,115.35) 134.42,115.26 134.42,114.07 134.93,113.56 137.96,113.56 138.39,113.13 146.03,113.13 146.67,113.76 148.37,113.76 149.31,114.7 150.93,114.7 v1(151.95,115.72)
  IN2 w0.114: v1(113.59,140.69) 107.63,134.72 v1(107.63,133.62)
  BOTTOM w0.127: U35.R11 134.51,115.41 v3(134.51,115.35) ; v1(114.74,168.93) 115.63,168.93 117.79,171.09 120.21,171.09 CN5.27 ; R546.1 v1(107.63,133.62)
PCH_DP_HPD: length 7.9
  TOP w0.114: R10846.1 142.42,120.66 R564.2 141.3,119.91 139.57,119.91 138.64,118.98 138.64,118.62 137.76,117.75 v3(137.76,117.35)
  BOTTOM w0.127: U35.L7 137.76,117.41 v3(137.76,117.35)
PCH_MBCLK0_R: length 26.7
  IN1 w0.089: v3(137.76,115.35) 138.26,115.84 139.34,115.84 139.59,116.1 139.72,116.1 140.12,115.7 140.24,115.7 140.45,115.9 140.45,116.03 140.05,116.43 140.05,116.56 140.26,116.76 140.38,116.76 140.78,116.36 140.91,116.36 141.12,116.57 141.12,116.69 140.71,117.1 140.71,117.22 140.92,117.43 141.05,117.43 141.45,117.03 141.57,117.03 141.78,117.23 141.78,117.36 141.38,117.76 141.38,117.89 141.59,118.09 141.71,118.09 142.11,117.69 142.24,117.69 142.45,117.9 142.45,118.02 142.04,118.43 142.04,118.55 142.25,118.76 142.38,118.76 142.78,118.36 142.9,118.36 143.11,118.56 143.11,118.69 142.71,119.09 142.71,119.22 143.06,119.57 143.06,120.54 144.1,121.58 145.15,121.58 145.75,122.18 146.94,122.18 149.13,124.37 149.43,124.37 149.66,124.14 149.66,123.83 v1(148.91,123.08)
  BOTTOM w0.127: v3(137.76,115.35) 137.76,115.4 U35.R7 ; Q32.6 149.03,124.75 148.76,124.48 R578.2 148.76,123.22 v1(148.91,123.08)
PCH_MBDAT0_R: length 29.8
  IN1 w0.089: v1(151.82,123.08) 151.82,123.21 150.42,124.61 149.03,124.61 146.84,122.42 145.65,122.42 145.05,121.83 144,121.83 142.82,120.64 142.82,119.67 139.24,116.09 138.16,116.09 138,115.92 137.51,115.92 v3(137.09,116.35)
  BOTTOM w0.127: U35.R8 137.09,116.04 v3(137.09,116.35) ; v1(151.82,123.08) 151.47,123.44 151.47,125.98 150.68,126.77 148.39,126.77 147.9,126.27 Q32.3 146.48,126.79 R580.2
PCH_ODD_EN: length 125.3
  TOP w0.127: v1(160.2,112.16) v1(160.2,111.5) 160.2,110.43 164.92,105.71 173.97,105.71 176.35,108.08 181.99,108.08 182.77,108.86 186.11,108.86 187.64,107.33 194.01,107.33 201.63,114.95 205.03,114.95 207.07,112.92 207.07,112.54 207.32,112.29 207.32,111.78 208.97,110.13 217.99,110.13 218.62,110.76 227.51,110.76 227.89,110.38 227.89,107.72 226.68,106.5 226.68,105.73 226.12,105.18 225.87,105.18 R703.2
  IN1 w0.089: v3(133.88,116.36) 133.88,116.49 134.24,116.86 134.8,116.86 135.68,117.74 138.35,117.74 140.01,119.4 140.01,120.42 141.03,121.43 141.53,121.43 143.41,123.31 146.72,123.31 148.65,125.24 151.31,125.24 159.57,116.99 159.57,112.8 v1(160.2,112.16)
  BOTTOM w0.127: v3(133.88,116.36) 134.18,116.67 U35.N12
PCH_PWRBTN#: length 11.4
  BOTTOM w0.076: 135.07,97.94 135.07,98.05 134.3,98.83 133.72,98.83 132.42,100.12 132.42,100.81 132.56,100.94 132.56,101.45 U35.BA15
  BOTTOM w0.127: R677.2 135.82,92.83 135.07,93.58 v1(135.07,94.15) 135.07,97.94
PCH_PWROK: length 161.6
  TOP w0.127: v1(165.08,78.58) 164.27,79.39 v1(164.22,79.39) 160.45,79.39 v1(160.05,79)
  IN2 w0.114: v1(160.05,79) 160.05,92.32 160.64,92.91 160.64,114.02 v1(160.2,114.45)
  IN3 w0.114: v1(165.08,78.58) 165.56,78.1 165.56,74.96 165.25,74.64 165.25,68.37 166.44,67.18 166.44,66.35 168.01,64.78 168.01,62.25 170.28,59.98 170.28,53.32 171.25,52.35 171.25,46.63 172.24,45.64 172.24,43.68 173.63,42.29 173.63,39.59 172.36,38.32 172.36,35.59 v1(172.91,35.03)
  BOTTOM w0.127: R647.2 131.63,88.8 R648.1 131.62,88.23 132.26,87.58 134.29,87.58 136.86,85.01 139.73,85.01 146.93,77.81 154.92,77.81 156.11,79 v1(160.05,79) ; v1(172.91,35.03) 172.91,34.7 172.41,34.2 U45.78 ; R103.2 139.37,132.11 140.01,131.46 146.44,131.46 147.02,130.88 148.65,130.88 149.46,130.07 151.67,130.07 155.89,125.85 155.89,122.46 157.54,120.81 158.24,120.81 161.55,117.5 161.55,115.54 160.46,114.45 v1(160.2,114.45)
PCH_RSMRST#: length 13.5
  BOTTOM w0.076: U35.AY17 130.68,101.99 130.68,101.25 130.3,100.87 130.3,100.67 133.03,97.94
  BOTTOM w0.127: 133.03,97.94 133.08,97.89 133.08,96.97 132.89,96.78 R661.2 R642.1 133.03,95.28 133.03,92.09 v1(133.15,91.97) 133.28,91.84 R655.2
PCH_SLP_A#: length 59.7
  TOP w0.127: v1(155.76,83.59) 155.76,83.33 v1(156.35,82.75) 156.65,82.44 163.53,82.44 168.2,87.12 168.2,87.68 170.06,89.53 v1(171.07,89.53)
  IN1 w0.132: v3(132.21,106.48) 132.64,106.04 132.64,103.65 133.03,103.27 133.64,103.27 136.81,100.1 138.49,100.1 139.19,99.4 141.78,99.4 142.8,98.37 148.34,98.37 152.07,94.63 152.07,94.63 154.49,92.22 154.49,87.44 155.76,86.17 v1(155.76,83.59)
  BOTTOM w0.127: U35.AN16 v3(132.21,106.48) ; v1(171.07,89.53) 170.62,89.99 R273.2
PCH_SLP_LAN#: length 4.6
  TOP w0.127: v3(133.12,103.89) 133.12,103.45 133.36,103.2 133.36,102.21 132.52,101.37 TP30.1
  BOTTOM w0.076: 132.22,103.21 U35.AW15
  BOTTOM w0.114: v3(133.12,103.89) 132.89,103.89 132.22,103.23 132.22,103.21
PCH_SLP_S5#: length 62.8
  IN2 w0.114: v1(167.54,80.79) 168.2,81.45 168.2,83.33 167.57,83.97 167.57,88.16 168.31,88.9 v1(168.31,89.93)
  BOTTOM w0.076: U35.AY16 131.64,102.5 131.34,102.19 131.34,101.55 131.67,101.22 131.67,99.89 133.53,98.02 133.53,97.94
  BOTTOM w0.127: v1(168.31,89.93) 168.31,89.93 168.59,90.2 R279.2 ; v1(167.54,80.79) 167.35,80.6 155.92,80.6 154.9,79.59 148.29,79.59 140.86,87.01 137.41,87.01 134.04,90.38 134.04,92.09 133.53,92.6 133.53,97.94
PCH_SLP_SUS#: length 14.2
  IN3 w0.127: v3(133.12,106.48) 133.57,106.03 133.57,103.71 134.18,103.1 135.68,103.1 140.21,98.57 v1(140.65,98.57)
  BOTTOM w0.127: v1(140.65,98.57) 141.13,98.09 TP4369.1 ; v3(133.12,106.48) U35.AN15
PCH_SLP_WLAN#: length 1.5
  TOP w0.127: v1(131.09,100.55) 130.49,101.16 TP23.1
  BOTTOM w0.089: U35.BB17 131.07,100.57 v1(131.09,100.55)
PCH_SPI_CLK: length 85.7
  TOP w0.127: v1(181.92,54.26) C747.1 180.65,54.77 180.65,54.88 R684.2
  IN1 w0.089: v3(142.68,104.03) 143.19,104.03 143.54,104.39 152.04,104.39 153.46,102.97 156.94,102.97 159.89,100.02 159.89,90.26 159.31,89.68 159.31,83.43 158.96,83.08 158.96,77.25 160.11,76.1 160.11,74.78 160.56,74.34 160.56,70.32 161.65,69.23 162.18,69.23 164.27,67.15 164.27,63.52 164.52,63.26 167.68,63.26 172.91,58.04 173.39,58.04 176.91,54.52 181.66,54.52 v1(181.92,54.26)
  BOTTOM w0.076: v3(142.68,104.03) 142.55,103.91 142.55,103.78 142.08,103.31 140.63,103.31 140.43,103.51 139.96,103.51 U35.AV2
PCH_SPI_CLK_EC: length 17.4
  TOP w0.127: v1(179.84,52.85) 180.14,53.16 R687.1
  IN3 w0.114: v1(174.02,50.44) 174.48,49.98 174.48,49.61 174.3,49.42 174.3,48.15 174.81,47.64 v1(174.81,47.51)
  BOTTOM w0.127: v1(174.02,50.44) 177.32,53.74 178.95,53.74 v1(179.84,52.85) ; U45.105 176.38,44.29 175.89,44.78 175.89,45.61 175.82,45.68 C4726.1 v1(174.81,47.51)
PCH_SPI_CS0#: length 89.7
  TOP w0.127: R602.2 182.81,51.58 v1(182.56,51.84) 182.68,51.96 v1(183.19,51.96)
  IN1 w0.089: v3(141.41,104.03) 141.88,103.56 143.47,103.56 143.81,103.91 146.61,103.91 147.27,103.25 148.88,103.25 149.55,103.92 151.84,103.92 153.26,102.5 156.75,102.5 159.3,99.94 159.3,92.63 158.78,92.11 158.78,87.52 158.15,86.89 158.15,76.91 159.3,75.76 159.3,70.15 160.97,68.49 160.97,64.19 162.36,62.79 167.49,62.79 172.71,57.57 173.19,57.57 176.91,53.86 181.17,53.86 182.56,52.47 v1(182.56,51.84)
  BOTTOM w0.076: U35.AU3 139.91,103.89 140.33,103.89 140.37,103.85 141.23,103.85 v3(141.41,104.03)
  BOTTOM w0.127: U41.1 v1(182.56,51.84)
PCH_SPI_IO2: length 81.3
  TOP w0.127: v1(177.83,52.85) 177.65,52.67 177.65,51.66 178.1,51.21 R589.1
  IN1 w0.089: v3(141.41,102.52) 141.8,102.92 143.92,102.92 144.13,102.71 146.54,102.71 147.16,102.1 149.03,102.1 149.25,101.87 151.06,101.87 151.16,101.77 152.99,101.77 153.23,102.01 155.32,102.01 157.79,99.54 157.79,92.65 158.3,92.15 158.3,87.86 157.64,87.2 157.64,76.74 158.82,75.56 158.82,69.12 159.61,68.34 159.61,64.87 162.16,62.31 167.29,62.31 172.51,57.09 172.99,57.09 176.91,53.17 177.51,53.17 v1(177.83,52.85)
  BOTTOM w0.089: U35.AW2 140.2,103.04 140.72,102.52 v3(141.41,102.52)
PCH_SPI_IO3: length 89.5
  TOP w0.127: R239.1 182.06,54.87 182.37,54.57 182.37,53.67 181.79,53.1 v1(181.79,52.47)
  IN1 w0.089: v3(138.73,103.79) 139.36,103.16 144.02,103.16 144.23,102.95 146.64,102.95 147.26,102.34 148.67,102.34 149.28,102.95 152.47,102.95 153.16,102.25 156.65,102.25 159.06,99.84 159.06,93.24 158.54,92.72 158.54,87.62 157.9,86.98 157.9,76.82 159.06,75.66 159.06,69.22 159.85,68.44 159.85,64.97 162.26,62.55 167.39,62.55 172.61,57.33 173.09,57.33 176.81,53.61 180.65,53.61 v1(181.79,52.47)
  BOTTOM w0.127: v3(138.73,103.79) 138.86,103.92 U35.AU4
PCH_SPI_SI: length 93.6
  TOP w0.127: v1(178.75,51.96) 179.25,52.47 179.25,52.98 179.51,53.23 179.51,54.53 179,55.04 R691.2
  IN1 w0.089: v3(142.04,102.51) 143.19,101.37 146.49,101.37 146.91,100.94 149.07,100.94 149.41,100.6 152.84,100.6 153.56,101.33 155.03,101.33 157.03,99.33 157.03,92.6 155.42,91 155.42,87.83 156.93,86.33 156.93,76.48 158.13,75.28 158.13,69.35 157.53,68.74 157.53,65.47 160.15,62.84 160.15,57.16 161.05,56.26 161.05,55.79 163.5,53.35 168.32,53.35 171.37,56.4 172.71,56.4 177.56,51.55 178.33,51.55 v1(178.75,51.96)
  BOTTOM w0.076: U35.AV3 139.46,103.33 140.33,103.33 140.52,103.14 141.79,103.14 142.04,102.89 v3(142.04,102.51)
PCH_SPI_SI_EC: length 16
  TOP w0.127: R654.1 178.75,53.22 v1(178.75,52.85)
  IN3 w0.114: v1(174.01,49.77) 174.01,47.94 174.3,47.64 174.3,44.83 v1(174.02,44.55)
  BOTTOM w0.127: U45.102 175.18,43.88 175.06,44 174.57,44 v1(174.02,44.55) 173.9,44.66 173.6,44.66 173.41,44.85 R735.1 ; v1(174.01,49.77) 177.6,53.36 178.24,53.36 v1(178.75,52.85)
PCH_SPI_SO: length 94.4
  TOP w0.127: v1(181.79,51.84) R650.1 182.06,51.13 182.28,50.92 182.28,49.93 v1(182.53,49.68)
  IN1 w0.089: v1(181.79,51.84) 181.19,52.43 177.16,52.43 172.85,56.74 171.21,56.74 168.15,53.69 163.64,53.69 161.4,55.93 161.4,56.4 160.5,57.3 160.5,62.98 158.68,64.8 158.68,68.78 158.48,68.98 158.48,75.42 157.28,76.61 157.28,86.76 156.78,87.26 156.78,89.52 156.23,90.08 156.23,91.32 157.41,92.5 157.41,99.44 155.18,101.67 153.39,101.67 152.67,100.95 149.58,100.95 148.77,101.75 143.43,101.75 v3(142.68,102.51)
  BOTTOM w0.089: v3(142.68,102.51) 142.68,102.25 142.31,101.88 140.68,101.88 140.49,102.07 140.49,102.48 140.3,102.67 139.67,102.67 139.54,102.8 U35.AW3
PCH_SPI_SO_EC: length 25.5
  TOP w0.127: v1(180.47,51.84) 180.78,51.53 R588.1
  IN3 w0.114: v1(178.08,37.99) 178.08,38.55 180.14,40.61 180.14,47.95 180.47,48.28 v1(180.47,51.84)
  BOTTOM w0.127: v1(178.08,37.99) 177.27,37.99 175.01,40.25 175.01,41.5 175.58,42.07 U45.103 175.58,43.85 175.18,44.25 175,44.25 v1(174.74,44.52) 174.3,44.95 R736.1
PCH_SUSPWRACK: length 86.9
  TOP w0.127: v1(155.76,96.54) 155.38,96.54 154.97,96.95 154.6,96.95 R11114.2 R11140.1
  IN1 w0.089: v1(155.76,96.54) 156.14,96.16 156.14,94.1 155.08,93.04 155.08,87.69 156.58,86.19 156.58,76.35 157.71,75.21 157.71,69.41 157.16,68.85 157.16,65.35 159.05,63.46 159.05,57.78 160.65,56.18 160.65,55.08 162.98,52.74 173.66,52.74 176.64,49.76 176.64,47.85 183.19,41.3 183.19,37.74 v1(183.77,37.15)
  BOTTOM w0.127: U45.15 186.27,35.8 185.98,36.09 184.84,36.09 v1(183.77,37.15)
PCH_TRST#: length 7.3
  TOP w0.127: R534.2 105.86,128.03 106.17,127.72 v1(106.17,126.72) 106.17,126.12 v1(106.28,126)
  BOTTOM w0.076: v1(106.28,126) 106.28,125.68 107.23,124.73 107.23,123.59 107.55,123.27 U35.B59 107.55,122.88 107.08,122.41 U35.C61
PCH_TYPEC_UPFB#: length 169.3
  TOP w0.127: v3(138.39,117.34) 138.39,118 138.93,118.55 138.93,118.96 139.67,119.69 141.45,119.69 141.75,120 142.65,120 143.95,121.3 143.95,121.69 v1(144.26,122) 144.84,122.57 144.84,124.35 147.62,127.13 147.62,130.08 151.62,134.08 v1(152.08,134.08) ; R11280.1 R11251.1 28.89,101.37 v1(29.01,101.49)
  IN1 w0.089: v1(56.83,118) 57.52,117.3 71,117.3 86.79,133.09 89.78,133.09 95.89,139.2 104.88,139.2 105.62,138.45 115.47,138.45 118.7,135.22 122.16,135.22 123.89,136.95 127.71,136.95 128.16,136.5 140.82,136.5 141.79,135.53 144.84,135.53 145.36,135.01 149.77,135.01 150.7,134.08 v1(152.08,134.08)
  IN3 w0.114: v1(29.01,101.49) 30.03,102.51 31.81,102.51 33.2,103.91 41.71,103.91 51.75,113.94 52.76,113.94 v1(56.83,118)
  BOTTOM w0.127: U35.L6 138.39,117.44 v3(138.39,117.34)
PCH_VRALERT#: length 19.6
  TOP w0.102: 139.63,108.22 139.52,108.34 136.31,108.34 135.95,107.97 135.77,107.97
  TOP w0.127: 139.63,108.22 140.01,107.84 140.01,107.72 141.05,106.67 143.77,106.67 145.15,108.05 145.15,108.41 145.41,108.67 145.43,108.67 145.49,108.73 146.35,108.73 146.36,108.74 146.81,108.74 147.19,109.13 147.19,109.94 TP19.1 147.81,110.38 148.16,110.03 148.81,110.03 R211.2 ; v1(134.04,107.2) 134.37,107.54 135.34,107.54 135.77,107.97
  BOTTOM w0.127: U35.AM11 134.29,107.45 v1(134.04,107.2)
PCI_PLTRST#: length 51.3
  TOP w0.127: v1(154.36,105.13) 154.36,105.56 153.85,106.06 152.71,106.06 152.33,105.68 148.52,105.68 148.18,105.34 147.29,105.34 146.3,104.35 143.73,104.35 143.11,104.97 140.09,104.97 139.76,105.3 139.76,105.31 139.52,105.55 139.51,105.55 139.49,105.57 139.14,105.57 138.97,105.4 137.59,105.4 137.24,105.75 137.24,107.31 137.04,107.51 136.67,107.51 136.62,107.46 136.08,107.46 135.99,107.55 135.68,107.55 135.26,107.13 v3(134.95,107.13)
  BOTTOM w0.127: U35.AN10 135.32,106.9 135.18,106.9 v3(134.95,107.13) ; v1(154.36,105.13) 153.73,104.49 153.73,101.62 153.37,101.26 153.37,97.28 152.58,96.49 152.58,96.16 153.35,95.4 153.35,92.73 154.95,91.13 156.98,91.13 157.66,90.44 158.47,90.44 159.24,89.68 162.86,89.68 163.11,89.43 U14.1 163.11,88.05 163.25,87.9 163.63,87.9 163.76,88.03 U14.2
PCIE_CLKREQ_NGFF_SSD#: length 23.7
  TOP w0.127: v1(154.62,104.54) 153.47,103.4 R11111.1
  BOTTOM w0.127: v1(154.62,104.54) 154.31,104.24 154.31,99.92 154.11,99.71 154.11,97.3 155.56,95.85 155.56,94.43 155.25,94.13 155.25,92.35 155.61,91.99 158.15,91.99 159.59,90.55 160.94,90.55 162.11,91.71 R11110.2
PCIE_CLKREQ_NGFF_SSD#_R: length 2.8
  BOTTOM w0.127: CN23.52 v1(162,94.25) 162.11,94.14 R11110.1
PCIE_CLKREQ_WLAN#: length 105.1
  TOP w0.127: R253.1 178.1,178.31 R241.1 178.1,177.17 v1(178.11,177.16) ; R224.1 155.89,102.38 157.66,104.16 157.66,107.21 157,107.87 157,119.17 154.76,121.42 154.76,126.47 159.44,131.16 v1(159.44,133.75)
  IN1 w0.089: v1(178.11,177.16) 178.11,175.53 177.12,174.54 162.26,174.54 157.66,169.95 157.66,156.74 156.77,155.85 156.77,143.53 155.25,142.01 155.25,140.23 155.7,139.78 155.7,136.61 157.54,134.77 158.43,134.77 v1(159.44,133.75)
  BOTTOM w0.127: v1(178.11,177.16) 178.22,177.27 Q23.3
PCIE_LAN_WAKE#: length 415.5
  TOP w0.127: R244.1 181.16,180.11 182.3,178.96 v1(182.3,178.62) v1(182.3,176.8) ; R713.2 v1(46.67,76.09)
  IN1 w0.089: v1(163.38,166.77) 162.81,167.34 162.81,170.49 165.53,173.21 178.22,173.21 181.81,176.8 v1(182.3,176.8) ; v1(153.6,30.42) 152.82,29.65 114.03,29.65 113.74,29.95 80.74,29.95 68.08,17.31 67.55,16.78 64.32,16.78 63.99,16.46 61.85,16.46 61.19,17.11 59.03,17.11 58.45,16.53 55.81,16.53 47.35,24.99 46.28,24.99 43.82,27.44 43.82,32.56 42.32,34.05 42.32,37.51 38.16,41.68 v1(37.9,41.68)
  IN2 w0.114: v1(163.76,147.47) 163.76,146.89 165.79,144.86 165.79,140.99 167.7,139.08 167.7,133.29 166.69,132.28 165.44,132.28 165.06,131.9 165.06,130.3 163.67,128.91 163.67,120.19 163.12,119.64 163.12,105.06 164.62,103.56 164.62,101.17 165.03,100.77 165.03,94.77 166.48,93.32 166.48,82.35 v1(166.84,81.99)
  IN3 w0.114: v1(166.84,81.99) 165.72,81.99 163.76,80.03 163.76,76.75 164.07,76.44 164.07,74.5 163,73.43 163,70 162.1,69.1 162.1,65.61 160.63,64.13 160.63,56.79 161.29,56.13 161.29,51.03 160.52,50.26 160.52,43.77 161.14,43.15 161.14,38.2 161.73,37.61 161.73,33.55 159.95,31.77 155.89,31.77 154.74,30.63 153.8,30.63 v1(153.6,30.42) ; v1(37.9,41.68) 37.9,49.55 38.54,50.18 38.54,53.54 39.34,54.34 39.34,61.34 42.66,64.66 43.93,64.66 50.25,70.98 50.25,74.22 48.37,76.09 v1(46.67,76.09)
  BOTTOM w0.076: 134.82,97.94 134.18,98.57 133.74,98.57 132.26,100.05 132.26,101.08 U35.BB15
  BOTTOM w0.127: 134.82,97.94 134.84,97.91 134.84,95.31 134.42,94.89 R250.1 134.3,94.75 134.3,93.75 135.31,92.73 135.31,90.95 138.14,88.12 140.84,88.12 148.61,80.35 154.45,80.35 155.47,81.36 165.36,81.36 165.98,81.99 v1(166.84,81.99) ; v1(163.76,147.47) 164.27,147.97 164.27,149.67 165.72,151.12 165.72,154.93 162.74,157.9 162.74,166.14 v1(163.38,166.77)
PCIE_LAN_WAKE#_R: length 15
  TOP w0.127: 44.38,79.39 43.63,79.39 43.49,79.53 R709.1 R702.2 v1(41.97,80.66) ; U15.39 41.77,71.26 v1(41.92,71.11)
  BOTTOM w0.127: v1(41.97,80.66) 42.47,80.15 42.47,76.73 41.46,75.71 v1(41.46,73.44) 41.46,71.52 41.87,71.11 v1(41.92,71.11)
PCIE_RCOMPN: length 1.2
  TOP w0.305: v3(137.7,120.54) 137.82,120.66 R562.2
  BOTTOM w0.305: U35.F5 137.9,120.34 v3(137.7,120.54)
PCIE_RCOMPP: length 1.7
  TOP w0.305: v3(138.99,121.36) 138.91,121.44 R562.1
  BOTTOM w0.305: U35.E5 138.47,121.3 138.89,121.3 138.99,121.41 v3(138.99,121.36)
PCIE_REQ_LAN#_R: length 11.6
  TOP w0.127: U15.29 37.3,68.41 36.25,67.35 36.25,66.56 35.63,65.93 v1(35.19,65.93) 34.22,65.93 33.58,65.3 R276.1 34.09,64.67 34.09,63.66 R277.2 32.7,63.15 32.19,62.63 Q25.1
PCIE_RX5+_LAN: length 147.6
  TOP w0.127: v1(30.66,68.98) 30.85,68.79 32.24,68.79 C4601.2
  IN1 w0.089: v1(30.66,68.98) 30.82,68.98 31.17,69.34 31.17,71.25 30.57,71.85 30.57,73.97 31.92,75.32 31.92,89.43 38.46,95.97 40.62,95.97 49.76,105.11 51.92,105.11 57.64,110.83 70.08,110.83 82.15,122.89 82.65,122.89 88.83,129.06 92.21,129.06 96.7,133.56 98.55,133.56 99.05,133.05 107.32,133.05 109.78,130.59 109.78,130.13 111.24,128.68 113.07,128.68 115.14,126.61 115.14,124.85 115.44,124.56 119.74,124.56 121.47,122.83 121.47,121.3 122.23,120.54 122.99,120.54 124.01,119.53 126.93,119.53 127.08,119.68 127.08,120.53 127.18,120.63 127.18,120.85 v3(127.64,121.3)
  BOTTOM w0.127: v3(127.64,121.3) 127.33,120.99 U35.E23
PCIE_RX5+_LAN_C: length 3.9
  TOP w0.127: U15.25 35.7,69.07 35.36,68.73 34.98,68.73 v1(34.35,69.36) 34.35,69.03 34.02,68.7 33.75,68.7 C4601.1
PCIE_RX5-_LAN: length 147.6
  TOP w0.127: v1(30.66,68.35) 30.85,68.54 32.24,68.54 C4602.2
  IN1 w0.089: v1(30.66,68.35) 30.66,68.41 31.36,69.11 31.36,71.33 30.77,71.93 30.77,73.89 32.11,75.24 32.11,89.35 38.54,95.78 40.7,95.78 49.84,104.92 52,104.92 57.71,110.64 70.16,110.64 82.23,122.7 82.73,122.7 88.91,128.87 92.28,128.87 96.78,133.37 98.47,133.37 98.97,132.86 107.24,132.86 109.59,130.51 109.59,130.06 111.16,128.49 112.99,128.49 114.95,126.53 114.95,124.77 115.36,124.37 119.66,124.37 121.28,122.75 121.28,121.23 122.15,120.35 122.91,120.35 123.93,119.34 127.01,119.34 127.27,119.6 127.27,120.45 127.49,120.67 v3(127.64,120.67)
  BOTTOM w0.127: U35.E22 127.96,120.99 v3(127.64,120.67)
PCIE_RX5-_LAN_C: length 3.9
  TOP w0.127: U15.26 36.1,69.06 35.52,68.47 34.73,68.47 v1(34.35,68.09) 33.99,68.45 33.57,68.45 C4602.1
PCIE_RX6+_WLAN: length 127.7
  IN3 w0.114: v1(196.04,181.22) 196.2,181.22 196.58,180.84 196.58,180.03 196.17,179.62 196.17,178.55 195.76,178.14 195.76,174.39 192.77,171.39 163.56,171.39 162.72,170.56 162.72,165.88 162.87,165.73 162.87,161.69 157.28,156.1 157.28,146.13 157.56,145.85 157.56,142.23 149.14,133.8 139.74,133.8 139.53,134 133.21,134 131.94,132.73 131.41,132.73 128.77,130.09 126.63,130.09 124.7,128.16 124.7,123.97 126.57,122.1 126.57,121.89 126.27,121.58 126.27,121.25 126.37,121.15 126.52,121.15 v3(126.68,121.3)
  BOTTOM w0.127: v1(196.04,181.22) 196.17,181.22 196.55,180.84 196.55,180.64 196.4,180.49 195.51,180.49 194.24,181.75 192.21,181.75 191.96,182 CN10.41 ; U35.E25 126.36,120.99 v3(126.68,121.3)
PCIE_RX6-_WLAN: length 127.7
  IN3 w0.114: v1(126.68,120.67) 127.13,121.13 127.13,121.46 126.8,121.79 126.8,122.19 124.93,124.07 124.93,128.07 126.73,129.86 128.86,129.86 131.5,132.51 132.04,132.51 133.31,133.78 139.44,133.78 139.64,133.57 149.23,133.57 157.79,142.13 157.79,145.94 157.51,146.22 157.51,156.01 163.1,161.6 163.1,165.82 162.95,165.98 162.95,170.46 163.65,171.17 192.86,171.17 195.99,174.3 195.99,178.05 196.4,178.45 196.4,179.53 196.81,179.93 v1(196.81,181.22)
  BOTTOM w0.127: U35.F25 126.35,120.34 v1(126.68,120.67) ; v1(196.81,181.22) 196.81,180.53 196.5,180.23 195.4,180.23 194.14,181.5 CN10.43
