# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ31: length 55.5
  IN3 w0.114: v3(106.62,103.87) 106.62,102.04 105.72,101.14 105.72,99.53 105.09,98.89 105.09,92.2 103.23,90.34 103.23,76.22 102.72,75.71 102.72,74.45 102.61,74.34 102.15,74.34 102.04,74.22 102.04,73.96 102.15,73.84 102.61,73.84 102.72,73.73 102.72,73.41 102.61,73.3 102.13,73.3 102.01,73.18 102.01,72.92 102.13,72.8 102.61,72.8 102.72,72.69 102.72,72.42 102.61,72.31 102.13,72.31 102.01,72.19 102.01,71.92 102.13,71.81 102.61,71.81 102.72,71.7 102.72,71.45 102.58,71.32 102,71.32 101.89,71.2 101.89,58.23 102.76,57.36 v1(102.97,57.36)
  BOTTOM w0.127: v1(102.97,57.36) 103.47,56.86 JDIM2.84 ; U35.AU60 v3(106.62,103.87)
M_B_DQ32: length 56.5
  IN3 w0.114: v1(127.15,57.51) 127.15,57.51 129.09,59.45 129.09,62.28 129.32,62.5 129.32,68.4 129.7,68.78 129.7,80.31 128.25,81.76 128.25,82.27 124.17,86.35 124.17,90.44 122.74,91.87 121.11,91.87 120.58,92.4 120.58,99.58 119.98,100.18 119.98,100.44 118.8,101.62 118.62,101.62 117.53,102.71 117.53,103.05 117.63,103.14 v1(117.63,103.9)
  BOTTOM w0.127: JDIM2.174 127.97,56.69 v1(127.15,57.51) ; v1(117.63,103.9) 117.63,103.9 U35.AU40
M_B_DQ33: length 57.4
  IN3 w0.076: 117.25,103.3 117.25,104.14 v3(117.63,104.53)
  IN3 w0.114: v1(127.16,58.78) 128.77,60.4 128.77,62.41 129,62.64 129,68.53 129.38,68.91 129.38,80.18 127.93,81.63 127.93,82.14 123.86,86.22 123.86,90.33 122.51,91.67 121.02,91.67 120.3,92.39 120.3,99.57 119.81,100.06 119.16,100.06 117.25,101.97 117.25,103.3
  BOTTOM w0.127: JDIM2.170 126.97,56.42 126.57,56.82 126.57,58.2 v1(127.15,58.78) ; U35.AT40 v3(117.63,104.53)
M_B_DQ34: length 58.3
  IN3 w0.076: 120.72,102.24 120.49,102.24 119.87,102.86 119.87,104.14 v3(119.48,104.53)
  IN3 w0.114: v1(129.77,56.93) 129.77,56.56 129.9,56.43 130.25,56.43 130.4,56.59 130.4,58.75 132.32,60.67 132.32,63.52 132.11,63.73 132.11,69.58 133.13,70.59 133.13,76.66 132.11,77.67 132.11,81.31 130.74,82.69 130.74,83.2 126.59,87.35 126.59,90.44 124.17,92.85 124.17,98.79 120.72,102.24
  BOTTOM w0.127: v1(129.77,56.93) 129.97,56.72 JDIM2.182 ; U35.AT37 v3(119.48,104.53)
M_B_DQ35: length 58
  IN3 w0.076: v1(119.48,103.88) 119.48,103.88 119.48,102.99 120.49,101.99 120.69,101.99 121.22,101.46
  IN3 w0.114: 121.22,101.46 122.66,100.01 122.66,99.13 122.99,98.8 123.53,98.8 123.92,98.41 123.92,92.82 126.27,90.47 126.27,87.22 130.42,83.06 130.42,82.56 131.8,81.18 131.8,77.54 132.81,76.53 132.81,70.72 131.8,69.71 131.8,63.6 132.01,63.39 132.01,60.8 129.98,58.77 129.47,58.77 129.32,58.62 129.32,58.3 129.42,58.2 v1(129.77,58.2)
  BOTTOM w0.127: v1(129.77,58.2) 130.19,58.2 130.97,57.41 JDIM2.186 ; U35.AU37 v1(119.48,103.88)
M_B_DQ36: length 58.2
  IN3 w0.076: v1(117.63,105.18) 117.08,104.63 117.08,103.68 116.85,103.44 116.85,103.02
  IN3 w0.114: v1(127.15,60.21) 127.42,59.94 127.67,59.94 127.82,60.09 127.82,60.7 127.97,60.85 128.3,60.85 128.45,61.01 128.45,61.67 128.26,61.87 128.26,62.34 128.68,62.77 128.68,68.66 129.07,69.04 129.07,80.05 127.62,81.5 127.62,82.01 123.54,86.08 123.54,90.35 122.43,91.47 120.94,91.47 120.07,92.33 120.07,99.51 119.81,99.78 118.56,99.78 118.04,100.3 118.04,100.73 116.85,101.92 116.85,103.02
  BOTTOM w0.127: JDIM2.173 127.72,62.66 127.89,62.49 127.89,60.67 127.43,60.21 v1(127.15,60.21) ; U35.AR40 v1(117.63,105.18)
M_B_DQ37: length 59
  IN3 w0.076: 116.64,103.14 116.64,103.4 116.32,103.72 116.32,105.51 116.68,105.87 v3(117.61,105.87)
  IN3 w0.114: v1(127.15,61.66) 127.56,61.25 127.73,61.25 127.93,61.46 127.93,61.74 127.59,62.09 127.59,62.48 127.78,62.67 128.14,62.67 128.36,62.9 128.36,68.79 128.71,69.13 128.71,79.96 127.3,81.37 127.3,81.88 123.22,85.95 123.22,90.34 122.3,91.26 120.85,91.26 119.82,92.3 119.82,99.28 119.64,99.46 118.83,99.46 118.67,99.31 118.67,98.44 118.52,98.29 118.19,98.29 117.56,98.92 117.56,100.91 117.28,101.2 116.64,101.83 116.64,103.14
  BOTTOM w0.127: JDIM2.169 126.72,62.63 126.65,62.55 126.65,62.19 127.15,61.68 v1(127.15,61.66) ; v3(117.61,105.87) U35.AP40
M_B_DQ38: length 60
  IN3 w0.076: v3(119.48,105.83) 119.07,105.83 118.94,105.7 118.94,103.65 118.78,103.49 118.78,103.19 120.6,101.37
  IN3 w0.114: v1(131.57,60.99) 130.73,60.14 130.56,60.14 130.44,60.26 130.44,60.43 131.14,61.13 131.14,62.99 130.8,63.32 130.8,63.83 131.16,64.19 131.16,66.8 130.85,67.11 130.85,67.45 131.16,67.76 131.16,69.97 131.16,69.97 131.74,70.55 131.74,76.69 131.16,77.27 131.16,80.92 129.79,82.29 129.79,82.8 125.63,86.95 125.63,90.47 123.41,92.69 123.41,98.23 123.27,98.37 122.82,98.37 122.14,99.05 122.14,99.95 120.73,101.37 120.6,101.37
  BOTTOM w0.127: v1(131.57,60.99) 131.57,60.42 131.37,60.22 130.77,60.22 130.59,60.39 130.59,60.67 130.22,61.04 JDIM2.183 ; U35.AP37 v3(119.48,105.83)
M_B_DQ39: length 59.4
  IN3 w0.076: 121.22,101.17 120.65,101.73 120.49,101.73 119.1,103.12 119.1,105.1 119.18,105.18 v3(119.48,105.18)
  IN3 w0.114: 121.22,101.17 122.42,99.96 122.42,99.08 122.91,98.6 123.44,98.6 123.67,98.37 123.67,92.78 125.95,90.5 125.95,87.09 130.1,82.93 130.1,82.43 131.48,81.05 131.48,77.41 132.06,76.83 132.06,76.43 132.17,76.31 132.37,76.31 132.49,76.19 132.49,76.02 132.37,75.9 132.17,75.9 132.06,75.78 132.06,75.59 132.17,75.48 132.37,75.48 132.49,75.35 132.49,75.18 132.37,75.06 132.17,75.06 132.06,74.94 132.06,74.75 132.17,74.64 132.37,74.64 132.49,74.52 132.49,74.34 132.37,74.22 132.17,74.22 132.06,74.1 132.06,73.91 132.17,73.8 132.37,73.8 132.49,73.68 132.49,73.5 132.37,73.38 132.17,73.38 132.06,73.27 132.06,73.08 132.17,72.96 132.37,72.96 132.49,72.84 132.49,72.67 132.37,72.54 132.17,72.54 132.06,72.43 132.06,72.24 132.17,72.12 132.37,72.12 132.49,72 132.49,71.83 132.37,71.7 132.17,71.7 132.06,71.59 132.06,71.4 132.17,71.29 132.37,71.29 132.49,71.16 132.49,70.99 132.37,70.87 132.17,70.87 132.06,70.75 132.06,70.42 131.48,69.84 131.48,67.63 131.33,67.48 131.33,67.08 131.48,66.93 131.48,64.06 131.12,63.7 131.12,63.45 131.57,63 v1(131.57,62.26)
  BOTTOM w0.127: U35.AR37 v3(119.48,105.18) ; JDIM2.187 131.22,62.61 131.12,62.5 130.63,62.5 130.45,62.33 130.45,61.28 130.72,61.01 130.98,61.01 131.12,61.15 131.12,61.8 v1(131.57,62.26)
M_B_DQ40: length 60.4
  IN3 w0.076: 121.71,103.27 121.71,104.13 v3(121.32,104.53)
  IN3 w0.114: 121.71,103.27 121.71,102.4 124.28,99.83 125.16,99.83 125.91,99.08 125.91,92.26 126.67,91.51 127.03,91.51 128.16,90.38 128.16,88 132.49,83.67 133.23,83.67 134.09,82.82 134.09,80.75 134.82,80.01 134.82,70.06 134.34,69.58 134.34,60.87 132.64,59.17 132.64,58.31 133.38,57.58 133.38,57.37 133.16,57.15 132.95,57.15 v1(132.11,57.99)
  BOTTOM w0.127: U35.AT33 v3(121.32,104.53) ; v1(132.11,57.99) 132.33,57.99 132.57,57.75 132.57,56.94 132.97,56.54 JDIM2.194
M_B_DQ41: length 59.7
  IN3 w0.114: v3(121.32,103.88) 121.32,102.51 124.19,99.63 125.07,99.63 125.66,99.05 125.66,92.23 126.58,91.31 126.9,91.31 127.84,90.36 127.84,87.87 132.36,83.35 133.1,83.35 133.72,82.74 133.72,80.35 133.91,80.16 134.15,80.16 134.42,79.89 134.42,78.61 133.86,78.05 133.86,77.7 134.42,77.14 134.42,70.11 133.67,69.35 133.67,69.11 134.03,68.75 134.03,61 133.37,60.34 132.88,60.34 131.03,58.49 131.03,56.5 131.2,56.33 131.72,56.33 v1(132.11,56.72)
  BOTTOM w0.127: JDIM2.190 131.97,56.59 v1(132.11,56.72) ; U35.AU33 v3(121.32,103.88)
M_B_DQ42: length 58.7
  IN3 w0.076: v3(123.05,103.88) 123.05,103.36 123.41,103 123.41,102.09 124.09,101.41 124.68,101.41 126.34,99.75 126.57,99.75 128.55,97.78 128.55,97.3
  IN3 w0.114: 128.55,97.3 128.55,93.57 129.62,92.5 129.62,88.61 133.11,85.13 133.84,85.13 136.28,82.69 136.28,79.03 136.4,78.91 136.7,78.91 136.81,78.8 136.81,78.61 136.7,78.49 136.4,78.49 136.28,78.38 136.28,78.19 136.4,78.07 136.7,78.07 136.81,77.96 136.81,77.77 136.7,77.66 136.4,77.66 136.28,77.54 136.28,77.35 136.4,77.24 136.7,77.24 136.81,77.12 136.81,76.93 136.7,76.82 136.4,76.82 136.28,76.7 136.28,76.51 136.4,76.4 136.7,76.4 136.81,76.28 136.81,76.09 136.7,75.98 136.4,75.98 136.28,75.86 136.28,75.67 136.4,75.56 136.7,75.56 136.81,75.45 136.81,75.26 136.7,75.14 136.4,75.14 136.28,75.03 136.28,74.84 136.4,74.72 136.7,74.72 136.81,74.61 136.81,74.42 136.7,74.3 136.4,74.3 136.28,74.19 136.28,74 136.4,73.88 136.7,73.88 136.81,73.77 136.81,73.58 136.7,73.46 136.4,73.46 136.28,73.35 136.28,73.16 136.4,73.05 136.7,73.05 136.81,72.93 136.81,72.74 136.7,72.63 136.4,72.63 136.28,72.51 136.28,72.32 136.4,72.21 136.7,72.21 136.81,72.09 136.81,71.9 136.7,71.79 136.4,71.79 136.28,71.67 136.28,71.48 136.4,71.37 136.7,71.37 136.81,71.25 136.81,71.06 136.7,70.95 136.4,70.95 136.28,70.84 136.28,70.67 136.42,70.53 136.7,70.53 136.81,70.42 136.81,70.23 136.7,70.11 136.52,70.11 136.28,69.87 136.28,69.45 135.8,68.97 135.8,62.41 v1(135.9,62.32)
  BOTTOM w0.127: v3(123.05,103.88) U35.AU30 ; JDIM2.207 136.22,62.65 v1(135.9,62.32)
M_B_DQ43: length 59.8
  IN3 w0.076: v3(123.05,104.53) 123.05,104.41 123.59,103.88 123.59,102.14 124.16,101.57 124.75,101.57 126.41,99.92 126.64,99.92 128.75,97.81 128.75,97.43
  IN3 w0.114: 128.75,97.43 128.75,93.66 129.94,92.47 129.94,88.74 131.72,86.97 132.51,86.97 132.78,86.69 132.78,85.9 133.24,85.45 133.98,85.45 136.6,82.82 136.6,79.46 137.13,78.93 137.13,70.09 136.6,69.57 136.6,69.32 136.12,68.84 136.12,68.3 136.26,68.16 136.67,68.16 136.78,68.04 136.78,67.85 136.67,67.74 136.24,67.74 136.12,67.62 136.12,67.43 136.24,67.32 136.67,67.32 136.78,67.21 136.78,67.02 136.67,66.9 136.27,66.9 136.15,66.78 136.15,66.6 136.27,66.48 136.59,66.48 136.71,66.36 136.71,65.11 136.12,64.52 136.12,62.88 136.32,62.68 136.32,61.47 135.9,61.04 v1(135.9,61.05)
  BOTTOM w0.127: v1(135.9,61.05) 135.41,61.05 134.93,60.57 134.54,60.57 134.3,60.81 134.3,61.49 135.22,62.42 JDIM2.203 ; v3(123.05,104.53) U35.AT30
M_B_DQ44: length 61.1
  IN3 w0.076: 121.44,102.1 121.05,102.48 121.05,103.01 120.93,103.12 120.93,105.07 121.04,105.18 v3(121.32,105.18)
  IN3 w0.114: v1(133.27,60.89) 133.71,61.32 133.71,63.94 133.56,64.09 133.56,64.33 133.71,64.48 133.71,68.62 133.26,69.07 133.26,69.39 134.07,70.2 134.07,77.05 133.05,78.06 133.05,78.38 133.21,78.53 133.9,78.53 134.02,78.65 134.02,78.84 133.9,78.95 133.18,78.95 133.05,79.08 133.05,79.25 133.18,79.37 133.9,79.37 134.02,79.49 134.02,79.68 133.9,79.79 133.26,79.79 133.05,79.99 133.05,80.17 133.4,80.52 133.4,82.6 132.97,83.03 132.23,83.03 127.53,87.74 127.53,90.36 126.87,91.02 126.58,91.02 125.44,92.16 125.44,98.97 124.99,99.43 124.11,99.43 121.44,102.1
  BOTTOM w0.127: v1(133.27,60.89) 133.27,60.47 132.97,60.17 132.47,60.17 132.22,60.41 132.22,60.89 132.01,61.11 132.01,62.43 132.22,62.64 JDIM2.191 ; U35.AR33 v3(121.32,105.18)
M_B_DQ45: length 61.8
  IN3 w0.076: 121.12,102.13 120.89,102.36 120.89,102.94 120.77,103.05 120.77,105.65 120.96,105.83 v3(121.32,105.83)
  IN3 w0.114: v1(133.27,62.16) 133.07,62.16 132.95,62.28 132.95,62.55 133.05,62.66 133.3,62.66 133.39,62.75 133.39,62.97 133.28,63.08 133.07,63.08 132.95,63.2 132.95,63.38 133.07,63.5 133.28,63.5 133.39,63.62 133.39,63.81 133.28,63.92 132.88,63.92 132.74,64.06 132.74,64.29 132.85,64.41 133.18,64.41 133.39,64.62 133.39,66.49 133.26,66.62 132.84,66.62 132.74,66.72 132.74,66.9 132.85,67.01 133.27,67.01 133.39,67.13 133.39,67.31 133.27,67.43 132.84,67.43 132.74,67.54 132.74,67.68 132.84,67.79 133.22,67.79 133.39,67.96 133.39,68.49 133.15,68.73 132.86,68.73 132.74,68.85 132.74,69.32 133.75,70.33 133.75,76.91 132.74,77.93 132.74,80.3 133.08,80.65 133.08,82.47 132.84,82.72 132.66,82.72 132.47,82.52 132.3,82.52 127.21,87.61 127.21,90.36 126.84,90.73 126.58,90.73 125.23,92.09 125.23,98.88 124.88,99.22 124.66,99.22 124.47,99.03 124.22,99.03 121.12,102.13
  BOTTOM w0.127: U35.AP33 v3(121.32,105.83) ; JDIM2.195 133.22,62.68 133.1,62.55 132.47,62.55 132.24,62.32 132.24,61.26 132.39,61.11 132.72,61.11 132.85,61.23 132.85,61.93 133.07,62.16 v1(133.27,62.16)
M_B_DQ46: length 60.1
  IN3 w0.076: 128.96,97.56 128.96,97.83 126.71,100.08 126.47,100.08 123.82,102.74 123.82,103.92 123.43,104.3 123.43,104.8 v3(123.05,105.18)
  IN3 w0.114: 128.96,97.56 128.96,97.56 128.96,93.74 130.26,92.44 130.26,88.88 131.85,87.29 132.64,87.29 133.1,86.82 133.1,86.04 133.37,85.76 134.11,85.76 136.92,82.95 136.92,79.59 137.45,79.06 137.45,69.96 137.01,69.53 137.01,69.15 136.82,68.97 136.82,68.45 137.17,68.11 137.17,66.26 137.03,66.13 137.03,64.98 136.44,64.39 136.44,63.02 136.65,62.8 136.65,61.35 136.33,61.03 136.33,59.81 136.25,59.73 136.06,59.73 135.95,59.62 135.95,59.43 136.06,59.31 136.48,59.31 136.65,59.14 136.65,58.6 v1(136.2,58.15)
  BOTTOM w0.127: JDIM2.204 135.47,57.39 135.31,57.55 135.31,57.92 135.54,58.15 v1(136.2,58.15) ; v3(123.05,105.18) U35.AR30
M_B_DQ47: length 60.9
  IN3 w0.076: 129.16,97.34 129.16,97.86 127.2,99.83 127.2,100.59 126.92,100.87 125.92,100.87 124,102.8 124,103.97 123.6,104.37 123.6,105.28 v3(123.05,105.83)
  IN3 w0.114: 129.16,97.34 129.16,93.85 130.57,92.44 130.57,89.01 131.98,87.6 132.77,87.6 133.43,86.94 133.43,86.35 133.71,86.08 134.24,86.08 137.24,83.09 137.24,79.72 137.88,79.08 137.88,69.9 137.51,69.53 137.51,66.16 137.35,66 137.35,64.85 136.98,64.49 136.98,56.35 136.78,56.15 136.45,56.15 136.2,56.41 v1(136.2,56.88)
  BOTTOM w0.127: v3(123.05,105.83) U35.AP30 ; JDIM2.208 136.47,56.6 v1(136.2,56.88)
M_B_DQ48: length 59.2
  IN3 w0.076: 128.45,99.71 128.43,99.74 128.23,99.74 127.86,100.11 127.86,100.87 127.19,101.53 126.2,101.53 124.91,102.82 v3(124.91,103.89)
  IN3 w0.114: v1(138.48,61.01) 139.46,61.98 139.46,62.85 139.3,63 139.14,63 139.02,63.12 139.02,63.38 139.14,63.5 139.3,63.5 139.46,63.65 139.46,65.94 139.08,66.31 139.08,66.84 139.2,66.96 139.31,66.96 139.46,67.1 139.46,67.31 139.31,67.45 139.2,67.45 139.08,67.57 139.08,67.83 139.2,67.95 139.73,67.95 139.87,68.09 139.87,68.3 139.73,68.44 139.23,68.44 139.08,68.59 139.08,68.79 139.23,68.94 139.86,68.94 140.01,69.09 140.01,69.29 139.86,69.44 139.6,69.44 139.46,69.59 139.46,69.8 139.6,69.95 139.86,69.95 140.01,70.1 140.01,81.11 139.86,81.26 139.6,81.26 139.46,81.4 139.46,81.61 139.6,81.75 139.88,81.75 140.01,81.89 140.01,82.08 139.88,82.21 139.61,82.21 139.46,82.37 139.46,83.17 132.24,90.39 132.24,92.88 131.53,93.59 131.53,94.69 130.07,96.14 130.07,98.1 128.45,99.71
  BOTTOM w0.127: v3(124.91,103.89) U35.AU27 ; v1(138.48,61.01) 137.75,61.01 137.22,61.53 JDIM2.211
M_B_DQ49: length 59.6
  IN3 w0.076: 128.33,99.46 128.29,99.5 128.23,99.5 127.69,100.04 127.69,100.8 127.12,101.37 126.13,101.37 124.5,102.99 124.5,104.03 124.91,104.43 v3(124.91,104.54)
  IN3 w0.114: v1(138.48,62.3) 138.27,62.52 138.27,63.99 139.14,64.86 139.14,65.81 138.77,66.18 138.77,69.01 139.14,69.38 139.14,70.08 139.63,70.57 139.63,70.78 139.48,70.92 139.31,70.92 139.16,71.07 139.16,71.27 139.31,71.42 139.46,71.42 139.63,71.59 139.63,71.74 139.46,71.91 139.29,71.91 139.14,72.06 139.14,72.25 139.29,72.41 139.48,72.41 139.63,72.55 139.63,72.76 139.48,72.9 139.29,72.9 139.14,73.05 139.14,73.25 139.29,73.4 139.48,73.4 139.63,73.54 139.63,73.75 139.48,73.89 139.29,73.89 139.14,74.05 139.14,74.24 139.29,74.39 139.48,74.39 139.63,74.53 139.63,74.74 139.48,74.88 139.29,74.88 139.14,75.04 139.14,75.23 139.29,75.38 139.48,75.38 139.63,75.52 139.63,75.73 139.48,75.87 139.29,75.87 139.14,76.03 139.14,76.22 139.29,76.37 139.48,76.37 139.63,76.51 139.63,76.72 139.48,76.86 139.29,76.86 139.14,77.02 139.14,77.21 139.29,77.36 139.48,77.36 139.63,77.51 139.63,77.71 139.48,77.86 139.29,77.86 139.14,78.01 139.14,78.2 139.29,78.35 139.48,78.35 139.63,78.5 139.63,78.7 139.48,78.85 139.29,78.85 139.14,79 139.14,79.19 139.29,79.34 139.48,79.34 139.63,79.49 139.63,79.69 139.48,79.84 139.29,79.84 139.14,79.99 139.14,80.18 139.29,80.33 139.48,80.33 139.63,80.48 139.63,80.68 139.48,80.83 139.29,80.83 139.14,80.98 139.14,81.78 138.99,81.93 138.72,81.93 138.58,82.08 138.58,82.29 138.72,82.44 138.99,82.44 139.14,82.6 139.14,82.8 138.99,82.95 138.65,82.95 138.5,83.1 138.5,83.68 131.86,90.32 131.86,92.88 131.3,93.44 131.3,94.58 129.85,96.03 129.85,97.94 128.33,99.46
  BOTTOM w0.127: JDIM2.215 138.22,62.56 v1(138.48,62.3) ; v3(124.91,104.54) U35.AT27
M_B_DQ50: length 58
  IN3 w0.076: 127.95,101.87 127.78,101.87 126.33,103.32 126.33,104.05 v3(125.84,104.54)
  IN3 w0.114: v1(141.35,62.18) 141.37,62.2 141.37,64.67 141.48,64.79 141.66,64.79 141.79,64.92 141.79,66.95 141.64,67.1 141.64,67.34 141.79,67.5 141.79,68.97 141.88,69.06 142.06,69.06 142.17,69.18 142.17,69.44 142.06,69.56 141.88,69.56 141.79,69.65 141.79,69.97 141.88,70.05 142.06,70.05 142.17,70.17 142.17,70.44 142.06,70.55 141.88,70.55 141.79,70.64 141.79,70.93 141.9,71.05 142.06,71.05 142.17,71.16 142.17,71.43 142.06,71.54 141.9,71.54 141.79,71.65 141.79,71.92 141.9,72.04 142.06,72.04 142.17,72.15 142.17,72.42 142.06,72.53 141.9,72.53 141.79,72.65 141.79,72.91 141.9,73.03 142.06,73.03 142.17,73.14 142.17,73.41 142.06,73.52 141.9,73.52 141.79,73.64 141.79,73.9 141.9,74.02 142.06,74.02 142.17,74.13 142.17,74.4 142.06,74.51 141.88,74.51 141.79,74.6 141.79,74.92 141.88,75.01 142.06,75.01 142.17,75.12 142.17,75.39 142.06,75.5 141.88,75.5 141.79,75.59 141.79,75.91 141.88,76 142.06,76 142.17,76.11 142.17,76.38 142.06,76.49 141.9,76.49 141.79,76.61 141.79,76.87 141.9,76.99 142.06,76.99 142.17,77.1 142.17,77.37 142.06,77.48 141.9,77.48 141.79,77.6 141.79,77.86 141.9,77.98 142.06,77.98 142.17,78.09 142.17,78.36 142.06,78.47 141.9,78.47 141.79,78.59 141.79,78.86 141.9,78.97 142.06,78.97 142.17,79.08 142.17,79.35 142.06,79.47 141.9,79.47 141.79,79.58 141.79,79.85 141.9,79.96 142.06,79.96 142.17,80.07 142.17,80.34 142.06,80.46 141.9,80.46 141.79,80.57 141.79,83.35 134.02,91.12 134.02,93.9 131.07,96.84 131.07,98.42 129.52,99.97 129.52,100.57 128.22,101.87 127.95,101.87
  BOTTOM w0.127: v1(141.35,62.18) 141.2,62.18 140.72,62.66 JDIM2.225 ; v3(125.84,104.54) U35.AT25
M_B_DQ51: length 57.6
  IN3 w0.076: 128.07,101.62 127.8,101.62 125.84,103.59 v3(125.84,103.89)
  IN3 w0.114: v1(141.37,58.55) 141.14,58.33 140.78,58.33 140.61,58.5 140.61,59.15 140.92,59.46 140.92,67.07 141.47,67.63 141.47,83.22 133.7,90.99 133.7,93.83 130.87,96.66 130.87,98.32 129.32,99.87 129.32,100.49 128.18,101.62 128.07,101.62
  BOTTOM w0.127: v1(141.37,58.55) 141.01,58.55 140.47,58.01 JDIM2.224 ; v3(125.84,103.89) U35.AU25
M_B_DQ52: length 60.1
  IN3 w0.076: v3(124.91,105.84) 124.53,105.46 124.53,104.28 124.34,104.1 124.34,102.92 126.06,101.2 127.05,101.2 127.53,100.73 127.53,99.97 129.62,97.87 129.62,97.56
  IN3 w0.114: v1(138.54,57.97) 138.32,57.75 138.1,57.75 137.92,57.93 137.92,64.1 138.82,64.99 138.82,65.68 138.45,66.05 138.45,69.14 138.82,69.51 138.82,81.39 138.18,82.03 138.18,83.55 131.53,90.2 131.53,92.81 130.43,93.9 130.43,94.94 129.62,95.75 129.62,97.56
  BOTTOM w0.127: v1(138.54,57.97) 137.93,57.97 137.47,57.51 JDIM2.212 ; v3(124.91,105.84) U35.AP27
M_B_DQ53: length 60.5
  IN3 w0.076: 129.39,97.59 129.39,97.87 127.36,99.9 127.36,100.66 126.99,101.04 125.99,101.04 124.17,102.85 124.17,104.17 124.36,104.36 124.36,105.94 v3(124.91,106.49)
  IN3 w0.114: 129.39,97.59 129.39,95.6 130.17,94.83 130.17,93.73 131.2,92.7 131.2,90.08 137.86,83.42 137.86,81.9 138.5,81.26 138.5,69.64 138.13,69.27 138.13,65.82 137.97,65.65 137.97,64.59 137.61,64.23 137.61,56.31 137.76,56.15 137.99,56.15 v1(138.54,56.7)
  BOTTOM w0.127: v3(124.91,106.49) U35.AN27 ; JDIM2.216 138.47,56.64 v1(138.54,56.7)
M_B_DQ54: length 60.1
  IN3 w0.114: v3(125.84,106.5) 126.41,105.92 126.77,105.92 127.13,105.56 127.13,103.05 127.82,102.36 128.31,102.36 129.93,100.74 129.93,100.14 131.63,98.44 131.63,97.05 134.65,94.03 134.65,91.39 142.8,83.23 142.8,65.03 142,64.23 142,62.76 142.11,62.66 142.11,60.41 141.94,60.24 141.94,57.46 141.76,57.28 v1(141.37,57.28)
  BOTTOM w0.127: v1(141.37,57.28) 141.47,57.18 JDIM2.228 ; v3(125.84,106.5) U35.AN25
M_B_DQ55: length 59.5
  IN3 w0.076: v3(125.84,105.85) 126.1,105.85 126.26,105.68 126.26,104.37 126.51,104.12 126.51,103.38 127.76,102.13 127.95,102.13
  IN3 w0.114: v1(141.37,60.91) 141.79,61.34 141.79,62.53 141.68,62.63 141.68,64.36 142.11,64.79 142.11,65.67 142.2,65.76 142.36,65.76 142.47,65.87 142.47,66.14 142.36,66.25 142.22,66.25 142.11,66.37 142.11,66.63 142.22,66.75 142.36,66.75 142.47,66.86 142.47,67.13 142.36,67.24 142.22,67.24 142.11,67.36 142.11,67.62 142.22,67.74 142.36,67.74 142.47,67.85 142.47,68.12 142.36,68.23 142.22,68.23 142.11,68.35 142.11,68.67 142.49,69.05 142.49,80.47 142.11,80.86 142.11,81.18 142.22,81.29 142.36,81.29 142.47,81.41 142.47,81.67 142.36,81.79 142.22,81.79 142.11,81.9 142.11,82.17 142.22,82.28 142.36,82.28 142.47,82.4 142.47,82.66 142.36,82.78 142.22,82.78 142.11,82.89 142.11,83.48 134.33,91.26 134.33,93.99 131.32,97 131.32,98.45 129.72,100.05 129.72,100.65 128.25,102.13 127.95,102.13
  BOTTOM w0.127: v1(141.37,60.91) 142.04,60.91 142.27,61.14 142.27,62.28 142.12,62.43 141.85,62.43 141.72,62.56 JDIM2.229 ; v3(125.84,105.85) U35.AP25
M_B_DQ56: length 61.4
  IN3 w0.076: 128.97,102.58 128.8,102.76 128.8,103.08 128.1,103.77 128.1,104.06 v3(128.54,104.5)
  IN3 w0.114: 128.97,102.58 130.56,100.99 130.56,100.39 132.29,98.66 132.29,97.48 135.51,94.25 135.51,92.3 144.54,83.27 144.54,80.44 144.66,80.33 144.98,80.33 145.09,80.21 145.09,79.95 144.98,79.83 144.66,79.83 144.54,79.72 144.54,79.45 144.66,79.34 144.98,79.34 145.09,79.22 145.09,78.96 144.98,78.84 144.66,78.84 144.54,78.73 144.54,78.46 144.66,78.35 144.98,78.35 145.09,78.23 145.09,77.97 144.98,77.85 144.66,77.85 144.54,77.74 144.54,77.47 144.66,77.36 144.98,77.36 145.09,77.24 145.09,76.98 144.98,76.86 144.66,76.86 144.54,76.75 144.54,76.48 144.66,76.37 144.98,76.37 145.09,76.25 145.09,75.99 144.98,75.87 144.66,75.87 144.54,75.76 144.54,75.49 144.66,75.38 144.98,75.38 145.09,75.26 145.09,74.99 144.98,74.88 144.66,74.88 144.54,74.77 144.54,74.5 144.66,74.39 144.98,74.39 145.09,74.27 145.09,74 144.98,73.89 144.66,73.89 144.54,73.78 144.54,73.51 144.66,73.39 144.98,73.39 145.09,73.28 145.09,73.01 144.98,72.9 144.66,72.9 144.54,72.78 144.54,72.52 144.74,72.33 144.74,71.91 144.54,71.72 144.54,70.24 144.07,69.78 144.07,61.85 v1(143.19,60.97)
  BOTTOM w0.127: v1(143.19,60.97) 142.87,60.97 142.72,61.11 JDIM2.233 ; v3(128.54,104.5) U35.AT22
M_B_DQ57: length 60.9
  IN3 w0.114: v3(128.54,103.87) 129,103.41 129,102.84 130.73,101.11 131.12,101.11 131.5,100.73 131.5,99.84 132.52,98.83 132.52,97.58 135.82,94.28 135.82,92.45 145.41,82.86 145.41,82.36 145.29,82.25 145.01,82.25 144.86,82.1 144.86,81.9 145.01,81.75 145.29,81.75 145.41,81.64 145.41,81.37 145.29,81.26 145.01,81.26 144.86,81.11 144.86,80.91 145.01,80.76 145.29,80.76 145.41,80.65 145.41,72.77 145.09,72.45 145.09,72.13 145.41,71.81 145.41,71.42 145.29,71.31 145.01,71.31 144.86,71.16 144.86,70.96 145.01,70.81 145.29,70.81 145.41,70.7 145.41,70.44 144.46,69.49 144.46,61.49 143.69,60.73 143.69,59.95 143.58,59.83 143.41,59.83 143.26,59.69 143.26,59.48 143.41,59.34 143.58,59.34 143.69,59.22 143.69,58.31 143.55,58.17 v1(143.17,58.17)
  BOTTOM w0.127: v3(128.54,103.87) U35.AU22 ; v1(143.17,58.17) 143.16,58.17 143.04,58.17 142.47,57.6 JDIM2.232
M_B_DQ58: length 59.9
  IN3 w0.114: v1(146.97,61.72) 146.87,61.82 146.87,83.46 137.16,93.18 137.16,93.62 136.91,93.86 136.91,95.08 136,96 136,96.51 135.52,96.99 135.52,97.15 135.79,97.42 135.79,97.59 135.66,97.72 135.49,97.72 135.21,97.44 135.06,97.44 134.92,97.59 134.92,97.74 135.2,98.02 135.2,98.19 135.08,98.32 134.9,98.32 134.62,98.03 134.47,98.03 134.32,98.18 134.32,98.33 134.61,98.61 134.61,98.79 134.48,98.91 134.31,98.91 134.03,98.63 133.87,98.63 133.74,98.77 133.74,99.18 133.33,99.59 132.77,99.59 132.21,100.15 132.21,100.5 132.31,100.6 132.42,100.6 132.59,100.78 132.59,101.12 131.37,102.34 130.51,102.34 130.1,102.75 130.1,103.55 129.47,104.19 v3(129.47,104.53)
  BOTTOM w0.127: v3(129.47,104.53) U35.AU21 ; v1(146.97,61.72) 145.92,60.66 145.54,60.66 145.32,60.88 145.32,61.59 145.72,61.99 JDIM2.245
M_B_DQ59: length 60.9
  IN3 w0.076: v3(129.47,105.18) 129.85,104.8 129.85,104.17 130.44,103.57 130.44,103.56 131.34,102.67
  IN3 w0.114: 131.34,102.67 132.61,101.39 133.03,101.39 133.79,100.63 133.79,100.05 136.66,97.18 136.66,97.02 136.38,96.74 136.38,96.58 136.57,96.39 136.73,96.39 137.01,96.67 137.17,96.67 137.49,96.36 137.49,93.29 147.19,83.59 147.19,83.05 147.44,82.79 147.44,82.3 147.19,82.04 147.19,81.55 147.44,81.29 147.44,80.8 147.19,80.54 147.19,80.05 147.44,79.79 147.44,79.3 147.19,79.04 147.19,78.55 147.44,78.3 147.44,77.8 147.19,77.55 147.19,77.23 147.44,76.97 147.44,76.48 147.19,76.23 147.19,75.73 147.44,75.48 147.44,74.98 147.19,74.73 147.19,74.23 147.44,73.98 147.44,73.48 147.19,73.23 147.19,72.73 147.44,72.48 147.44,71.98 147.19,71.73 147.19,71.23 147.44,70.98 147.44,70.48 147.19,70.23 147.19,69.74 147.44,69.48 147.44,68.99 147.19,68.73 147.19,68.24 147.44,67.98 147.44,67.49 147.19,67.23 147.19,66.74 147.44,66.48 147.44,65.99 147.19,65.73 147.19,65.24 147.44,64.99 147.44,64.49 147.21,64.26 147.21,63.72 147.41,63.51 147.41,63.11 147.21,62.91 147.21,62.35 147.44,62.12 147.44,60.89 147,60.45 v1(146.97,60.45)
  BOTTOM w0.127: v3(129.47,105.18) U35.AT21 ; JDIM2.249 146.72,62.61 147.63,61.7 147.63,61.1 v1(146.97,60.45)
M_B_DQ60: length 62.8
  IN3 w0.114: v1(128.54,106.41) 127.44,105.31 127.44,103.87 128.37,102.94 128.37,102.59 130.13,100.82 130.13,100.22 131.83,98.52 131.83,97.28 135.01,94.11 135.01,91.91 143.43,83.49 143.43,64.78 142.73,64.08 142.73,60.15 142.56,59.99 142.56,56.8 141.88,56.12 141.88,55.91 142.18,55.61 142.39,55.61 143.17,56.39 v1(143.17,56.9)
  BOTTOM w0.127: v1(128.54,106.41) U35.AN22 ; JDIM2.236 143.47,56.79 143.36,56.9 143.17,56.9 v1(143.17,56.9)
M_B_DQ61: length 62.5
  IN3 w0.114: v1(143.19,62.24) 143.05,62.38 143.05,62.77 143.29,63.01 143.29,63.35 143.05,63.59 143.05,63.95 143.74,64.65 143.74,70.33 143.86,70.45 144.11,70.45 144.23,70.56 144.23,70.83 144.11,70.94 143.86,70.94 143.74,71.06 143.74,71.32 143.86,71.44 144.11,71.44 144.23,71.55 144.23,71.82 144.11,71.93 143.86,71.93 143.74,72.05 143.74,72.32 143.86,72.43 144.11,72.43 144.23,72.54 144.23,72.81 144.11,72.92 143.86,72.92 143.74,73.04 143.74,73.31 143.86,73.42 144.11,73.42 144.23,73.53 144.23,73.8 144.11,73.92 143.86,73.92 143.74,74.03 143.74,74.3 143.86,74.41 144.11,74.41 144.23,74.52 144.23,74.79 144.11,74.91 143.86,74.91 143.74,75.02 143.74,75.29 143.86,75.4 144.11,75.4 144.23,75.52 144.23,75.78 144.11,75.9 143.86,75.9 143.74,76.01 143.74,76.28 143.86,76.39 144.11,76.39 144.23,76.51 144.23,76.77 144.11,76.89 143.86,76.89 143.74,77 143.74,77.27 143.86,77.38 144.11,77.38 144.23,77.5 144.23,77.76 144.11,77.88 143.86,77.88 143.74,77.99 143.74,78.26 143.86,78.37 144.11,78.37 144.23,78.49 144.23,78.75 144.11,78.87 143.86,78.87 143.74,78.98 143.74,79.25 143.86,79.36 144.11,79.36 144.23,79.48 144.23,79.74 144.11,79.86 143.86,79.86 143.74,79.97 143.74,80.24 143.86,80.35 144.11,80.35 144.23,80.47 144.23,80.74 144.11,80.85 143.86,80.85 143.74,80.96 143.74,81.23 143.86,81.34 144.11,81.34 144.23,81.46 144.23,81.73 144.11,81.84 143.86,81.84 143.74,81.95 143.74,82.22 143.86,82.34 144.11,82.34 144.23,82.45 144.23,82.72 144.11,82.83 143.86,82.83 143.74,82.94 143.74,83.62 135.31,92.06 135.31,94.13 132.06,97.38 132.06,98.58 130.33,100.31 130.33,100.91 128.57,102.67 128.57,103.03 127.73,103.87 127.73,104.96 v1(128.54,105.77)
  BOTTOM w0.127: v1(128.54,105.77) U35.AP22 ; v1(143.19,62.24) 143.48,62.24 143.72,62.48 JDIM2.237
M_B_DQ62: length 61.7
  IN3 w0.076: v3(129.47,106.43) 129.82,106.43 130.01,106.23 130.01,104.27 130.34,103.95 130.35,103.95
  IN3 w0.114: 130.35,103.95 132.52,101.78 133.12,101.78 134.24,100.65 134.24,100.05 137.8,96.49 137.8,93.43 147.76,83.47 147.76,58.79 147.38,58.41 147.13,58.41 146.97,58.56 v1(146.97,59.18)
  BOTTOM w0.127: v1(146.97,59.18) JDIM2.250 ; v3(129.47,106.43) 129.43,106.43 U35.AP21
M_B_DQ63: length 62.5
  IN3 w0.114: v1(129.47,107.07) 129.63,107.07 130.11,106.59 130.35,106.59 130.85,106.09 130.85,103.72 132.58,102 133.41,102 134.71,100.7 134.71,100.03 138.12,96.62 138.12,93.56 148.14,83.54 148.14,58.69 146.38,56.94 v1(145.51,56.94)
  BOTTOM w0.127: v1(145.51,56.94) 145.97,56.47 JDIM2.246 ; v1(129.47,107.07) U35.AN21
M_B_DQS0: length 82.5
  IN3 w0.114: v1(103.76,109.8) 103.31,110.24 102.97,110.24 102.45,110.76 101.48,110.76 100.56,111.68 100.56,112.97 100,113.54 92.33,113.54 89.27,110.48 89.27,109.63 81.82,102.18 81.82,88.08 84.63,85.27 84.63,68.26 84.3,67.93 84.3,67.32 84.54,67.08 84.98,67.08 85.09,66.97 85.09,66.57 84.98,66.46 84.54,66.46 84.3,66.22 84.3,65.64 84.54,65.4 84.98,65.4 85.09,65.29 85.09,64.9 84.98,64.78 84.54,64.78 84.3,64.54 84.3,63.97 84.54,63.73 85.03,63.73 85.19,63.56 85.19,63.24 85.05,63.11 84.51,63.11 84.3,62.89 84.3,60.33 84.54,60.09 84.99,60.09 v1(85.25,59.84)
  BOTTOM w0.127: JDIM2.13 85.72,62.63 85.64,62.55 85.64,62.41 86.15,61.91 86.15,60.5 85.88,60.23 85.64,60.23 v1(85.25,59.84) ; U35.AH65 v1(103.76,109.8)
M_B_DQS1: length 72.1
  IN3 w0.114: v1(95.55,110.14) 95.34,109.94 95.34,109.56 95,109.21 93.63,109.21 93.01,108.59 93.01,106.64 90.93,104.55 90.93,103.41 86.02,98.51 86.02,90.51 90.64,85.89 90.64,68.76 90.31,68.43 90.31,60.96 90.03,60.68 90.03,59.86 89.44,59.28 89.44,58.24 89.61,58.07 89.86,58.07 89.99,58.21 v1(89.99,58.65)
  BOTTOM w0.076: U35.AG70 101.16,110.07 101.11,110.12 100.71,110.12 100.56,110.19 100.47,110.19 100.32,110.13 99.95,110.13 99.52,110.56 99,110.56 98.81,110.75 96.03,110.75 95.92,110.85 95.2,110.85 95.08,110.74 95.08,110.54 95.13,110.48 95.31,110.48 95.43,110.61 95.64,110.61 95.71,110.53 95.71,110.31 v1(95.55,110.14)
  BOTTOM w0.127: v1(89.99,58.65) 89.99,58.4 90.1,58.3 90.48,58.3 90.85,57.93 90.85,56.48 90.97,56.35 JDIM2.34
M_B_DQS2: length 63.7
  IN3 w0.076: v3(103.83,105.15) 103.46,104.78 103.46,104.26 103.54,104.18 103.54,103.43 103.56,103.4 103.56,103.38
  IN3 w0.114: v1(95.35,60.35) 95.35,60.82 95.6,61.06 95.94,61.06 96.16,61.28 96.16,62.59 95.65,63.1 95.65,67.04 96.13,67.52 96.13,86.72 94.61,88.25 93.94,88.25 90.02,92.17 90.02,96.64 92.46,99.08 97.47,99.08 97.98,99.58 98.35,99.58 99.26,100.49 99.89,100.49 100.34,100.93 100.34,101.88 101.06,102.61 103.19,102.61 103.56,102.99 103.56,103.38
  BOTTOM w0.127: JDIM2.55 96.22,62.7 96.12,62.59 96.12,60.97 95.86,60.71 95.44,60.71 95.35,60.62 v1(95.35,60.35) ; v3(103.83,105.15) U35.AR65
M_B_DQS3: length 55.5
  IN3 w0.076: 105.37,101.01 105.37,101.01 105.34,101.04 105.34,101.11 106.39,102.17 106.39,103.45 106.24,103.6 106.24,104.82 v1(106.6,105.18)
  IN3 w0.114: 105.37,101.01 105.37,99.61 104.17,98.42 104.17,92.35 102.61,90.79 102.61,76.49 101.26,75.14 101.26,60.49 100.74,59.96 100.46,59.96 100.03,59.53 100.03,58.05 100.12,57.96 100.29,57.96 100.46,58.13 v1(100.46,58.59)
  BOTTOM w0.127: U35.AR60 v1(106.6,105.18) ; v1(100.46,58.59) 100.46,58.32 100.56,58.21 100.93,58.21 101.37,57.77 101.37,56.42 101.47,56.32 JDIM2.76
M_B_DQS4: length 58.3
  IN3 w0.076: 118.52,102.8 118.51,102.81 118.51,102.85 118.01,103.35 118.01,104.26 118.12,104.37 118.12,104.74 v3(118.56,105.18)
  IN3 w0.114: v1(129.72,61.68) 129.72,61.42 129.85,61.3 130.12,61.3 130.3,61.48 130.3,62.64 129.94,63 129.94,64.16 130.32,64.54 130.32,66.45 129.94,66.83 129.94,67.72 130.32,68.11 130.32,70.57 130.56,70.81 130.82,70.81 130.9,70.9 130.9,71.34 130.82,71.43 130.56,71.43 130.32,71.67 130.32,72.25 130.56,72.49 130.84,72.49 130.9,72.55 130.9,73.02 130.82,73.11 130.56,73.11 130.32,73.35 130.32,73.92 130.56,74.16 130.82,74.16 130.9,74.25 130.9,74.7 130.82,74.78 130.56,74.78 130.32,75.02 130.32,75.6 130.56,75.84 130.84,75.84 130.9,75.9 130.9,76.35 130.32,76.93 130.32,80.57 128.87,82.02 128.87,82.53 124.8,86.61 124.8,90.6 123.3,92.09 122.64,92.09 121.89,92.84 121.89,98.71 121,99.6 121,100.33 118.52,102.8
  BOTTOM w0.127: v1(129.72,61.68) 129.72,61.11 129.59,60.98 129.33,60.98 129.1,61.21 129.1,62.53 129.22,62.66 JDIM2.179 ; U35.AR38 v3(118.56,105.18)
M_B_DQS5: length 60.2
  IN3 w0.076: v1(122.11,105.16) 122.11,105.05 122.67,104.49 122.67,103.58 122.7,103.55 122.7,103.54
  IN3 w0.114: v1(134.09,58.07) 134.09,58.33 134.2,58.44 134.58,58.44 135.18,59.05 135.18,69.23 135.66,69.71 135.66,82.43 133.58,84.51 132.84,84.51 129,88.35 129,91.04 127.15,92.89 127.15,98.89 126.56,99.47 126.18,99.47 124.71,100.95 124.05,100.95 122.48,102.51 122.48,102.93 122.7,103.14 122.7,103.54
  BOTTOM w0.127: v1(134.09,58.07) 134.09,58.62 133.98,58.73 133.75,58.73 133.56,58.53 133.56,57.23 133.79,57 133.99,57 134.29,56.7 134.29,56.48 134.47,56.3 JDIM2.200 ; v1(122.11,105.16) U35.AR32
M_B_DQS6: length 59
  IN3 w0.076: 128.08,100.95 128.06,100.96 128.06,101 127.86,101.2 127.76,101.2 125.29,103.67 125.29,105.03 125.13,105.19 v3(124.91,105.19)
  IN3 w0.114: v1(139.6,60.38) 139.6,59.79 139.72,59.68 139.95,59.68 140.08,59.8 140.08,67.42 140.63,67.97 140.63,82.87 132.86,90.64 132.86,92.97 131.84,93.99 131.84,94.89 130.35,96.39 130.35,98.13 128.87,99.6 128.87,100.34 128.52,100.69 128.33,100.69 128.08,100.95
  BOTTOM w0.127: JDIM2.221 139.72,62.68 139.58,62.54 139.58,61.6 139.15,61.17 139.15,60 139.35,59.8 139.51,59.8 139.6,59.89 v1(139.6,60.38) ; U35.AR27 v3(124.91,105.19)
M_B_DQS7: length 61.1
  IN3 w0.076: 130.99,101.99 130.97,101.99 130.94,101.96 130.56,101.96 129.5,103.03 129.5,103.63 129.09,104.04 129.09,105.42 v1(129.47,105.8)
  IN3 w0.114: v1(145.51,58.21) 145.51,58.49 145.62,58.61 145.99,58.61 146.25,58.87 146.25,83.21 136.29,93.16 136.29,94.8 135.38,95.72 135.38,96.25 133.11,98.51 133.11,98.92 131.97,100.06 131.97,101.4 131.39,101.99 130.99,101.99
  BOTTOM w0.127: v1(145.51,58.21) 145.51,58.74 145.36,58.89 145.09,58.89 144.83,58.64 144.83,56.47 144.97,56.33 JDIM2.242 ; U35.AR21 v1(129.47,105.8)
M_B_DQS8: length 4.7
  TOP w0.127: v1(106.72,62.28) 106.73,62.28 106.48,62.52 106.09,62.92 106.09,63.89 105.82,64.15 v1(105.47,64.15) R10926.2
  BOTTOM w0.127: JDIM2.97 106.72,62.28 106.73,62.28 v1(106.72,62.28)
M_B_DQS#0: length 82.6
  IN3 w0.114: v1(103.11,109.8) 102.36,110.55 101.39,110.55 100.35,111.59 100.35,112.88 99.91,113.33 92.42,113.33 89.49,110.4 89.49,109.54 82.04,102.09 82.04,88.17 84.84,85.36 84.84,68.17 84.51,67.84 84.51,67.41 84.63,67.3 85.06,67.3 85.31,67.06 85.31,66.48 85.06,66.24 84.63,66.24 84.51,66.13 84.51,65.73 84.63,65.62 85.06,65.62 85.31,65.38 85.31,64.81 85.06,64.57 84.63,64.57 84.51,64.45 84.51,64.06 84.63,63.94 85.12,63.94 85.41,63.65 85.41,63.16 85.14,62.89 84.6,62.89 84.51,62.8 84.51,60.42 84.63,60.31 85.64,60.31 85.76,60.42 85.76,60.8 85.45,61.11 v1(85.25,61.11)
  BOTTOM w0.127: JDIM2.11 85.22,62.68 85.4,62.51 85.4,62.31 85.91,61.81 85.91,60.6 85.78,60.47 85.4,60.47 85.25,60.62 v1(85.25,61.11) ; U35.AH66 v1(103.11,109.8)
M_B_DQS#1: length 72.2
  IN3 w0.114: v1(89.99,57.38) 89.22,58.15 89.22,59.37 89.81,59.95 89.81,60.77 90.1,61.05 90.1,68.52 90.42,68.85 90.42,85.8 85.81,90.42 85.81,98.6 90.71,103.5 90.71,104.64 92.79,106.73 92.79,108.68 93.54,109.43 94.91,109.43 95.13,109.65 95.13,109.93 95.05,110.01 95.05,110.01 v1(94.92,110.14)
  BOTTOM w0.076: U35.AG69 101.53,110.06 101.31,110.22 101.15,110.29 100.75,110.29 100.59,110.36 100.43,110.36 100.29,110.29 100.02,110.29 99.59,110.73 99.07,110.73 98.88,110.92 96.09,110.92 95.99,111.02 95.13,111.02 94.92,110.8 v1(94.92,110.14)
  BOTTOM w0.127: v1(89.99,57.38) 89.99,57.95 90.1,58.06 90.38,58.06 90.6,57.83 90.6,56.49 90.47,56.36 JDIM2.32
M_B_DQS#2: length 63.6
  IN3 w0.076: 103.35,103.34 103.35,103.4 103.37,103.43 103.37,104.12 103.29,104.19 103.29,104.85 103.4,104.95 103.4,105.36 v3(102.97,105.8)
  IN3 w0.114: v1(95.35,61.62) 95.35,61.39 95.47,61.27 95.85,61.27 95.94,61.37 95.94,62.51 95.43,63.01 95.43,67.13 95.92,67.61 95.92,86.63 94.52,88.03 93.85,88.03 89.81,92.08 89.81,96.73 92.37,99.3 97.38,99.3 97.89,99.8 98.26,99.8 99.17,100.71 99.8,100.71 100.12,101.02 100.12,101.97 100.98,102.83 103.1,102.83 103.35,103.07 103.35,103.34
  BOTTOM w0.127: v1(95.35,61.62) 95.35,61.06 95.47,60.95 95.76,60.95 95.88,61.07 95.88,62.53 95.72,62.68 JDIM2.53 ; v3(102.97,105.8) U35.AR66
M_B_DQS#3: length 55.5
  IN3 w0.076: 105.15,101.01 105.17,101.03 105.17,101.18 106.23,102.24 106.23,103.38 106.08,103.53 106.08,104.83 v3(105.69,105.21)
  IN3 w0.114: v1(100.46,57.32) 99.82,57.96 99.82,59.62 100.37,60.18 100.65,60.18 101.05,60.58 101.05,75.23 102.4,76.58 102.4,90.88 103.96,92.44 103.96,98.51 105.15,99.7 105.15,101.01
  BOTTOM w0.127: U35.AR61 v3(105.69,105.21) ; JDIM2.74 100.97,56.33 101.13,56.48 101.13,57.67 100.83,57.97 100.55,57.97 100.46,57.87 v1(100.46,57.32)
M_B_DQS#4: length 58.3
  IN3 w0.076: 118.68,102.95 118.66,102.97 118.63,102.97 118.18,103.42 118.18,104.14 v3(118.56,104.53)
  IN3 w0.114: v1(129.72,60.41) 129.72,60.98 129.82,61.08 130.21,61.08 130.51,61.39 130.51,62.73 130.16,63.09 130.16,64.07 130.54,64.45 130.54,66.54 130.16,66.92 130.16,67.63 130.54,68.02 130.54,70.48 130.65,70.59 130.91,70.59 131.12,70.81 131.12,71.43 130.91,71.65 130.65,71.65 130.54,71.76 130.54,72.16 130.65,72.27 130.93,72.27 131.12,72.46 131.12,73.11 130.91,73.32 130.65,73.32 130.54,73.44 130.54,73.83 130.65,73.95 130.91,73.95 131.12,74.16 131.12,74.79 130.91,75 130.65,75 130.54,75.11 130.54,75.51 130.65,75.62 130.93,75.62 131.12,75.81 131.12,76.44 130.54,77.02 130.54,80.66 129.09,82.11 129.09,82.62 125.01,86.69 125.01,90.69 123.39,92.31 122.73,92.31 122.1,92.93 122.1,98.8 121.21,99.69 121.21,100.42 118.68,102.95
  BOTTOM w0.127: v1(129.72,60.41) 129.72,60.6 129.58,60.74 129.23,60.74 128.86,61.11 128.86,62.53 128.72,62.67 JDIM2.177 ; U35.AT38 v3(118.56,104.53)
M_B_DQS#5: length 60.3
  IN3 w0.076: 122.48,103.54 122.48,103.56 122.51,103.59 122.51,104.42 122.42,104.51 v3(122.11,104.51)
  IN3 w0.114: 122.48,103.54 122.48,103.23 122.27,103.02 122.27,102.42 123.96,100.73 124.62,100.73 126.09,99.26 126.47,99.26 126.93,98.8 126.93,92.81 128.78,90.95 128.78,88.26 132.75,84.29 133.49,84.29 135.44,82.34 135.44,69.8 134.97,69.32 134.97,59.14 134.49,58.66 133.77,58.66 133.69,58.74 133.69,58.93 v1(134.09,59.34)
  BOTTOM w0.127: U35.AT32 v3(122.11,104.51) ; v1(134.09,59.34) 134.09,59.05 134.01,58.97 133.65,58.97 133.31,58.63 133.31,57.13 133.69,56.76 133.89,56.76 134.05,56.6 134.05,56.41 133.97,56.33 JDIM2.198
M_B_DQS#6: length 59.1
  IN3 w0.076: 128.23,101.1 128.21,101.11 128.18,101.11 127.93,101.37 127.83,101.37 125.45,103.74 125.45,104.81 v3(125.84,105.2)
  IN3 w0.114: 128.23,101.1 128.42,100.91 128.61,100.91 129.09,100.43 129.09,99.69 130.56,98.22 130.56,96.48 132.06,94.98 132.06,94.08 133.08,93.06 133.08,90.73 140.85,82.96 140.85,67.89 140.29,67.33 140.29,59.71 140.04,59.46 139.69,59.46 139.6,59.37 v1(139.6,59.11)
  BOTTOM w0.127: U35.AR25 v3(125.84,105.2) ; JDIM2.219 139.22,62.66 139.34,62.54 139.34,61.7 138.91,61.27 138.91,59.9 139.6,59.2 v1(139.6,59.11)
M_B_DQS#7: length 61.2
  IN3 w0.076: v1(128.54,105.14) 128.64,105.24 128.8,105.24 128.92,105.11 128.92,103.97 129.33,103.56 129.33,102.96 130.49,101.8 130.94,101.8 130.97,101.77 130.99,101.77
  IN3 w0.114: v1(145.51,59.48) 145.14,59.11 145.14,58.93 145.25,58.82 145.9,58.82 146.03,58.96 146.03,83.12 136.07,93.07 136.07,94.71 135.16,95.63 135.16,96.16 132.9,98.42 132.9,98.83 131.76,99.97 131.76,101.31 131.3,101.77 130.99,101.77
  BOTTOM w0.127: U35.AR22 v1(128.54,105.14) ; JDIM2.240 144.47,56.34 144.59,56.46 144.59,58.74 144.99,59.13 145.4,59.13 145.51,59.24 v1(145.51,59.48)
M_B_DQS#8: length 6.2
  TOP w0.127: v1(106.72,60.99) 106.34,60.99 v1(105.75,61.59) 105.72,61.61 105.72,62.5 105.09,63.14 R10929.2
  BOTTOM w0.127: v1(106.72,60.99) 106.22,61.49 JDIM2.95
M_B_EVENT#: length 4.9
  TOP w0.127: R10928.2 113.33,56.28 R10921.1 115.36,56.91 v1(115.5,57.04)
  BOTTOM w0.203: v1(115.5,57.04) 115.97,56.57 JDIM2.134
M_B_ODT0_DIMM: length 57.3
  IN3 w0.076: v1(116.92,96.98) 117.21,97.27 117.9,97.27 118.41,96.76 118.41,92.87 120.53,90.75 121.29,90.75 121.62,90.42
  IN3 w0.191: 121.62,90.42 121.62,85.29 125.53,81.38 125.53,80.03 125.79,79.77 126.42,79.77 126.87,79.33 126.87,78.02 127.11,77.78 127.11,69.8 126.2,68.88 126.2,67.02 126.43,66.78 126.43,66.4 126.2,66.16 126.2,64.86 126.76,64.29 126.76,63.92 126.02,63.18 125.44,63.18 125.15,62.89 125.15,62.51 125.41,62.25 125.41,61.87 125.02,61.49 124.71,61.49 124.52,61.3 124.52,60.98 124.19,60.65 124.19,60.45 124.34,60.29 124.52,60.29 125.22,60.99 v1(125.54,60.99)
  BOTTOM w0.076: U35.BA42 117.39,101.59 117.53,101.45 117.53,101.44 117.54,101.44 117.66,101.19 117.66,100.12 117.46,99.91 117.46,99.43 117.34,99.31
  BOTTOM w0.102: 117.34,99.31 117.34,97.1 117.22,96.98 v1(116.92,96.98)
  BOTTOM w0.203: JDIM2.155 123.22,61.6 124.28,60.55 124.59,60.55 124.8,60.75 124.8,60.91 124.9,61.01 125.53,61.01 v1(125.54,60.99)
M_B_ODT1_DIMM: length 58.8
  IN3 w0.076: 122.09,90.33 121.51,90.91 120.6,90.91 118.64,92.87 118.64,96.98 117.37,98.25 v1(116.92,98.25)
  IN3 w0.191: v1(125.24,59.76) 125.52,59.48 125.87,59.48 126.02,59.63 126.02,61.49 125.88,61.64 125.88,62.37 127.23,63.73 127.23,64.79 127.11,64.92 126.82,64.92 126.67,65.07 126.67,65.96 126.8,66.1 127.08,66.1 127.23,66.25 127.23,66.92 127.08,67.08 126.8,67.08 126.67,67.22 126.67,67.95 126.78,68.07 126.98,68.07 127.16,68.25 127.16,68.49 126.98,68.68 126.98,69 127.58,69.6 127.58,77.98 127.34,78.22 127.34,78.61 127.58,78.85 127.58,79.49 126.82,80.24 126.27,80.24 126,80.51 126,80.92 126.17,81.08 126.17,81.41 122.09,85.48 122.09,90.33
  BOTTOM w0.076: v1(116.92,98.25) 116.74,98.25 116.34,98.65 116.34,99.03 117.13,99.81 117.13,100.08 117.3,100.25 117.3,100.73 117.13,100.9 117.13,100.99 117.12,100.99 117.12,101.19 117.16,101.27 117.18,101.29 117.18,101.52 117.12,101.63 117.12,101.86 117.16,101.94 117.16,102.2 117.12,102.23 117.12,102.54 117.16,102.58 117.16,102.81 U35.AW42
  BOTTOM w0.203: JDIM2.161 124.72,62.68 124.9,62.5 125.13,62.5 126.14,61.49 126.14,60.42 125.48,59.76 v1(125.24,59.76)
M_B_PARITY: length 63.4
  IN3 w0.076: 115.42,92.35 115.42,93.62 115.32,93.72 115.32,98.52 115.5,98.7 116.01,98.7 116.52,99.21 116.52,99.97 116.16,100.33 116.16,105.58 116.67,106.09 v3(116.67,106.56)
  IN3 w0.191: 115.42,92.35 115.42,91.86 116.57,90.71 116.78,90.71 117.16,90.33 117.16,83.44 118.94,81.66 118.94,81.17 119.11,81 119.6,81 119.76,80.85 119.76,80.58 119.6,80.43 119.08,80.43 118.94,80.29 118.94,80 119.08,79.86 119.98,79.86 120.22,80.1 120.49,80.1 120.91,79.68 120.91,79.46 120.73,79.29 119.07,79.29 118.94,79.16 118.94,78.87 119.09,78.71 120.92,78.71 121.07,78.56 121.07,78.3 120.92,78.14 119.42,78.14 119.27,77.99 119.27,77.72 119.42,77.57 120.8,77.57 120.95,77.42 120.95,77.15 120.8,77 119.58,77 119.43,76.85 119.43,76.58 119.58,76.43 120.8,76.43 120.95,76.28 120.95,76.01 120.8,75.86 120.48,75.86 120.33,75.7 120.33,75.41 120.46,75.29 120.9,75.29 121.05,75.13 121.05,74.78 120.59,74.33 v1(120.59,65.68)
  BOTTOM w0.203: v3(116.67,106.56) 116.26,106.15 U35.AP43 ; JDIM2.143 118.22,64.92 118.38,65.07 118.98,65.07 119.18,64.87 119.18,64.64 119.36,64.46 119.77,64.46 119.94,64.64 119.94,65.37 120.25,65.68 v1(120.59,65.68)
M_B_RAS#: length 59.8
  IN3 w0.076: 116.52,91.63 116.13,92.01 116.13,94.91 v1(115.73,95.32)
  IN3 w0.191: 116.52,91.63 116.74,91.41 117.1,91.41 118.1,90.41 118.1,83.83 122.01,79.92 122.01,74.42 121.53,73.93 121.53,64.3 121.02,63.79 121.02,59.89 120.35,59.22 120.35,56.66 120.5,56.51 120.77,56.51 120.94,56.69 120.94,58.85 121.49,59.39 v1(121.49,59.59)
  BOTTOM w0.076: 115,98.95 115,99.14 115.63,99.77 115.63,101.73 115.87,101.96 115.87,102.43 115.89,102.5 116,102.71 116.16,102.88 U35.AW44
  BOTTOM w0.102: v1(115.73,95.32) 114.74,96.31 114.74,97.81 115,98.07 115,98.95
  BOTTOM w0.203: JDIM2.152 122.47,56.65 123.04,57.22 123.04,58.04 v1(121.49,59.59)
M_B_WE#: length 60.8
  IN3 w0.076: v1(116.92,93.17) 117.31,92.77 117.31,92.57 117.53,92.35
  IN3 w0.191: v1(122.71,62.25) 122.71,63.43 124.09,64.81 124.09,68.16 123.6,68.65 123.6,68.9 124.09,69.39 124.09,70.37 124.24,70.53 124.85,70.53 125,70.67 125,70.88 124.85,71.02 124.24,71.02 124.09,71.17 124.09,71.37 124.24,71.52 124.85,71.52 125,71.66 125,71.87 124.85,72.01 124.24,72.01 124.09,72.17 124.09,72.36 124.24,72.51 124.85,72.51 125,72.65 125,72.86 124.85,73 124.24,73 124.09,73.16 124.09,73.35 124.24,73.5 124.85,73.5 125,73.64 125,73.85 124.85,73.99 124.24,73.99 124.09,74.15 124.09,74.34 124.24,74.49 124.85,74.49 125,74.63 125,74.84 124.85,74.98 124.24,74.98 124.09,75.14 124.09,75.33 124.24,75.48 124.86,75.48 125,75.62 125,75.82 124.86,75.96 124.14,75.96 124,76.1 124,76.29 124.14,76.43 124.87,76.43 125,76.56 125,76.77 124.85,76.93 123.58,76.93 123.42,77.08 123.42,77.27 123.58,77.42 123.99,77.42 124.14,77.57 124.14,77.77 123.99,77.92 123.58,77.92 123.42,78.07 123.42,80.5 119.51,84.42 119.51,90.37 117.53,92.35
  BOTTOM w0.076: 115.63,98.7 115.63,99.06 116.13,99.56 116.13,100.72 116.33,100.92 116.33,101.19 116.28,101.31 116.28,101.45 116.34,101.68 116.34,101.81 116.27,102.03 116.27,102.04 116.16,102.14 U35.AY44
  BOTTOM w0.102: 115.63,98.7 115.63,98.55 116.13,98.04 116.13,93.49 115.89,93.24 115.89,93.03 116.22,92.69 116.44,92.69 v1(116.92,93.17)
  BOTTOM w0.203: v1(122.71,62.25) 122.64,62.25 122.33,61.94 122.13,61.94 122.03,62.04 122.03,62.44 122.22,62.63 JDIM2.151
MAIND: length 267.2
  TOP w0.127: v1(34.85,54.25) 34.73,54.12 PQ6058.3 ; PQ3.3 45.78,33.55 v1(45.65,33.67)
  TOP w0.254: PQ3.3 PC103.2 47.51,35.11 PR148.2
  IN1 w0.089: v1(157.84,40.91) 157.87,40.91 157.89,40.89 157.89,40 155.63,37.74 150.44,37.74 148.03,35.33 113.89,35.33 112.79,34.22 106.83,34.22 105.8,35.25 81.26,35.25 80.32,34.31 79.3,34.31 75.81,30.81 75.81,28.49 67.6,20.29 67.32,20.29 66.13,19.11 59.06,19.11 58.27,19.9 55.27,19.9 45.79,29.37 45.79,33.54 v1(45.65,33.67) 45.65,34.31 44.46,35.5 44.46,39.44 36.63,47.26 36.63,51.25 34.85,53.02 v1(34.85,54.25) 34.85,59.71 36.76,61.61 36.76,62.09 41.3,66.63 44.35,66.63 46.3,68.59 46.3,70.78 47.7,72.17 47.7,74.13 48.42,74.85 48.42,75.8 44.84,79.39 44.84,91.73 57.58,104.48 67.94,104.48 69.65,106.19 76.51,106.19 80.32,102.38 80.32,93.71 79.05,92.44 v1(78.25,92.44)
  BOTTOM w0.127: v1(159.92,41.24) 159.87,41.29 PQ6065.2 158.22,41.29 v1(157.84,40.91)
  BOTTOM w0.203: PQ26.4 v1(78.25,92.44)
MAINON: length 102.9
  IN2 w0.114: v1(190.94,29.1) 190.66,29.1 190.23,28.67 189.11,28.67 186.7,26.26 186.04,26.26 185.76,26.54 182.2,26.54 181.9,26.23 181.9,25.83 181.49,25.42 179.05,25.42 178.34,24.71 177.27,24.71 176.76,25.22 176.51,25.22 175.34,26.39 172.04,26.39 171.74,26.08 171.74,25.17 171.07,24.51 v1(170.67,24.51)
  IN3 w0.114: v1(108.13,25.06) 109.66,23.54 161.68,23.54 162.69,24.56 169.04,24.56 169.35,24.25 170.41,24.25 v1(170.67,24.51)
  BOTTOM w0.127: v1(108.13,25.06) 108.28,25.21 U1006.10 ; U49.1 195.32,32.52 195.1,32.3 195.1,31.79 R791.2 195.75,31.13 v1(194.46,29.84) 193.72,29.1 v1(190.94,29.1) 189.91,29.1 R389.1 188.65,28.84 188.65,29.48 188.34,29.8 U45.30
MAINON_ON_G: length 242.7
  TOP w0.127: PQ5.2 68.92,95.09 v1(68.64,95.37)
  TOP w0.254: v1(46.21,30.25) 46.54,30.58 PQ3.2 46.54,31.67 44.95,33.26 PR150.1 PR151.2 44,35.11 43.56,34.67 PQ11.3 40.47,32.66 39.5,32.66 38.36,31.52 PQ10.2 37.32,31.52 36.12,32.71 36.12,39.39 36.7,39.97 v1(37.04,39.97) PQ4.2 v1(39.17,39.97)
  IN1 w0.089: v1(46.21,30.25) 46.21,29.22 55.35,20.09 58.35,20.09 59.14,19.3 66.06,19.3 67.38,20.62 67.58,20.62 75.6,28.64 75.6,30.98 79.18,34.56 80.19,34.56 81.07,35.44 106.26,35.44 107.29,34.41 112.71,34.41 113.81,35.52 147.73,35.52 152.5,40.28 v1(153.22,40.28)
  IN3 w0.114: v1(68.64,95.37) 66.81,95.37 65.51,96.67 54.72,96.67 53.45,95.4 50.73,95.4 45.78,90.44 45.78,79.34 50.73,74.38 50.73,70.7 44.18,64.15 42.91,64.15 39.79,61.04 39.79,53.93 39.17,53.31 v1(39.17,39.97)
  BOTTOM w0.127: v1(153.22,40.28) 157.05,36.44 158.45,36.44 158.81,36.09 158.81,35.45
MAINON_R: length 272.2
  TOP w0.127: v1(39.43,30.12) v1(41.33,30.12) 41.87,30.66 PR147.1 41.87,31.96 41.81,32.02 PQ11.2 ; v1(73.77,18.18) 72.37,16.78 67.85,16.78 67.24,17.39 v1(67.24,18.94) ; PR257.2 39.27,53.61 38.56,54.33 38.56,54.73 36.25,57.04 v1(36.25,58.19)
  TOP w0.203: PR6294.2 62.09,52.61 60,50.52 53.47,50.52 49.89,46.93 49.56,46.93 49.18,47.31 v1(48.57,47.31) 48.19,46.93 PR37.1
  IN1 w0.089: v1(191.45,28.59) 191.45,28.98 191.83,29.36 191.83,30.25 191.29,30.78 190.4,30.78 189.67,31.52 188.19,31.52 186.22,33.48 184.66,33.48 183.59,34.56 179.73,34.56 179.51,34.34 175.58,34.34 175.1,33.86 172.23,33.86 171.25,32.88 171.25,32.32 168.66,29.73 163.21,29.73 158.74,25.25 108.85,25.25 107.61,26.5 82.87,26.5 74.55,18.18 v1(73.77,18.18) 73.46,18.18 68.03,12.75 56.12,12.75 55.6,13.27 52.21,13.27 51.72,13.75 45.13,13.75 39.43,19.45 v1(39.43,30.12) ; v1(48.57,47.31) 48.24,47.64 39.07,47.64 38.44,48.28 38.44,52 37.1,53.33 37.1,56.26 36.25,57.11 v1(36.25,58.19)
  IN3 w0.114: v1(48.57,47.31) 48.57,44.09 47.68,43.2 47.68,40.53 43.24,36.09 40.82,36.09 39.43,34.69 v1(39.43,30.12)
  BOTTOM w0.127: PR6291.2 67.12,19.06 v1(67.24,18.94) ; U49.4 197.05,33.82 196.78,33.55 196.78,31.89 196.53,31.64 R791.1 196.53,30.76 196.28,30.51 195.91,30.51 193.99,28.59 v1(191.45,28.59)
MBCLK: length 157
  TOP w0.127: v1(156.9,142.26) 156.67,142.49 156.67,149.37 155.99,150.06 155.99,162.58 152.2,166.36 152.2,168.98 152.48,169.26 PC9.1 PR7.2 153.48,170.2 153.92,170.65 PD2.1 154.19,170.96 151.69,173.45 151.69,177.64 149.88,179.45 149.88,182.24 150.19,182.54 150.86,182.54 PR178.1
  IN3 w0.114: v1(177.76,44.52) 177.76,44.91 176.78,45.88 176.78,47.32 176.45,47.66 176.45,50.45 173.5,53.39 173.5,56.57 172.5,57.57 172.5,60.92 171.89,61.54 171.89,63.73 169.18,66.43 169.18,76.21 168.88,76.52 168.88,81.79 169.16,82.07 169.16,83.78 166.22,86.71 166.22,101.32 166.03,101.51 166.03,104 161.89,108.14 161.89,121.23 162.48,121.81 v1(162.5,121.81)
  BOTTOM w0.127: v1(162.5,121.81) 162.38,121.69 162.11,121.69 161.73,122.07 161.73,123.34 161.07,124 161.07,126.99 158.93,129.13 158.93,138.08 156.65,140.37 156.65,142.01 v1(156.9,142.26) ; R731.1 177.88,44.94 177.88,44.65 v1(177.76,44.52) 178.03,44.25 178.03,44.17 178.38,43.82 U45.110
MBDATA: length 157.9
  TOP w0.127: v1(156.14,142.26) 156.39,142.51 156.39,149.26 155.71,149.94 155.71,162.46 151.92,166.25 151.92,168.68 151.32,169.28 PC8.1 PR6.2 150.35,170.23 150.8,170.67 PD1.1 151.42,170.7 151.42,177.53 149.6,179.34 149.6,182.35 150.38,183.13 150.94,183.13 PR177.1
  IN3 w0.114: v1(162.52,121.18) 162.27,121.18 162.16,121.07 162.16,108.25 166.3,104.11 166.3,101.62 166.49,101.43 166.49,86.82 169.42,83.89 169.42,81.96 169.14,81.68 169.14,76.63 169.45,76.32 169.45,66.54 172.15,63.84 172.15,61.65 172.77,61.03 172.77,57.68 173.77,56.68 173.77,53.5 176.71,50.56 176.71,47.77 177.05,47.43 177.05,45.99 178.42,44.62 v1(178.42,44.52)
  BOTTOM w0.127: v1(162.52,121.18) 162.29,121.41 161.99,121.41 161.45,121.95 161.45,123.22 160.79,123.88 160.79,126.88 158.65,129.01 158.65,137.97 156.37,140.25 156.37,142.03 v1(156.14,142.26) ; R732.1 178.21,44.94 178.21,44.72 v1(178.42,44.52) 178.31,44.41 178.31,44.29 178.78,43.81 U45.111
