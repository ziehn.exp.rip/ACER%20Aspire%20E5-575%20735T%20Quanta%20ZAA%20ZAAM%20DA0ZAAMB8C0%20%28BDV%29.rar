# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBB_DBI0: length 17.4
  IN1 w0.114: v3(193.18,126.59) 193.63,127.05 194.15,127.05 194.37,126.83 203.68,126.83 204.13,127.27 207.74,127.27 v3(208.58,126.43)
  BOTTOM w0.152: v3(208.58,126.43) VRAM3003.D2 ; U3002.E11 v3(193.18,126.59)
FBB_DBI1: length 20.1
  TOP w0.152: VRAM3007.P13 v3(208.57,117.62)
  IN3 w0.114: v3(208.57,117.62) 208.17,117.22 208.17,116.57 207.59,116 205.19,116 204.64,116.55 199.03,116.55 197.81,117.77 195.36,117.77 193.27,119.86 193.27,120.5 v1(193.05,120.72)
  BOTTOM w0.152: v1(193.05,120.72) 193.01,120.72 U3002.E3
FBB_DBI2: length 24.6
  IN1 w0.114: v3(216.57,117.62) 216.16,117.22 216.16,116.64 215.77,116.25 205.64,116.25 202.75,119.15 197.1,119.15 196.74,119.51 195.97,119.51 v1(195.54,119.94)
  BOTTOM w0.152: v1(195.54,119.94) 195.54,119.95 U3002.A3 ; VRAM3003.P13 v3(216.57,117.62)
FBB_DBI3: length 25.9
  TOP w0.152: VRAM3007.D2 216.57,127.25 216.57,127.76 216.34,127.99 216.34,128.54 216.08,128.8 215.4,128.8 v1(214.89,129.31)
  BOTTOM w0.152: U3002.C9 194.73,125.74 195.22,125.74 195.51,126.03 202.51,126.03 205.79,129.31 v1(214.89,129.31)
FBB_DBI4: length 18.8
  TOP w0.152: v3(208.6,137.76) VRAM3002.D2
  IN1 w0.114: v3(208.6,137.76) 208.19,137.36 208.19,136.78 207.83,136.42 205.42,136.42 205.24,136.59 195.52,136.59 195.18,136.26 193.7,136.26 193.64,136.2 192.76,136.2 v1(192.34,136.62)
  BOTTOM w0.152: v1(192.34,136.62) 192.29,136.62 U3002.F23
FBB_DBI5: length 22.3
  IN1 w0.114: v3(208.6,147.36) 208.17,147.79 208.17,148.36 207.54,148.99 202.74,148.99 196.84,143.09 196.27,143.09 195.09,141.92 193.6,141.92 193.5,142.03 192.99,142.03 192.72,141.76 192.72,141.14 v1(192.34,140.76)
  BOTTOM w0.152: U3002.F27 192.3,140.76 v1(192.34,140.76) ; VRAM3006.P13 209,146.96 208.6,147.35 v3(208.6,147.36)
FBB_DBI6: length 29
  TOP w0.152: VRAM3002.P13 217.39,147.36 v1(217.39,149.24)
  BOTTOM w0.102: U3002.C30 194.72,143.23 195.21,143.23 195.37,143.39 196.27,143.39 196.4,143.26 196.78,143.26
  BOTTOM w0.152: 196.78,143.26 197.45,143.26 204.32,150.13 216.51,150.13 v1(217.39,149.24)
FBB_DBI7: length 25.6
  BOTTOM w0.152: U3002.A24 196.26,137.51 v1(202.14,137.51) 202.75,137.51 205.75,134.51 215.58,134.51 217.42,136.36 217.42,137.73 VRAM3006.D2
FBB_DEBUG0: length 1.5
  TOP w0.127: R4100.2 195.12,127.86 v1(194.72,128.26)
  BOTTOM w0.127: U3002.C12 194.72,128.23 v1(194.72,128.26)
FBB_DEBUG0_K: length 1.5
  TOP w0.127: TP4104.1 190.16,128.67 v1(190.62,129.13)
  BOTTOM w0.305: U3002.G14 190.62,129.13 v1(190.62,129.13)
FBB_DEBUG1: length 1.4
  TOP w0.127: v1(194.73,134.11) 194.73,133.61 R4102.2
  BOTTOM w0.127: U3002.C20 194.73,134.14 v1(194.73,134.11)
FBB_DEBUG1_K: length 1.4
  TOP w0.127: TP4105.1 190.49,134.26 v1(190.61,134.14)
  BOTTOM w0.152: v1(190.61,134.14) 190.63,134.14 U3002.G20
FBB_EDC0: length 15.5
  IN1 w0.114: v3(207.78,126.43) 207.26,126.96 204.26,126.96 203.82,126.51 194.24,126.51 194.11,126.64 v3(193.91,126.64)
  BOTTOM w0.152: v3(193.91,126.64) 193.91,126.57 U3002.D10 ; v3(207.78,126.43) VRAM3003.C2
FBB_EDC1: length 19.9
  TOP w0.152: v3(207.77,117.59) 207.77,117.62 VRAM3007.R13
  IN3 w0.114: v3(193.09,121.48) 193.3,121.28 193.93,121.28 194.32,120.9 194.32,119.32 195.5,118.13 197.95,118.13 199.18,116.9 204.79,116.9 205.34,116.35 207.11,116.35 207.34,116.58 207.34,117.17 v3(207.77,117.59)
  BOTTOM w0.152: U3002.D5 193.09,121.61 v3(193.09,121.48)
FBB_EDC2: length 26.5
  IN1 w0.114: v1(194.75,119.94) 195.5,119.19 196.61,119.19 196.97,118.83 202.62,118.83 205.51,115.93 216.25,115.93 216.96,116.64 216.96,117.22 v3(217.37,117.62)
  BOTTOM w0.152: U3002.C3 194.35,120.34 v1(194.75,119.94) ; VRAM3003.R13 v3(217.37,117.62)
FBB_EDC3: length 26.2
  TOP w0.152: v1(216.21,129.31) 216.62,129.31 217.35,128.57 217.35,127.27 VRAM3007.C2
  BOTTOM w0.152: v1(216.21,129.31) 215.75,128.85 205.94,128.85 202.69,125.6 196.42,125.6 196.28,125.74 195.71,125.74 195.31,125.34 U3002.B9
FBB_EDC4: length 16.3
  TOP w0.152: v3(207.8,137.76) VRAM3002.C2
  IN1 w0.114: v3(193.15,136.6) 195.08,136.6 195.42,136.94 206.11,136.94 206.94,137.76 v3(207.8,137.76)
  BOTTOM w0.152: U3002.E23 193.15,136.62 v3(193.15,136.6)
FBB_EDC5: length 19.7
  IN1 w0.114: v3(193.15,141.62) 193.28,141.62 193.34,141.56 195.18,141.56 196.4,142.78 196.97,142.78 202.87,148.67 207.13,148.67 207.36,148.44 207.36,147.8 v3(207.8,147.36)
  BOTTOM w0.152: v3(207.8,147.36) 207.8,147.35 VRAM3006.R13 ; v3(193.15,141.62) 193.15,141.61 U3002.E28
FBB_EDC6: length 28.3
  TOP w0.152: v3(217.4,146.56) 217.4,146.56 VRAM3002.R13
  BOTTOM w0.102: U3002.B30 195.25,142.97 195.48,142.97 195.7,143.18 196.16,143.18 196.35,142.99 196.78,142.99
  BOTTOM w0.152: v3(217.4,146.56) 217.39,146.57 217.39,148.6 216.29,149.7 204.5,149.7 197.8,142.99 196.78,142.99
FBB_EDC7: length 26.4
  BOTTOM w0.152: VRAM3006.C2 218.21,137.75 218.21,137.23 218.26,137.18 218.26,136.43 215.91,134.08 205.54,134.08 202.58,137.04 v1(200.8,137.04) U3002.A23
FBVDDQ_EN: length 81.1
  TOP w0.127: R4012.1 228.78,113.63 228.75,113.66 D4000.3 228.1,114.52 v1(228.98,115.4) 229.29,115.72 v1(230.56,115.72) ; PR122.2 218.27,178.73 v1(218.47,178.94)
  IN1 w0.089: v1(230.56,115.72) 230.71,115.87 230.71,120.11 229.92,120.9 229.92,133.55 228.38,135.09 228.38,155.74 226.24,157.88 226.24,167.02 228.78,169.56 228.78,176.6 226.45,178.94 v1(218.47,178.94)
FBVDDQ_SENSE: length 6.1
  BOTTOM w0.127: U3002.F1 191.83,118.38 193.48,116.73 194.11,116.73 194.87,115.97 R4115.1 194.51,114.85 v1(194.06,114.85)
FCCM_A: length 23.1
  IN1 w0.203: v1(144.05,180.51) 143.82,180.28 143.82,178.18 145.98,176.02 145.98,169.59 141.84,165.45 140.52,165.45 140.01,164.94 140.01,164.28 v1(139.93,164.21)
  BOTTOM w0.203: PR42.2 143.19,180.74 143.41,180.51 v1(144.05,180.51)
  BOTTOM w0.254: v1(139.93,164.21) 139.85,164.12 PR238.1
FCCM_B: length 37
  TOP w0.203: v1(144.74,173.32) 145.32,173.32 145.7,172.94 145.7,168.53 142.95,165.78 135.82,165.78 135.29,165.25 134.8,165.25 134.65,165.4 131.2,165.4 130.98,165.18 129.15,165.18 v1(128.83,165.5)
  BOTTOM w0.203: PR26.1 145.1,172.96 v1(144.74,173.32) ; PR229.1 120.19,164.48 120.95,165.25 v1(125.54,165.25) 125.58,165.25 126.29,165.96 128.38,165.96 v1(128.83,165.5)
  BOTTOM w0.254: v1(128.83,165.5) 128.44,165.11 PR234.1
FCCM_C: length 36.9
  TOP w0.203: PR46.2 136.99,181.89 v1(136.99,182.49)
  IN1 w0.203: v1(136.99,182.49) 136.99,183.18 138.56,184.75 147.5,184.75 149.97,182.29 150.93,182.29 151.44,181.78 151.44,173.02 151.19,172.77 151.19,167.41 149.74,165.96 149.74,165.17 v1(150.2,164.71)
  BOTTOM w0.254: v1(150.2,164.71) 150.83,164.08 PR240.1
G5335-AGND: length 14.2
  TOP w0.381: v1(215.04,175.89) 215.04,174.49 v1(215.61,173.92) 216.11,173.43 217.01,173.43 217.35,173.76 PR117.2 218.48,173.76 220.02,175.31 220.02,176.65 v1(220.07,176.7)
  BOTTOM w0.254: PU22.4 220.07,176.7 v1(220.07,176.7) 220.33,176.96 PR100.2 219.88,177.33 219.77,177.44 219.77,177.82 219.45,178.13 PR109.1
  BOTTOM w0.305: PC293.2 PR109.1
  BOTTOM w0.381: PC92.2 215.09,175.84 v1(215.04,175.89)
G5335-AGND-1: length 13.6
  TOP w0.508: v1(63.91,71.97) 63.98,72.03 63.98,72.12 64.04,72.18 PR82.2 64.84,74.46 66.1,73.2 v1(66.1,72.97)
  BOTTOM w0.254: v1(63.91,71.97) 64.04,72.1 PU15.4
  BOTTOM w0.305: v1(66.1,72.97) 66.1,72.84 66.79,72.15 PC89.2
  BOTTOM w0.381: v1(63.91,71.97) 63.91,70.99 63.45,70.52 PR92.2 63.2,70.33 v1(63.86,69.67) 64.09,69.67 64.55,70.12 PR87.2 PC272.2
G5335-BST:
  vias: v1(216.72,173.45)
G5335-BST-1:
  vias: v1(67.42,75.28)
G5335-EN: length 4.5
  TOP w0.254: v1(218.57,176.68) 218.27,176.98 PR122.1
  BOTTOM w0.127: PC293.1 217.35,178.14 v1(217.35,178.66)
  BOTTOM w0.254: PU22.2 219.07,176.31 218.7,176.68 v1(218.57,176.68) 218.14,177.11 PC293.1
G5335-EN-1: length 3.7
  TOP w0.127: v1(65.97,72.26) 65.54,72.26 v1(65.33,72.05)
  TOP w0.381: PR83.1 65.54,71.85 v1(65.33,72.05)
  BOTTOM w0.254: PR83.1 65.46,71.33 65.46,71.62 65.33,71.75 v1(65.33,72.05) 65.04,72.35 PU15.2
G5335-FB: length 6.2
  BOTTOM w0.127: v1(219.08,179.22) 219.13,179.27 PR108.2
  BOTTOM w0.254: PR100.1 219.96,178.47 PR108.2 ; PR100.1 220.33,178.02 220.53,177.82 220.66,177.82 220.91,177.57 220.91,176.96 220.58,176.63 220.58,176.49 220.57,176.48 PU22.5 ; PR100.1 220.55,178.33 PC274.1
G5335-FB-1: length 4.6
  TOP w0.127: v1(62.21,72.18) 62.21,71.33 PR86.2
  TOP w0.381: v1(63.2,72.03) PC235.1 PR86.2
  BOTTOM w0.254: 63.2,71.98 63.54,72.32 PU15.5
  BOTTOM w0.305: v1(63.2,72.03) PC235.1
G5335-LX: length 1.2
  TOP w0.762: v2(217.48,169.18) 217.57,169.09 PR120.1
  vias: v1(217.56,171.06)
G5335-LX-1: length 1.3
  TOP w0.762: v2(65.18,84.93) 65.3,84.81 PR98.1
  vias: v1(61.3,79.45)
G5335-PFM: length 3.7
  TOP w0.127: PR103.1 218.73,175.26 v1(218.57,175.1)
  TOP w0.254: PR103.1 218.73,176.03 v1(219.41,176.71)
  BOTTOM w0.254: PU22.3 219.57,176.57 219.44,176.71 v1(219.41,176.71) 219.13,176.98 PR109.2
G5335-PFM-1: length 3.5
  TOP w0.127: v1(64.67,72) 64.75,72.08 v1(64.75,72.66)
  TOP w0.381: v1(64.67,72) 64.55,71.88 PR93.1
  BOTTOM w0.254: PU15.3 64.54,72.28 64.7,72.13 64.7,72.03 64.67,72 ; 64.67,72 64.67,71.65 64.55,71.52 PR93.1 ; 64.67,72 v1(64.67,72)
G5335-PWRGD: length 2.5
  BOTTOM w0.254: PR110.1 216.85,176.78 v1(217.4,176.22) 217.84,175.78 PU22.1
G5335-PWRGD-1: length 2.3
  BOTTOM w0.254: PR94.1 66.53,71.55 v1(66.07,72) 65.84,72.23 65.84,72.26 65.54,72.56 PU15.1
G5335-SS: length 1.9
  BOTTOM w0.254: PC92.1 216.58,175.32 v1(216.82,175.08) 216.87,175.03 PU22.23
G5335-SS-1: length 2.6
  BOTTOM w0.127: v1(66.78,73.15) 67,72.93 PC89.1
  BOTTOM w0.254: PC89.1 67.49,73.32 66.97,73.85 PU15.23
G5335-TON: length 2.6
  BOTTOM w0.127: v1(221.9,176.6) 221.9,176.85 PR116.2
  BOTTOM w0.254: PR116.2 221.34,177.27 221.34,176.68 221.07,176.4 PU22.6
G5335-TON-1: length 2.1
  BOTTOM w0.254: 62.49,72.08 v1(62.52,72.11) 63.04,72.63 PU15.6
  BOTTOM w0.305: 62.49,72.08 62.24,71.83 PR97.2
G5335-VCC: length 3.7
  TOP w0.508: PR111.2 216.72,175.16 216.72,174.37 v1(216.77,174.31)
  BOTTOM w0.127: PC280.1 215.68,174.62 214.97,173.91 213.77,173.91 v1(213.42,173.55)
G5335-VCC-1: length 2.1
  TOP w0.254: PR88.2 67.88,73.59 v1(67.93,73.55)
  TOP w0.762: v1(67.32,74.47) 66.91,74.06 PR88.2
G5719LX2.5V:
  vias: v1(165.54,45.79)
G_MBCLK_R: length 8.4
  BOTTOM w0.127: R329.2 223.76,60.85 221.85,62.76 R333.1 C431.1 221.38,60.94 v1(221.17,60.73) 220.52,60.08 U19.4
G_MBDATA_R: length 5.2
  BOTTOM w0.127: R336.2 224.41,59.46 224.53,59.33 R334.1 C454.1 222.69,57.93 v1(222.63,57.87) 222.3,57.54 U19.6
GC6_FB_EN: length 104.9
  TOP w0.127: v1(226.75,110.26) 218.5,110.26 217.73,109.49 213.19,109.49 209.23,105.53 207.85,105.53 207.32,106.06 201.73,106.06 200.08,107.72 195.65,107.72 194.5,106.57 193.73,106.57 193.49,106.33 v1(193.49,105.18) 189.92,105.18 189.52,105.58 188.14,105.58 187.81,105.91 179.61,105.91 176.33,102.64 159.95,102.64 v1(159.82,102.51) ; D4000.1 226.42,113 227.39,112.03 v1(227.39,111.78) ; v1(136.81,106.47) 136.81,105.58 137.22,105.18 138.72,105.18 139.35,104.54 142.93,104.54 143.55,103.92 146.5,103.92 146.87,104.29 v1(147,104.29) 147.88,104.29 148.26,104.66 R199.2 148.71,105.25 151.99,105.25 R204.1 152.5,104.79 v1(153.25,104.04)
  IN1 w0.089: v1(153.25,104.04) 153.77,103.52 158.55,103.52 159.57,102.51 v1(159.82,102.51) ; v1(226.75,110.26) 226.75,111.14 v1(227.39,111.78)
  BOTTOM w0.127: R4328.2 193.74,104.92 v1(193.49,105.18) ; v1(136.81,106.47) 137.14,106.8 U35.AN7
GC6_FB_EN_R: length 29.9
  IN1 w0.089: v1(185.53,122.39) 185.14,122.01 185.14,120.97 184.33,120.16 184.33,117.24 183.83,116.73 183.83,115.08 183.65,114.91 183.65,113.39 183.18,112.92 182.4,112.92 181.59,112.11 181.59,110.05 v1(181.16,109.62)
  BOTTOM w0.127: v1(181.16,109.62) 181.39,109.39 181.39,108.22 183.42,106.19 187.89,106.19 188.4,105.68 189.29,105.68 189.68,105.29 Q4300.1 190.75,105.29 191.18,104.85 R4329.1 R4326.2 ; U3002.P6 v1(185.53,122.39)
GFX_SCL: length 19.9
  TOP w0.127: v1(183.86,121.54) 183.42,121.11 183.42,119.55 184.25,118.72 184.25,117.67 183.75,117.16 183.75,115.01 183.52,114.78 183.52,113.52 182.02,112.02 182.02,111.88 v1(181.16,111.02)
  BOTTOM w0.127: v1(183.86,121.54) 183.86,121.52 U3002.T4 ; Q4302.4 186.62,109.88 R4341.1 185.87,110.26 185.6,110 184.46,110 183.95,110.51 182.68,110.51 182.17,111.02 v1(181.16,111.02)
GFX_SDA: length 18.6
  TOP w0.127: v1(181.16,110.38) 182.29,110.38 182.44,110.53 182.44,110.75 182.29,110.9 181.94,110.9 181.79,111.05 181.79,111.26 181.94,111.41 182.17,111.41 182.3,111.53 182.3,111.91 183.8,113.41 183.8,114.66 184.03,114.89 184.03,117.05 184.53,117.55 184.53,118.83 183.7,119.67 183.7,120.56 v1(183.87,120.74)
  BOTTOM w0.127: v1(181.16,110.38) 181.22,110.44 181.75,110.44 R4342.1 183.98,108.21 Q4302.1 ; U3002.T3 183.48,120.34 v1(183.87,120.74)
GPIO10_VREF: length 169.8
  TOP w0.508: Q4509.2 228.01,119.41 v1(227.59,119.83) 227.16,120.26 v1(226.04,120.26) 226.04,124.58 v1(228.25,126.79)
  IN3 w0.508: v1(185.48,115.84) 185.48,116.25 186.98,117.75 191.91,117.75 195.64,114.02 195.64,113.3 197.03,111.91 197.03,110.64 201.1,106.57 205.42,106.57 209.35,110.51 217.1,110.51 218.37,111.78 221.8,111.78 225.35,115.34 225.35,119.86 225.76,120.26 v1(226.04,120.26) ; v1(223.96,142.13) 224.34,142.13 225.06,142.85 225.06,149.86 221.48,153.44 214.05,153.44 211.89,155.59 210.75,155.59 209.99,156.36 v1(209.33,156.36)
  BOTTOM w0.305: U3002.L1 187.63,117.84 185.63,115.84 v1(185.48,115.84) 185.22,115.59 R4323.1 R4325.1
  BOTTOM w0.508: v1(223.96,142.13) 225.35,142.13 Q4510.2 227.13,135.71 229.39,133.45 229.39,127.6 228.58,126.79 v1(228.25,126.79) ; v1(209.33,156.36) 209.33,157.4 208.59,158.13 Q4500.2 207.7,160.85 206.29,162.26 206.29,163.48 205.45,164.32 205.45,169.56 204.42,170.59 202.99,170.59 201.86,171.72 198.05,171.72 196.91,170.58 192.72,170.58 192.08,169.95 187.13,169.95 185.63,168.45 183.93,168.45 182.81,169.56 182.81,171.04 180.35,173.5 180.35,174.75 179.94,175.15 179.13,175.15
GPIO12_ACIN: length 35.2
  TOP w0.127: v1(171.38,117.37) 170.89,116.87 Q4301.4 168.99,116.87 R4346.2 168.98,116.5 R4319.1
  IN1 w0.089: v1(171.38,117.37) 173.67,115.08 173.67,109.14 174.17,108.63 181.57,108.63 182.43,109.49 182.43,111.78 182.94,112.29 183.47,112.29 184.68,113.5 184.68,114.41 185.08,114.81 185.08,117.68 v1(185.12,117.72)
  BOTTOM w0.127: U3002.N3 185.53,119.89 185.53,118.59 185.12,118.18 v1(185.12,117.72)
GPU_ALERT: length 6
  BOTTOM w0.127: R4317.2 184.21,116.63 184.52,116.95 185.56,116.95 186.44,117.83 186.44,118.96 186.83,119.35 U3002.M2
GPU_BUFRST: length 8.6
  BOTTOM w0.127: U3002.L2 187.63,119.53 188.02,119.15 188.02,117.75 186.75,116.48 186.75,113.56 186.37,113.19 R4343.1 186.23,113.19 185.79,112.74 185.23,112.74 v1(185.18,112.68)
GPU_EVENT#_D: length 35
  TOP w0.127: R4318.1 184.93,115.22 184.67,115.48 v1(184.67,116.45)
  IN1 w0.089: v1(186.44,123.21) 185.96,122.73 185.96,121.38 184.67,120.1 v1(184.67,116.45) 184.67,115.55 183.84,114.72 183.84,113.3 183.26,112.71 182.47,112.71 181.79,112.03 v1(181.79,109.62)
  BOTTOM w0.127: v1(181.79,109.62) 181.65,109.48 181.65,108.32 183.53,106.45 187.64,106.45 190,108.81 191.83,108.81 192.22,108.42 R4336.1 192.54,107.59 193.05,107.08 193.05,106.83 192.81,106.59 Q4300.4
  BOTTOM w0.14: U3002.M7 186.83,123.59 v1(186.44,123.21)
GPU_OVT#: length 28.7
  TOP w0.127: v1(173.16,114.95) 173.16,115.36 172.94,115.57 Q4301.1
  IN1 w0.089: v1(173.16,114.95) 172.73,114.52 172.73,109.8 174.1,108.43 181.64,108.43 182.68,109.47 182.68,110.64 v1(183.06,111.02)
  BOTTOM w0.127: U3002.M1 186.83,117.85 184.71,115.74 184.71,113.43 184.47,113.19 R4316.2 183.7,112.68 183.7,111.65 v1(183.06,111.02)
GPU_PEX_RST_HOLD#: length 47.7
  IN3 w0.114: v1(183.06,113.81) 183.06,114.07 183.7,114.7 190.84,114.7 191.22,114.32 194.67,114.32 195.13,113.86 195.13,110.13 199.83,105.43 207.63,105.43 v1(208.26,106.06)
  BOTTOM w0.127: v1(208.26,106.06) 209.4,104.92 214.28,104.92 215.4,106.04 U4002.1
  BOTTOM w0.14: U3002.P1 185.13,118.59 184.59,118.05 184.59,117.8 182.68,115.89 182.68,114.22 183.06,113.84 v1(183.06,113.81) 183.19,113.68 R4322.1
GPU_PWR_GD: length 109.1
  TOP w0.127: D4000.2 226.88,114.32 227.13,114.07 227.13,112.92 v1(227.39,112.67)
  IN1 w0.089: v1(227.39,112.67) 226.04,112.67 219.69,106.32 216.74,106.32 213.43,103 207.57,103 206.87,102.31 205.74,102.31 205,103.05 195.32,103.05 194.41,102.13 187.14,102.13 186.64,101.63 180.53,101.63 178.85,99.96 178.85,95.62 178.56,95.32 178.56,91.22 177.06,89.73 177.06,86.86 175.88,85.68 175.88,78.81 175.16,78.1 175.16,76.42 176.65,74.94 176.65,69 182.36,63.29 182.36,61.81 182.68,61.49 186.95,61.49 v1(187.2,61.74)
  BOTTOM w0.127: PR252.2 v1(190.37,61.21) 189.82,61.21 189.29,61.74 v1(187.2,61.74)
GPU_THROTTING#: length 83.8
  TOP w0.127: PQ40.3 v1(152.56,176.14) ; R4346.1 166.93,118.13 165.28,118.13 v1(164.85,118.56) 164.83,118.59 159.62,118.59 155.91,122.3 155.91,126 160.36,130.45 160.71,130.45 161.35,131.08 161.35,131.97 160.74,132.58 160.74,146.29 162.81,148.36 163.28,148.36 165.97,151.05 165.97,155.04 163.63,157.37 163.63,161.36 v1(162.05,162.95)
  IN2 w0.114: v1(162.05,162.95) 161.73,163.27 161.73,169.95 160.2,171.47 158.3,171.47 157.92,171.09 155.23,171.09 152.56,173.76 v1(152.56,176.14)
GPX: length 1.6
  BOTTOM w0.127: U44.3 168.19,66.05 TP4359.1
GSPI0_MOSI: length 15
  BOTTOM w0.076: 143.69,103.84 143.68,103.85 143.62,103.85 142.82,104.65 138.63,104.65 138.49,104.79 138.49,104.95 138.26,105.18 137.57,105.18 U35.AR7
  BOTTOM w0.127: R619.2 150.37,104.1 146.86,104.1 146.6,103.84 143.69,103.84
GSPI1_MOSI: length 14.7
  TOP w0.127: v3(138.68,106.3) 138.92,106.06 139.76,106.06 140.16,105.66 143.4,105.66 143.56,105.49 145.92,105.49 v1(146.25,105.83) 147.06,106.64 147.82,106.64 148.52,107.33 149.23,107.33 149.61,107.72 150.69,107.72 R207.2
  BOTTOM w0.127: v3(138.68,106.3) 138.18,106.8 U35.AN5
H_CPU_SVIDART#: length 6.2
  BOTTOM w0.127: U35.B63 105.08,123.22 104.77,123.53 104.77,124.09 104.58,124.28 104.58,124.76 103.75,125.58 103.36,125.58 103.05,125.89 v1(103.05,127.48) R552.1
H_CPU_SVIDCLK: length 83.7
  TOP w0.127: PR35.1 133.03,174.7 v1(132.52,174.19) 132.47,174.14 PR341.2
  IN1 w0.089: v1(105.21,150.46) 106.89,152.14 106.89,154.73 108.11,155.95 108.11,156.94 109.13,157.96 109.13,159.57 110.34,160.78 110.34,162.4 111,163.06 111,164.15 113.09,166.24 113.09,168.17 114.23,169.31 114.23,170.33 116.52,172.61 116.52,173.96 117.2,174.64 119.9,174.64 119.99,174.56 119.99,174.16 120.14,174.01 120.43,174.01 120.59,174.16 120.59,174.52 120.74,174.67 121.03,174.67 121.18,174.52 121.18,174.16 121.34,174.01 121.63,174.01 121.78,174.16 121.78,174.52 121.93,174.67 122.22,174.67 122.38,174.52 122.38,174.16 122.53,174.01 122.82,174.01 122.97,174.16 122.97,174.52 123.13,174.67 123.42,174.67 123.57,174.52 123.57,174.04 123.72,173.88 124.05,173.88 124.2,174.04 124.2,175.38 124.35,175.53 124.64,175.53 124.8,175.38 124.8,174.75 124.95,174.59 125.24,174.59 125.39,174.75 125.39,175.38 125.55,175.53 125.84,175.53 125.99,175.38 125.99,174.85 126.19,174.64 126.68,174.64 127.21,174.11 131.6,174.11 131.68,174.19 v1(132.52,174.19)
  BOTTOM w0.114: 104.2,126.26 104.2,125.75 104.83,125.12 104.83,124.64 105.08,124.39 U35.A63
  BOTTOM w0.127: v1(105.21,150.46) 105.21,147.4 101.12,143.31 101.12,135.81 102.42,134.51 102.93,134.51 103.5,133.94 103.5,127.08 104.2,126.38 104.2,126.26
H_CPU_SVIDDAT: length 84
  TOP w0.127: PR40.2 132.63,175.7 v1(132.49,175.56) 132.09,175.15 PR340.2
  IN1 w0.089: v1(103.71,148.79) 103.71,151.06 105.72,153.07 105.72,155.21 106.36,155.85 106.36,156.99 107.5,158.13 107.5,159.63 108.87,161.01 108.87,162.58 109.84,163.55 109.84,164.64 111.92,166.72 111.92,168.65 113.06,169.79 113.06,170.81 115.35,173.1 115.35,174.85 116.8,176.3 122.61,176.3 124.01,177.69 132.26,177.69 132.64,177.31 132.64,175.71 v1(132.49,175.56)
  BOTTOM w0.076: 102.44,126.26 102.44,125.98 103.03,125.39 103.66,125.39 104.27,124.78 104.27,124.28 104.57,123.99 104.57,123.42 104.72,123.27 104.72,123.02 104.82,122.92 104.82,122.61 104.51,122.3 U35.D64
  BOTTOM w0.127: v1(103.71,148.79) 103.76,148.74 103.76,147.61 99.95,143.8 99.95,135.32 102.39,132.88 102.39,130.67 R138.2 102.44,129.65 102.44,126.26
H_PECI: length 144.2
  IN1 w0.089: v1(139.25,125.9) 139.77,126.42 151.79,126.42 157.21,121.01 163.42,114.8 163.42,111.94 168.75,106.6 168.75,101 168.17,100.42 168.17,95.82 169.57,94.41 169.88,94.1 169.88,89.74 167.77,87.63 167.77,84.46 169.27,82.97 169.27,77.11 169.79,76.59 169.79,75.01 170.41,74.39 170.41,73.77 v1(171.05,73.13)
  IN2 w0.114: v1(139.25,125.9) 139.25,126.13 138.14,127.24 127.72,127.24 126.29,128.67 123.88,128.67 123.31,128.1 118.61,128.1 116.97,126.46 116.97,125.19 115.75,123.97 111.36,123.97 v1(110.09,125.24)
  IN3 w0.114: v1(171.05,73.13) 171.05,71.9 170.64,71.5 170.64,68.54 173.27,65.92 173.27,65.1 174.21,64.16 174.21,62.84 176.26,60.79 176.26,56.47 177.73,55 180.52,55 181.95,53.57 182.07,53.57 v1(182.53,53.11)
  BOTTOM w0.076: U35.A54 110.03,123.94 109.71,124.27 109.71,124.86 v1(110.09,125.24)
  BOTTOM w0.127: v1(182.53,53.11) 182.53,52.49 183.19,51.83 183.19,49.75 182.23,48.79 R738.2
H_PROCHOT#: length 452.3
  TOP w0.127: PU5.10 153.81,182.11 152.58,183.33 152.58,184.17 v1(152.53,184.22) PR174.1 ; v1(132.23,173.23) 132.56,173.23 PR32.1 ; v1(101.28,127.27) 101.4,127.4 R465.1 101.17,127.9 R531.1 ; v1(87.18,128.04) 87.18,127.65 86.67,127.15 86.67,123.08 86.16,122.57 86.16,120.16 v1(87.69,118.64)
  IN1 w0.089: v1(65.46,109.62) 57.81,109.62 41.46,93.27 41.46,79.78 41.08,79.39 41.08,76.85 41.97,75.97 41.97,73.55 42.37,73.15 42.37,70.97 38.73,67.33 38.43,67.33 31.77,60.67 31.77,42.31 33.27,40.82 33.27,33.82 35.52,31.57 35.52,21.46 43.95,13.02 51.57,13.02 51.91,12.68 55.36,12.68 55.88,12.17 68.28,12.17 70.94,14.83 73.87,14.83 75.25,16.21 75.25,18.06 83.11,25.92 102.49,25.92 103.86,24.55 108.73,24.55 109.32,23.97 117.95,23.97 118.54,24.56 158.87,24.56 163.45,29.14 169.32,29.14 171.86,31.68 171.86,32.66 172.47,33.27 175.49,33.27 175.93,33.71 182.14,33.71 182.81,33.04 186.11,33.04 189.16,29.99 v1(191.32,29.99) ; v1(152.53,184.22) 152.08,184.68 152.08,185.69 149.56,188.21 143.09,188.21 141.92,187.04 139.2,187.04 135.1,182.94 135.1,181.67 136.13,180.63 136.13,176.35 133,173.23 v1(132.23,173.23)
  IN2 w0.114: v1(132.23,173.23) 130.46,173.23 127.56,170.33 127.56,169.93 125.3,167.66 124.67,167.66 124.02,168.31 121.11,168.31 120.46,167.67 117.16,167.67 110.93,161.44 110.93,158.62 110.57,158.25 110.57,156.99 109.78,156.2 108.36,156.2 106.65,154.49 106.65,153.52 104.78,151.65 104.78,150.94 103.84,149.99 103.84,149.67 103.52,149.36 103.52,149.2 103.14,148.82 103.14,148 102.55,147.41 102.55,146.2 95,138.65 95,137.87 87.18,130.05 v1(87.18,128.04) ; v1(101.28,127.27) 101.28,127.02 100.26,126 96.7,126 89.34,118.64 v1(87.69,118.64) 78.52,109.47 71.03,109.47 70.33,108.78 66.31,108.78 v1(65.46,109.62)
  BOTTOM w0.127: Q30.3 191.7,30.37 v1(191.32,29.99) ; v1(132.23,173.23) 132.36,173.23 PR200.2
H_PROCHOT#_R: length 7.8
  TOP w0.127: R531.2 100.39,127.4 v1(100.64,127.15)
  BOTTOM w0.076: 101.28,126.26 102.49,125.04 103.51,125.04 103.94,124.61 103.94,124.14 104.24,123.85 104.24,122.9 104.17,122.83 104.17,122.63 U35.C65
  BOTTOM w0.127: v1(100.64,127.15) 100.64,126.89 101.28,126.26
HDA_BCLK_R: length 5.5
  BOTTOM w0.076: U35.AY22 128.37,102.1 128.37,100.79 129.01,100.14 129.01,99.92
  BOTTOM w0.127: 129.01,99.92 129.01,99.41 129.72,98.7 R644.2
HDA_RST#_R: length 10.8
  BOTTOM w0.076: U35.AW22 128.65,102.84 128.94,102.56 128.94,102.17 128.87,102.11 128.87,101.99 129.09,101.77 129.09,100.77 131.55,98.31 131.55,97.94
  BOTTOM w0.127: 131.55,97.94 131.55,94.44 R660.2
HDA_SDO_R: length 10.4
  BOTTOM w0.076: U35.BB22 128.65,100.74 129.24,100.15 129.24,99.69 130.16,98.78 130.16,97.94
  BOTTOM w0.127: R737.2 129.72,92.22 130.16,92.65 130.16,93.31 129.72,93.75 R645.2 130.16,94.19 130.16,97.94
HDA_SYNC_R: length 7.2
  BOTTOM w0.076: 130.87,97.94 130.87,98.57 129.6,99.84 129.6,100.03 128.92,100.7 128.92,101.47 U35.BA22
  BOTTOM w0.127: C742.2 131.3,96.22 131.3,97.13 R667.2 130.87,97.94
HDMI_5V: length 25.4
  TOP w0.254: D31.2 v1(18.67,41.25) ; D30.2 v1(23.55,41.29)
  IN1 w0.254: v1(17.07,56.03) 19.18,56.03 22.03,53.18 22.03,51.96 23.55,50.44 v1(23.55,41.29) 18.71,41.29 v1(18.67,41.25)
HDMI_DDCCLK_MB: length 23.1
  TOP w0.127: U18.19 18.23,45.23 18.37,45.09 18.37,44.6 v1(18.12,44.34) 17.96,44.19 R316.2
  IN3 w0.114: CN12.15 10.66,53.66 10.66,55 11.17,55.51 13.28,55.51 15.54,53.25 15.54,44.86 16.82,43.58 18.22,43.58 18.4,43.76 18.4,44.06 v1(18.12,44.34)
HDMI_DDCCLK_SW: length 172.3
  TOP w0.127: R322.1 17.58,52.42 v1(17.66,52.34) 17.86,52.15 17.86,51.58 17.73,51.45 U18.7
  IN3 w0.114: v1(17.66,52.34) 17.84,52.17 17.84,51.58 18.46,50.96 20.14,50.96 24.82,55.65 24.82,59.27 30.4,64.84 31.11,64.84 38.78,72.51 38.78,75.05 37.89,75.94 37.89,77.6 38.41,78.12 38.41,81.59 39.3,82.48 39.3,90.38 53.96,105.04 53.96,105.66 60.23,111.93 69.55,111.93 69.93,111.93 83.24,125.24 95.29,125.24 95.88,125.83 101.45,125.83 102.16,126.54 107.85,126.54 109.02,125.37 109.02,124.63 109.94,123.72 110.84,123.72 112.4,122.16 112.4,119.62 112.99,119.03 121.75,119.03 123.29,117.49 124.68,117.49 126.72,115.46 130.74,115.46 131.12,115.84 131.12,116.22 131.77,116.87 132.35,116.87 132.95,117.47 133.64,117.47 v3(133.83,117.28)
  BOTTOM w0.127: v3(133.83,117.28) 133.53,117.58 U35.L13
HDMI_DDCDATA_MB: length 22.5
  TOP w0.127: R317.2 18.98,44.19 v1(18.83,44.34) 18.62,44.55 18.62,45.13 18.73,45.24 U18.20
  IN3 w0.114: v1(18.83,44.34) 18.64,44.15 18.64,43.66 18.32,43.34 16.72,43.34 15.3,44.76 15.3,53.15 13.18,55.26 11.27,55.26 10.9,54.9 10.9,54.15 CN12.16
HDMI_DDCDATA_SW: length 172.7
  TOP w0.127: U18.6 18.23,51.46 18.11,51.58 18.11,52.06 v1(18.4,52.34) 18.47,52.42 R319.1
  IN3 w0.114: v1(18.4,52.34) 18.08,52.03 18.08,51.68 18.56,51.2 20.04,51.2 24.58,55.75 24.58,59.37 30.3,65.08 31.01,65.08 38.54,72.61 38.54,74.95 37.65,75.84 37.65,77.7 38.17,78.22 38.17,81.69 39.06,82.58 39.06,90.48 53.71,105.14 53.71,105.76 60.13,112.17 69.65,112.17 69.83,112.17 83.14,125.48 95.19,125.48 95.78,126.07 101.35,126.07 102.06,126.78 107.95,126.78 109.26,125.47 109.26,124.73 110.04,123.96 110.94,123.96 112.64,122.26 112.64,119.72 113.09,119.27 121.85,119.27 123.39,117.74 124.78,117.74 126.82,115.7 130.64,115.7 130.88,115.94 130.88,116.32 131.67,117.11 132.25,117.11 132.85,117.71 134.02,117.71 v3(134.45,117.28)
  BOTTOM w0.127: U35.L12 134.18,117.55 v3(134.45,117.28)
HDMI_EQ0: length 3.4
  TOP w0.127: U18.8 17.23,51.12 v1(16.57,51.79) R11274.1 R11277.1
HDMI_EQ1: length 3.3
  TOP w0.127: R11275.1 R11276.1 20.5,52.27 v1(20.66,52.12) 20.23,51.69 U18.2
HDMI_MB_HPD: length 17.5
  TOP w0.127: U18.21 v1(19.23,44.91) ; R720.1 16.07,57.81 v1(16.06,57.8) 16.07,57.8 R721.1
  IN1 w0.089: v1(16.06,57.8) 16.06,56.03 15.04,55.01 15.04,52.34 16.57,50.82 16.57,47.04 18.7,44.91 v1(19.23,44.91)
HDMI_MB_HPD_R: length 14.7
  TOP w0.127: Q41.3 25.71,55.26 24.95,54.5 R11064.2 25.73,53.48 R718.1 26.09,52.85 v1(26.02,52.78) ; U18.5 v1(18.73,51.71)
  IN2 w0.114: v1(18.73,51.71) 24.95,51.71 v1(26.02,52.78)
HP-L2: length 16.7
  TOP w0.381: v1(204.26,37.37) 204.5,37.12 204.5,35.05 203.39,33.94 v1(203.39,30.36)
  BOTTOM w0.203: v1(204.26,37.37) 204.18,37.44 U23.32
  BOTTOM w0.381: v1(203.39,30.36) R421.1 204.27,29.86 204.5,29.64 204.5,28.98 ; 204.5,28.98 C552.2 ; 204.5,28.98 204.5,28.95 203.54,27.99 v1(203.54,27.96) 203.54,26.33 202.99,25.79 R423.1 R422.2
HP-L3: length 16.9
  IN3 w0.381: v1(209.94,11.65) 209.54,11.65 208.08,13.1 208.08,16.3 204.27,20.11 204.27,22 v1(203.51,22.76)
  BOTTOM w0.305: CN2020.23 v1(209.94,11.65)
  BOTTOM w0.381: R422.1 C553.1 v1(203.51,22.76)
HP-R2: length 16.1
  BOTTOM w0.203: 203.78,37.09 203.78,37.63 203.88,37.72 203.88,38.41 203.78,38.5 U23.33
  BOTTOM w0.381: 203.78,37.09 203.78,35.88 203.69,35.79 203.69,34.74 v1(203.51,34.56) 202.81,33.87 202.81,32.32 201.6,31.1 R418.1 201.6,29.7 201.71,29.59 201.71,28.99 C549.2 201.71,28.96 201.71,27.99 202.11,27.58 202.11,26.05 201.85,25.79 R417.1 R420.2
HP-R3: length 18.8
  IN3 w0.381: v1(209.97,10.65) 209.01,10.65 207.07,12.59 207.07,16.05 202.1,21.01 v1(202.1,22.76)
  BOTTOM w0.305: CN2020.25 v1(209.97,10.65)
  BOTTOM w0.381: R420.1 C550.1 v1(202.1,22.76)
HP_DET_CN: length 6.2
  TOP w0.127: CN12.19 11.28,56.28 13.26,56.28 14.15,57.17 v1(14.41,57.17) R721.2
HP_JD#: length 33.2
  IN3 w0.381: v1(209.61,16.15) 209.35,16.4 209.35,16.65 206.3,19.7 206.3,21.61 205.67,22.24 205.67,24.02 206.33,24.68 206.33,29 207.7,30.37 207.7,33.29 208.03,33.62 208.03,34.77 209.61,36.34 209.61,38.63 210.5,39.52 210.5,42.17 v1(211.27,42.95)
  BOTTOM w0.305: CN2020.14 v1(209.61,16.15)
  BOTTOM w0.381: R383.1 211.52,43.2 v1(211.27,42.95)
HSYNC: length 26.7
  TOP w0.114: U13.19 21.02,68.95 20.78,69.18 20.66,69.18 19.84,70 v1(19.77,70) 20,70.23 R11267.1 ; U40.2 v1(13.39,87.55)
  BOTTOM w0.114: v1(13.39,87.55) 13.39,87.9 13.77,88.28 14.69,88.28 15.37,87.6 15.37,78.96 18.55,75.78 18.55,72.46 19.77,71.24 v1(19.77,70)
HWPG: length 180.5
  TOP w0.508: v1(184.65,32.42) 185.15,32.91 185.98,32.91 187.56,31.34 187.56,26.79 185.6,24.84 185.6,24.15 185.43,23.97 185.43,22.32 183.22,20.11 174.02,20.11 v1(170.36,23.77) v1(169.6,23.77)
  IN2 w0.508: v1(160.2,115.34) 160.58,115.34 161.73,114.19 161.73,103.91 162.87,102.76 162.87,93.62 164.01,92.48 164.01,90.44 163.51,89.94 163.51,81.68 162.11,80.28 162.11,77.74 162.62,77.24 162.62,74.44 v1(162.11,73.93)
  IN3 w0.508: v1(162.11,73.93) 162.11,73.43 161.68,72.99 161.68,65.78 160.2,64.31 160.2,56.62 160.87,55.95 160.87,51.21 160.1,50.44 160.1,43.59 160.67,43.02 160.67,37.4 v1(161.22,36.85)
  BOTTOM w0.203: U45.21 185.61,33.4 184.65,32.44 v1(184.65,32.42)
  BOTTOM w0.508: R102.2 138.74,133.38 138.74,131.96 139.69,131.01 146.26,131.01 146.85,130.42 148.47,130.42 149.31,129.59 151.49,129.59 155.38,125.69 155.38,122.34 157.36,120.37 158.05,120.37 161.11,117.31 161.11,115.96 160.48,115.34 v1(160.2,115.34) ; v1(161.22,36.85) 161.78,36.85 162.12,36.51 R374.1 162.63,35.58 163.64,34.56 D20.2 D18.2 D17.2 D11.2 D14.2 163.05,27.11 D4014.2 D4001.2 161.64,23.43 163.38,25.17 168.2,25.17 v1(169.6,23.77)
HWPG_1.5V: length 156.2
  TOP w0.508: PR53.1 v1(44.89,45.23) 45.62,45.97 45.62,46.27 45.36,46.53 PU2.1
  IN1 w0.508: v1(161.52,31.64) 161.52,31.08 158.74,28.3 116.73,28.3 115.79,27.36 109.52,27.36 108.29,28.59 81.33,28.59 67.26,14.52 57.23,14.52 56.58,15.18 55.25,15.18 52.18,18.24 50.79,18.24 49.21,19.83 49.21,20.14 42.47,26.88 v1(42.47,30.47)
  IN2 w0.508: v1(42.47,30.47) 42.47,37.1 44.89,39.52 v1(44.89,45.23)
  BOTTOM w0.508: v1(161.52,31.64) 161.52,32.49 D18.1
HWPG_1.05VGFX: length 2.1
  TOP w0.305: TP76.1 203.24,171.45 PR318.1
  TOP w0.508: PR317.1 203.27,172.41 PR318.1
HWPG_1.8VS5: length 49.6
  TOP w0.508: v1(162.54,65.55) 160.97,63.98 160.97,56.53 161.23,56.27 161.23,50.71 160.61,50.1 160.61,43.83 160.06,43.28 160.06,37.93 156.65,34.51 v1(156.64,34.51) v1(155.25,34.51)
  BOTTOM w0.381: PU6.1 161.58,64.65 161.85,64.93 PR73.1 162.54,65.1 v1(162.54,65.55)
  BOTTOM w0.508: v1(155.25,34.51) 155.25,32.91 155.14,32.8 155.14,29.47 156.27,28.34 160.33,28.34 160.97,28.98 D11.1
HWPG_1.35VGFX: length 110
  IN1 w0.089: v1(215.3,178.43) 212.68,181.05 212.68,185.69 209,189.38 207.42,189.38 204.6,192.2 203.28,192.2 201.86,190.77 201.86,186.84 198.68,183.66 195.89,183.66 190.18,177.95 188.5,177.95 188.12,177.57 182.3,177.57 178.14,173.4 165.45,173.4 162.62,170.56 162.62,166.39 163.63,165.37 163.63,156.32 164.39,155.55 164.39,150.55 160.08,146.24 160.08,143.91 v1(159.44,143.28)
  BOTTOM w0.127: v1(159.44,143.28) v1(160.03,142.69) 160.46,142.26 164.15,142.26 R4207.2
  BOTTOM w0.254: PR110.2 PR296.1 215.77,177.96 v1(215.3,178.43)
HWPG_1VS5: length 133.8
  IN1 w0.508: v1(82.4,31.52) 82.75,31.17 148.47,31.17 148.86,31.56 154.73,31.56 v1(155.77,30.51)
  IN3 w0.508: v1(82.4,31.52) 82.4,37.3 78.28,41.43 78.28,44.55 79.22,45.49 79.22,46.46 78.54,47.14 78.54,49.42 79.22,50.1 79.22,65.77 77.27,67.71 70.34,67.71 68.43,69.62 v1(67.47,69.62)
  BOTTOM w0.203: v1(67.47,69.62) 67.49,69.64 PR295.1
  BOTTOM w0.381: PR94.2 PR295.1
  BOTTOM w0.508: v1(155.77,30.51) 155.77,29.9 156.57,29.1 v1(159.89,29.1) 159.92,29.1 D17.1
HWPG_2.5V: length 43.7
  IN2 w0.508: v1(169.47,51.2) 168.2,51.2 167.82,50.82 165.03,50.82 163.12,48.91 161.09,48.91 160.33,48.15 160.33,46.2 v1(152.71,38.58)
  BOTTOM w0.508: v1(169.47,51.2) 169.47,50.57 PR314.1 PR306.1 ; D4001.1 157.37,23.43 v1(156.49,24.3) 154.5,26.3 154.5,35.19 153.73,35.96 153.73,37.56 v1(152.71,38.58)
HWPG_+VCCOPC: length 208.6
  TOP w0.508: v1(58.81,80.97) 58.6,81.17 PR293.1
  IN1 w0.508: v1(36.89,38.12) 36.89,36.47 41.46,31.9 41.46,25.17 43.36,23.26 43.36,18.69 44.51,17.55 49.21,17.55 52.56,14.19 56.17,14.19 56.82,13.53 67.67,13.53 81.74,27.6 107.88,27.6 109.26,26.23 158.34,26.23 v1(159.69,27.58) ; v1(58.81,80.97) 58.81,79.67 55.56,76.42 55.56,74.19 54.16,72.79 v1(49.71,72.79)
  IN3 w0.508: v1(36.89,38.12) 36.8,38.21 36.8,53.38 37.32,53.9 37.32,62.94 39.3,64.92 41.08,64.92 43.67,67.51 45.7,67.51 47.05,68.85 47.05,70.89 47.55,71.39 48.29,71.39 49.69,72.79 v1(49.71,72.79)
  BOTTOM w0.508: D14.1 v1(160.18,27.11) 160.16,27.11 v1(159.69,27.58) ; v1(58.81,80.97) 58.6,81.17 PR290.1
HWPG_VDDR: length 175
  TOP w0.127: PR107.1 42.56,51.15 44.18,51.15 44.79,51.76 45.09,51.76 45.87,52.54 PR267.2 46.15,52.54 46.51,52.9 46.51,53.89 v1(46.69,54.07)
  IN1 w0.508: v1(81.64,31.54) 81.64,31.82 81.97,32.15 82.63,32.15 83.01,31.78 148.21,31.78 148.95,32.51 157.77,32.51 158.68,33.42 160.13,33.42 v1(160.76,34.06)
  IN2 w0.508: v1(46.69,54.07) 45.65,54.07 45.07,54.66 44.76,54.66 44.01,55.4 43.99,55.4 43.63,55.77 43.63,57.52 43.73,57.62 43.73,58.6 43.36,58.97 43.36,59.71 44.25,60.6 44.25,62.95 47.91,66.61 48.58,66.61 50.55,68.59 52.25,68.59 53.14,69.48 v1(58.26,69.48)
  IN3 w0.508: v1(81.64,31.54) 81.64,37.18 77.65,41.17 77.65,49.55 78.36,50.26 78.36,65.63 76.99,67 63.38,67 60.9,69.48 v1(58.26,69.48)
  BOTTOM w0.127: v1(160.03,34.34) 160.31,34.06 v1(160.76,34.06)
  BOTTOM w0.508: D20.1 161.27,34.56 v1(160.76,34.06)
I2C0_SCL: length 152.6
  TOP w0.127: v1(139.38,17.42) 139.38,16.17 139.5,16.05 140.28,16.05 141.26,17.03 141.26,20.96 152.66,32.37 155.68,32.37 160.89,37.58 160.89,42.76 162.65,44.52 164.43,44.52 165.52,45.61 170.22,45.61 170.95,46.34 170.95,48.5 171.35,48.9 171.35,54.29 170.87,54.77 170.87,61.11 171.74,61.97 171.74,62.5 172.29,63.06 172.56,63.06 v1(172.78,63.28)
  IN1 w0.089: v3(138.4,114.28) 138.57,114.1 139.02,114.1 139.11,114.19 141.07,114.19 141.69,114.82 146.97,114.82 147.21,115.06 147.21,115.25 v1(147.12,115.34) 148.01,116.22 148.9,116.22 149.41,116.73 152.29,116.73 153.84,115.18 153.84,114.04 154.98,112.9 154.98,111.37 159.44,106.92 160.76,106.92 162.88,104.79 162.88,101.47 162.71,101.29 162.71,85.07 162.16,84.53 162.16,77.92 164.28,75.8 164.28,74.19 166.93,71.54 166.93,68.32 172.18,63.07 172.57,63.07 v1(172.78,63.28)
  BOTTOM w0.127: v1(147.12,115.34) 146.61,115.84 R166.2 ; Q43.4 139.5,15.66 139.73,15.88 139.73,16.06 R403.1 139.13,17.16 v1(139.38,17.42) ; U35.U6 138.09,114.59 v3(138.4,114.28)
I2C0_SDA: length 155.7
  TOP w0.127: v1(172.78,62.64) 172.64,62.78 172.41,62.78 172.01,62.39 172.01,61.85 171.15,60.99 171.15,54.88 171.63,54.4 171.63,48.79 171.23,48.38 171.23,46.22 170.34,45.33 165.64,45.33 164.55,44.24 162.77,44.24 161.17,42.64 161.17,37.46 155.8,32.09 152.77,32.09 141.53,20.85 141.53,16.91 140.39,15.77 139.38,15.77 v1(136.32,12.7)
  IN1 w0.089: v1(172.78,62.64) 172.59,62.83 172.08,62.83 166.69,68.22 166.69,71.44 164.04,74.09 164.04,75.7 161.92,77.82 161.92,84.63 162.46,85.17 162.46,101.39 162.64,101.57 162.64,104.69 160.66,106.67 159.34,106.67 154.74,111.27 154.74,112.8 153.6,113.94 153.6,115.08 152.19,116.49 149.51,116.49 149,115.98 148.11,115.98 147.73,115.6 147.73,115.36 v1(147.76,115.34) 147.45,115.03 147.45,114.96 147.07,114.57 141.79,114.57 141.17,113.95 139.21,113.95 139.12,113.86 138.26,113.86 137.84,114.28 v3(137.76,114.28)
  BOTTOM w0.127: R167.2 147.76,115.83 v1(147.76,115.34) ; U35.U7 137.43,114.61 v3(137.76,114.28) ; Q43.1 136.06,14.36 135.95,14.24 135.95,13.73 R405.1 v1(136.32,12.7)
I2C1_SCL: length 128.7
  TOP w0.127: Q2.3 118.16,174.13 R13.2 v1(118.92,172.72) ; v1(156.14,134.39) 155.89,134.13 155.89,133.62 149.31,127.05 149.31,124.25 148.19,123.13 148.19,120.77 148.9,120.06 148.9,118.52 148.48,118.1 148.24,118.1 v1(148.01,117.88)
  IN1 w0.089: v3(136.47,114.28) 136.86,114.68 140.58,114.68 141.75,115.84 143.19,115.84 145.45,118.1 147.78,118.1 v1(148.01,117.88) ; v1(118.92,172.72) 118.74,172.54 118.74,171.7 116.77,169.73 116.77,166.92 112.63,162.78 112.63,162.43 111.94,161.74 111.94,158.52 111.35,157.92 111.35,156.52 110.31,155.48 110.31,153.83 108.64,152.17 108.64,151.28 106.48,149.12 106.48,143.24 108.11,141.61 113.75,141.61 117.84,145.7 123.32,145.7 127.32,141.7 132.7,141.7 135.24,139.16 146.37,139.16 147.21,138.32 150.39,138.32 153.32,135.39 155.48,135.39 155.87,134.99 155.87,134.65 v1(156.14,134.39)
  BOTTOM w0.127: v1(148.01,117.88) 148.51,117.88 R169.1 ; U35.U9 136.47,114.33 v3(136.47,114.28)
I2C1_SCL_C: length 8.4
  TOP w0.127: R13.1 120.2,173.88 Q2.4 121.09,174.38 121.09,174.38 R12.1 122.22,174.38 122.61,174.77 v1(122.61,175.66) 122.61,176.17 122.18,176.6 120.78,176.6 120.19,177.19 R6.1
I2C1_SDA: length 131.4
  TOP w0.127: v1(148.01,118.51) 148.14,118.38 148.37,118.38 148.62,118.64 148.62,119.94 147.91,120.66 147.91,123.25 149.03,124.37 149.03,127.16 155.61,133.74 155.61,134.21 155.43,134.39 v1(155.39,134.39) ; Q2.6 120.2,176.16 119.82,176.55 R10.2 119.18,176.16 v1(119.18,173.99)
  IN1 w0.089: v3(137.1,115.35) 137.1,115.17 137.36,114.92 140.48,114.92 141.65,116.09 143.09,116.09 145.35,118.35 147.85,118.35 v1(148.01,118.51) ; v1(119.18,173.99) 118.5,173.31 118.5,171.8 116.53,169.83 116.53,167.02 112.39,162.88 112.39,162.53 111.7,161.84 111.7,158.62 111.11,158.02 111.11,156.62 110.06,155.58 110.06,153.93 108.4,152.27 108.4,151.38 106.24,149.22 106.24,143.14 108.01,141.37 113.85,141.37 117.94,145.46 123.22,145.46 127.22,141.46 132.6,141.46 135.14,138.92 146.27,138.92 147.11,138.08 150.28,138.08 153.22,135.15 155.38,135.15 155.63,134.89 155.63,134.63 v1(155.39,134.39)
  BOTTOM w0.127: R165.1 148.64,118.51 v1(148.01,118.51) ; U35.U8 136.78,115.03 v3(137.1,115.35)
I2C1_SDA_C: length 6.7
  TOP w0.127: R9.1 116.65,175.68 Q2.1 118.16,176.29 118.42,176.55 R10.1 118.79,176.94 118.17,177.57 118.17,177.79 118.32,177.95 v1(119.06,177.95) 119.69,178.58 R5.1
I2C_TP_SCL_R: length 22.4
  IN3 w0.114: v1(138.1,17.44) 138.1,17.31 135.99,15.2 124.07,15.2 123.63,15.64 123.63,16.93 123.63,16.93 123.63,17.16 v1(123.92,17.45)
  BOTTOM w0.127: Q43.3 137.23,15.66 137.47,15.89 137.47,16.41 R410.1 R403.2 138.1,16.91 v1(138.1,17.44) ; v1(123.92,17.45) 124,17.37 CN17.3
I2C_TP_SDA_R: length 21.7
  IN3 w0.114: v1(137.1,12.62) 134.78,14.94 123.96,14.94 123.36,15.53 123.36,17.04 123.37,17.04 123.37,17.16 v1(123.08,17.45)
  BOTTOM w0.127: v1(137.1,12.62) R405.2 R409.1 137.98,13.6 137.98,14.12 138.22,14.36 Q43.6 ; CN17.4 123,17.37 v1(123.08,17.45)
I2CA_SCL: length 7.2
  BOTTOM w0.127: U3002.R4 184.33,120.89 184.74,120.48 184.74,118.58 184.21,118.05 184.21,117.8 182.17,115.76 R4208.2
I2CA_SDA: length 8.8
  TOP w0.127: v1(183.88,122.37) 184.3,121.94 184.3,121.08 184.59,120.8 184.59,120.03 186.24,118.38 v1(186.24,116.17) R4209.2
  BOTTOM w0.127: U3002.R5 184.3,121.94 v1(183.88,122.37)
I2CB_SCL: length 11.7
  IN1 w0.089: v1(184.74,123.23) 184.31,122.8 184.31,120.46 183.95,120.11 183.95,117.37 182.43,115.84 v1(182.43,113.81)
  BOTTOM w0.127: R4337.1 182.17,113.56 v1(182.43,113.81) ; U3002.R7 v1(184.74,123.23)
I2CB_SDA: length 9.9
  TOP w0.127: R4338.1 v1(182.17,116.02) 182.17,116.61 183.61,118.04 183.61,118.34 182.78,119.17 182.78,122.05 v1(183.93,123.19)
  BOTTOM w0.127: U3002.R6 v1(183.93,123.19)
I2CC_SCL: length 5.8
  BOTTOM w0.127: U3002.R2 184.33,119.31 183.85,118.84 183.85,117.92 182.99,117.06 182.71,117.06 181.64,115.99 181.64,115.7 R4339.1
I2CC_SDA: length 9.2
  BOTTOM w0.127: R4340.1 181.11,113.19 180.7,113.59 180.7,115.66 182.48,117.44 182.99,117.44 183.6,118.05 183.6,118.96 183.88,119.24 183.88,119.88 184.33,120.33 U3002.R3
ICMNT: length 309.3
  TOP w0.127: v1(182.77,62.22) 181.71,63.28 179.45,63.28 v1(177.7,61.54) 176.51,60.34 176.51,48.29 177.18,47.62 177.18,45.61 176.87,45.3 176.87,40.18 176.1,39.42 176.1,37.61 175.08,36.58 172.48,36.58 171.52,35.63 171.52,31.42 168.2,28.1 v1(168.2,27.3)
  TOP w0.381: PC3.2 153.49,187.33 PR170.1 v1(154.41,187.95)
  IN1 w0.089: v1(186.87,174.39) 187.38,174.9 189.41,174.9 193.4,178.89 196.07,178.89 196.84,179.66 197.1,179.66 198.71,181.28 198.71,182.26 201.13,184.68 202.37,184.68 204.5,182.54 204.5,180.06 204.22,179.77 204.22,172.6 204.91,171.91 204.91,171.51 206.88,169.53 206.88,159.71 208.38,158.21 220.07,158.21 223.7,154.58 224.55,154.58 227.11,152.01 227.11,133.77 228.68,132.21 228.68,119.72 227.93,118.98 227.93,113.52 229.22,112.24 229.22,106.73 227.21,104.72 216.01,104.72 213.68,102.39 207.79,102.39 207.09,101.7 205.52,101.7 204.74,102.48 195.56,102.48 194.65,101.56 187.38,101.56 186.88,101.06 180.77,101.06 179.43,99.72 179.43,95.38 179.13,95.09 179.13,90.99 177.63,89.49 177.63,86.63 176.84,85.84 176.84,69.08 182.77,63.15 v1(182.77,62.22)
  IN3 w0.114: v1(154.41,187.95) 154.41,178.91 158.11,175.22 160.52,175.22 162.01,173.73 180.5,173.73 181.59,174.82 186.44,174.82 v1(186.87,174.39)
  BOTTOM w0.127: v1(168.2,27.3) 168.56,27.3 169.19,27.92 C516.2 169.19,29.07 169.47,29.36 169.95,29.36 170.39,29.8 U45.67
ILIM_HI: length 3.4
  TOP w0.127: U22.16 20.61,26.3 21.49,27.18 v1(21.49,27.81) 21.65,27.96 R377.1
ILIM_LO: length 2.8
  TOP w0.127: R376.2 21.9,26.94 v1(21.28,26.32) 20.76,25.8 U22.15
IMVP_PWRGD: length 77.5
  TOP w0.127: v1(132.39,172.56) 132.91,172.56 PR30.1
  IN3 w0.114: v1(132.39,172.56) 133.15,173.32 133.15,176.8 131.88,178.07 130.61,178.07 130.1,177.57 127.18,177.57 126.29,176.68 124.77,176.68 123.25,175.15 117.4,175.15 115.75,173.5 115.75,172.99 113.85,171.09 113.85,169.56 112.45,168.17 112.45,166.64 111.31,165.5 111.31,164.99 109.66,163.34 109.66,162.96 108.9,162.2 108.9,160.29 108.26,159.66 107.88,159.66 107.24,159.02 107.24,158.13 106.99,157.88 106.99,156.86 106.4,156.27 106.4,154.16 104.43,152.19 104.43,151.18 102.73,149.48 102.73,145.62 100.51,143.4 100.51,139.21 v1(97.47,136.16)
  BOTTOM w0.127: R478.1 94.55,132.36 95.05,132.86 95.05,133.37 95.43,133.75 U33.2 96.78,133.75 97.47,134.44 v1(97.47,136.16) ; PR197.2 132.58,172.56 v1(132.39,172.56)
IMVP_PWRGD_3V: length 319.1
  TOP w0.127: v1(182.8,34.16) R113.2 182.2,34.94 v1(182.1,35.05) 181.81,35.31 U8.1
  IN1 w0.089: v1(89.46,127.78) 89.46,127.78 83.69,122 82.29,122 69.4,109.11 57.86,109.11 42.47,93.73 42.47,73.6 42.76,73.32 42.76,70.81 38.89,66.94 38.59,66.94 32.17,60.51 32.17,42.47 33.66,40.98 33.66,33.98 36.02,31.62 36.02,21.71 44.18,13.56 51.64,13.56 52.13,13.08 55.52,13.08 56.04,12.56 68.11,12.56 70.79,15.23 73.72,15.23 74.86,16.37 74.86,18.22 82.95,26.31 107.53,26.31 109.48,24.36 117.79,24.36 118.49,25.06 158.82,25.06 163.29,29.53 168.73,29.53 171.46,32.26 171.46,32.81 172.31,33.67 175.18,33.67 175.66,34.14 182.79,34.14 v1(182.8,34.16)
  BOTTOM w0.127: v1(89.46,127.78) 89.46,128.54 89.34,128.67 89.34,129.43 94.48,129.43 95.68,130.63 R485.2 95.07,131.36 94.01,131.36 93.77,131.6 R478.2 93.27,132.47 93.27,132.86 93.51,133.1 U33.4
INT_AMIC-VREFO: length 7.1
  BOTTOM w0.127: R397.2 207.29,34.91 205.86,34.91 v1(205.85,34.89)
  BOTTOM w0.203: C534.1 207.2,37.87 206.81,37.87 206.18,38.5 U23.27
  BOTTOM w0.254: C534.1 207.19,36.86 207.19,35.84 R397.2
INT_HDMI_HPD: length 301.3
  TOP w0.127: v1(26.73,56.92) Q41.1 26.73,55.14 26.09,54.5 R718.2 R722.2 ; v1(155.86,69.39) 156.5,69.39 157.08,68.8 160.64,68.8 160.91,68.52 160.91,64.84 160.43,64.36 160.43,56.2 160.71,55.93 160.71,50.93 160.09,50.31 160.09,44.22 159.54,43.67 159.54,38.15 156.5,35.1 154.87,35.1 153.45,33.67 152.96,33.67 147.88,28.59 124.64,28.59 120.19,24.14 v1(119,24.14) 116.38,24.14 v1(113.72,21.48)
  IN1 w0.089: v1(26.73,56.92) 25.22,55.4 25.22,41.26 26.69,39.78 26.69,25.58 34.99,17.29 38.13,17.29 43.97,11.45 53.27,11.45 53.91,10.81 55.04,10.81 55.33,11.1 68.84,11.1 70.55,12.81 75.36,12.81 76.68,14.12 76.68,17.84 83.11,24.28 102.62,24.28 103.42,23.48 107.54,23.48 108.76,22.26 112.94,22.26 v1(113.72,21.48)
  IN3 w0.114: v1(155.86,69.39) 155.25,70 155.25,72.92 155.76,73.43 155.76,73.81 155.2,74.37 155.2,76.8 159.44,81.05 159.44,88.67 160.84,90.06 160.84,100.73 158.3,103.27 158.3,104.79 157.03,106.06 156.39,106.06 155.63,106.83 155.63,108.92 154.36,110.19 154.36,115.65 151.24,118.76 149.99,118.76 148.08,116.86 146.49,116.86 146.11,117.24 144.58,117.24 143.95,116.61 142.42,116.61 142.17,116.86 136.96,116.86 v3(136.47,117.35)
  BOTTOM w0.127: v3(136.47,117.35) 136.47,117.4 U35.L9
INT_HDMICLK+: length 131
  TOP w0.127: C389.1 25.97,51.2 26.35,51.2 v1(26.6,50.95)
  IN3 w0.114: v1(26.6,50.95) 26.7,51.05 27.34,51.05 27.72,51.43 27.72,58.27 37.16,67.71 37.52,67.71 41.2,71.39 41.2,74.88 41.56,75.24 41.56,76.63 41.23,76.96 41.23,78.66 41.43,78.86 41.43,90.04 53.27,101.87 55.05,101.87 63.33,110.15 70.57,110.15 83.88,123.46 97.08,123.46 97.84,122.71 106.99,122.71 107.93,121.77 107.93,120.49 v3(108.41,120.01)
  BOTTOM w0.127: v3(108.41,120.01) 108.73,119.69 U35.G56
INT_HDMICLK+_C: length 5.5
  TOP w0.127: CN12.10 11.86,50.81 v1(12.49,50.81) 12.69,50.81 12.97,50.53 14.44,50.53 R303.1 14.92,50.43 15.82,49.53 U18.10
INT_HDMICLK+_C_R: length 4.1
  TOP w0.127: C389.2 24.43,51.2 24.19,51.2 22.64,49.65 22.23,49.65 22.11,49.53 U18.31
INT_HDMICLK-: length 131
  TOP w0.127: C387.1 25.97,51.45 26.35,51.45 v1(26.6,51.71)
  IN3 w0.114: v3(108.41,120.62) 108.26,120.62 108.16,120.72 108.16,121.87 107.09,122.94 97.93,122.94 97.18,123.69 83.78,123.69 70.47,110.38 63.23,110.38 54.95,102.1 53.17,102.1 41.2,90.13 41.2,78.96 41,78.75 41,76.86 41.33,76.53 41.33,75.33 40.98,74.98 40.98,71.49 37.43,67.94 37.06,67.94 27.49,58.36 27.49,51.52 27.24,51.28 26.88,51.28 26.6,51.56 v1(26.6,51.71)
  BOTTOM w0.127: v3(108.41,120.62) 108.69,120.34 U35.F56
INT_HDMICLK-_C: length 5.6
  TOP w0.127: U18.9 16.15,50.03 14.97,51.21 R303.2 14.44,51.11 v1(13.82,51.11) 13.22,51.11 12.93,51.39 11.66,51.39 CN12.12
INT_HDMICLK-_C_R: length 4.1
  TOP w0.127: U18.32 22.11,50.03 22.23,49.91 22.53,49.91 24.08,51.45 24.43,51.45 C387.2
INT_HDMITX0N: length 136.4
  TOP w0.127: C398.1 25.97,45.36 26.27,45.36 v1(26.47,45.56)
  IN3 w0.114: v1(26.47,45.56) 26.81,45.56 31.71,50.46 31.71,60.69 37.2,66.19 38.54,66.19 43.06,70.71 43.06,78.96 44.28,80.18 44.28,90.92 53.57,100.21 55.67,100.21 62.78,107.32 71.46,107.32 75.53,111.4 78.46,111.4 88.45,121.39 96.68,121.39 97.36,120.72 99.95,120.72 100.39,120.29 105.47,120.29 106.23,119.53 110.47,119.53 110.7,119.76 110.7,120.19 v3(111.17,120.66)
  BOTTOM w0.127: v3(111.17,120.66) 110.85,120.34 U35.F53
INT_HDMITX0N_C: length 10.4
  TOP w0.127: CN12.9 10.94,49.06 10.94,46.07 11.23,45.78 v1(13.19,45.78) 14,45.78 14.1,45.88 R312.2 14.68,45.88 15.84,47.03 U18.15
INT_HDMITX0N_C_R: length 4.6
  TOP w0.127: C398.2 24.81,45.73 24.44,45.36 24.19,45.36 23.81,45.74 v1(23.81,46.45) 23.1,46.45 22.64,46.91 22.23,46.91 22.11,47.03 U18.26
INT_HDMITX0P: length 136.4
  TOP w0.127: v1(26.47,44.9) 26.27,45.1 25.97,45.1 C405.1
  IN3 w0.114: v1(111.15,119.94) 111.26,119.84 111.26,119.68 111.08,119.5 110.77,119.5 110.57,119.3 106.13,119.3 105.37,120.06 100.29,120.06 99.86,120.49 97.26,120.49 96.59,121.17 88.54,121.17 78.55,111.17 75.63,111.17 71.55,107.09 62.88,107.09 55.76,99.98 53.66,99.98 44.51,90.82 44.51,80.09 43.29,78.87 43.29,70.61 38.63,65.96 37.29,65.96 31.93,60.6 31.93,50.36 v1(26.47,44.9)
  BOTTOM w0.127: U35.G53 110.9,119.69 v1(111.15,119.94)
INT_HDMITX0P_C: length 10.4
  TOP w0.127: U18.16 16.16,46.53 14.73,45.1 R312.1 14.1,45.1 14,45.19 v1(11.96,45.19) 10.99,45.19 10.61,45.57 10.61,48.66 10.27,49 CN12.7
INT_HDMITX0P_C_R: length 4.6
  TOP w0.127: U18.25 22.11,46.53 22.23,46.65 22.53,46.65 22.91,46.28 v1(22.91,45.55) 23.63,45.55 24.08,45.1 24.43,45.1 C405.2
INT_HDMITX1N: length 132.1
  TOP w0.127: C406.1 25.97,47.39 26.22,47.39 v1(26.47,47.64)
  IN3 w0.114: v1(26.47,47.64) 26.73,47.39 27.04,47.39 30.94,51.3 30.94,60.9 37.1,67.05 38.47,67.05 42.4,70.98 42.4,79.26 42.88,79.74 42.88,90.67 53.45,101.24 55.17,101.24 62.67,108.73 70.22,108.73 76.95,115.46 79.11,115.46 86.35,122.7 96.77,122.7 98.09,121.38 100.14,121.38 100.67,121.91 101.68,121.91 101.91,121.69 106.04,121.69 106.68,121.05 107.3,121.05 v1(107.5,121.25)
  BOTTOM w0.127: U35.E58 107.76,120.99 v1(107.5,121.25)
INT_HDMITX1N_C: length 5.5
  TOP w0.127: CN12.6 11.86,48.19 12.63,48.19 v1(12.79,48.03) 13.26,47.56 14,47.56 14.1,47.65 R314.2 14.89,47.65 15.26,48.03 U18.13
INT_HDMITX1N_C_R: length 3.7
  TOP w0.127: U18.28 22.11,48.03 22.23,47.91 23.16,47.91 23.7,47.37 24.41,47.37 C406.2
INT_HDMITX1P: length 132.2
  TOP w0.127: C407.1 25.97,47.14 26.22,47.14 v1(26.47,46.88)
  IN3 w0.114: v1(26.47,46.88) 26.75,47.16 27.13,47.16 31.17,51.2 31.17,60.8 37.19,66.82 38.56,66.82 42.63,70.89 42.63,79.17 43.11,79.65 43.11,90.57 53.55,101.01 55.27,101.01 62.76,108.5 70.31,108.5 77.04,115.23 79.2,115.23 86.44,122.47 96.68,122.47 98,121.15 100.23,121.15 100.77,121.69 101.59,121.69 101.82,121.46 105.95,121.46 106.61,120.8 107.32,120.8 v3(107.5,120.62)
  BOTTOM w0.127: v3(107.5,120.62) 107.7,120.62 U35.F58
INT_HDMITX1P_C: length 5.5
  TOP w0.127: CN12.4 11.66,47.61 12.39,47.61 13.02,46.97 v1(13.82,46.97) 14,46.97 14.1,46.87 R314.1 14.93,46.87 15.59,47.53 U18.14
INT_HDMITX1P_C_R: length 3.7
  TOP w0.127: C407.2 24.46,47.11 23.6,47.11 23.06,47.65 22.23,47.65 22.11,47.53 U18.27
INT_HDMITX2N: length 138.2
  TOP w0.127: C408.1 25.97,49.42 26.35,49.42 v1(26.6,49.68)
  IN3 w0.114: v3(109.4,120.67) 109.4,120.44 109.53,120.31 109.71,120.31 109.86,120.47 109.86,121.51 107.97,123.4 101.6,123.4 100.64,124.35 83.62,124.35 70.29,111.02 61.42,111.02 40.21,89.81 40.21,77.77 39.5,77.05 39.5,76.47 40.34,75.63 40.34,72.24 37.34,69.23 36.71,69.23 33.97,66.49 33.97,65.93 33.2,65.17 32.64,65.17 31.27,63.8 31.27,63.01 29.77,61.51 29.29,61.51 25.94,58.16 25.94,53.9 25.58,53.54 25.58,49.55 25.84,49.3 26.4,49.3 26.6,49.5 v1(26.6,49.68)
  BOTTOM w0.127: v3(109.4,120.67) 109.61,120.67 109.81,120.86 U35.E55
INT_HDMITX2N_C: length 10.2
  TOP w0.127: v1(13.81,49.43) R315.2 14.61,49.36 15.28,49.36 15.6,49.03 U18.11
  IN3 w0.114: v1(13.81,49.43) 13.06,49.43 12.54,48.91 12.54,46.25 12.07,45.78 11.22,45.78 CN12.3
