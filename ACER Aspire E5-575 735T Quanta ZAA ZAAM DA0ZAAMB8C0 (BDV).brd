# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_TYPEC_CHG_HI: length 269.3
  TOP w0.127: R11279.2 v1(38.28,112.29)
  IN1 w0.089: v1(185.55,38.58) 185.55,37.79 185.15,37.38 185.15,36.7 184.19,35.74 179.07,35.74 178.86,35.53 175.97,35.53 174.87,34.43 171.99,34.43 170.43,32.86 170.43,32.48 168.24,30.3 162.97,30.3 158.5,25.83 109.09,25.83 107.85,27.07 81.77,27.07 67.83,13.13 56.28,13.13 55.63,13.77 52.41,13.77 49.04,17.15 44.34,17.15 40.7,20.79 40.7,30.87 40.12,31.45 40.12,32.47 36,36.6 36,40.59 34.49,42.1 34.49,50.98 33.15,52.32 33.15,61.23 38.67,66.75 38.97,66.75 42.95,70.73 42.95,73.77 42.77,73.95 42.77,79.57 43.62,80.41 v1(43.62,90.19)
  BOTTOM w0.127: U45.3 186.08,40.6 185.39,39.91 185.39,38.74 v1(185.55,38.58) ; v1(38.28,112.29) v1(38.87,111.7) 39.68,110.89 41.2,110.89 46.16,105.94 46.16,101.75 43.62,99.21 v1(43.62,90.19)
EC_TYPEC_EN: length 3.1
  BOTTOM w0.127: R11153.1 168.54,35 v1(169.71,35) U45.80
EC_TYPEC_EN_R: length 247.6
  TOP w0.203: U28.6 34.22,109.85 34.88,110.51 36.24,110.51 R11278.1 37.51,110.51 v1(38.66,110.51)
  IN2 w0.114: v1(45.14,102.13) 45.14,98.59 44.73,98.18 44.73,79.4 48.47,75.66 48.47,74.48 47.77,73.78 47.77,71.16 46.89,70.28 46.89,68.75 44.4,66.26 44.4,66.17 40.57,62.34 40.57,61.03 39.11,59.56 38.54,59.56 37.95,58.97 37.95,57.87 39.25,56.56 39.25,54.94 39.76,54.43 39.76,40.96 39.93,40.79 39.93,39.57 39.43,39.06 39.43,32.15 40.7,30.88 40.7,28.47 42.7,26.46 42.7,24.75 48.96,18.5 54.1,18.5 56.32,16.28 67.02,16.28 74.44,23.7 77.14,23.7 82.38,28.93 105.68,28.93 108.69,25.93 110.04,25.93 110.27,25.7 163.68,25.7 v1(165.28,27.3)
  BOTTOM w0.127: v1(38.66,110.51) 40.95,110.51 45.14,106.32 v1(45.14,104.6) v1(45.14,102.13) ; R11153.2 166.3,35.07 165.16,33.93 165.16,27.43 v1(165.28,27.3)
ECAGND:
  vias: v1(165.92,29.1)
EDP_AUX#_C: length 5.1
  BOTTOM w0.127: C2.2 124.13,167.93 R449.2 R450.1 123.88,170.19 123.88,170.96 CN5.22
EDP_AUX_C: length 5.1
  BOTTOM w0.127: CN5.23 122.72,171.42 123.06,171.42 123.63,170.85 123.63,170.44 R447.1 R448.2 123.12,168.92 C4.2
EDP_AUXN: length 71.6
  IN3 w0.114: v3(114.84,121.25) 114.84,121.14 115.01,120.97 115.17,120.97 118.43,124.23 119.16,124.23 120.61,125.67 120.61,130.17 119.34,131.44 119.34,132.77 118.27,133.83 118.27,134.28 114.99,137.56 108.9,137.56 107.24,139.21 107.24,147.85 114.51,155.11 114.51,156.26 113.61,157.15 113.61,161.38 117.71,165.48 119.21,165.48 120.08,166.34 121.45,166.34 121.62,166.51 121.62,166.64 121.24,167.02 v1(121.21,167.02)
  BOTTOM w0.127: v3(114.84,121.25) 115.12,121.25 115.29,121.07 U35.E45 ; v1(121.21,167.02) 121.29,166.95 121.29,166.49 121.57,166.21 123.43,166.21 123.91,166.69 123.91,166.91 C2.1
EDP_AUXP: length 71.6
  IN3 w0.114: v3(114.84,120.6) 114.99,120.75 115.27,120.75 118.52,124 119.26,124 120.83,125.57 120.83,130.27 119.56,131.53 119.56,132.86 118.5,133.93 118.5,134.38 115.09,137.79 108.99,137.79 107.47,139.31 107.47,147.75 114.74,155.02 114.74,156.35 113.84,157.25 113.84,161.28 117.8,165.25 119.31,165.25 120.17,166.11 121.54,166.11 121.85,166.42 v1(121.85,167.02)
  BOTTOM w0.127: U35.F45 115.09,120.34 v3(114.84,120.6) ; C4.1 123.37,167.4 123.53,167.4 123.65,167.28 123.65,166.8 123.32,166.47 121.67,166.47 121.54,166.59 121.54,166.72 v1(121.85,167.02)
EDP_HPD: length 112.7
  TOP w0.127: v1(161.73,157.88) 162.05,157.88 165.21,154.72 165.21,151.36 162.96,149.12 162.49,149.12 159.95,146.58 159.95,142.59 156.19,138.83 154.23,138.83 146.11,130.7 146.11,128.03 R563.2 144.85,126.77 144.1,126.77 142.42,125.09 142.42,123.34 v1(142.14,123.05) 141.92,122.83 141.28,122.83 141,122.55 141,121.71 141.57,121.15 141.57,120.57 141.15,120.16 139.06,120.16 138.87,119.97 138.41,119.97 138.18,119.74 138.18,118.59 137.47,117.88 136.33,117.88 135.87,117.41 v3(135.87,117.27) ; v1(122.24,173.62) C804.2 R457.1
  IN2 w0.114: v1(161.73,157.88) 158.3,161.31 158.3,165.18 156.7,166.78 156.7,168.12 153.47,171.34 150.42,171.34 149.15,172.61 146.74,172.61 145.47,171.34 136.84,171.34 134.93,173.25 133.79,173.25 133.38,173.65 129.95,173.65 129.75,173.86 126.96,173.86 126.04,174.77 124.9,174.77 123.75,173.62 v1(122.24,173.62)
  BOTTOM w0.127: U35.L10 135.48,117.68 135.87,117.29 v3(135.87,117.27)
EDP_HPD_R: length 2.2
  TOP w0.127: R457.2 120.87,171.85 v1(120.58,172.14)
  BOTTOM w0.127: CN5.25 v1(120.58,172.14)
EDP_RCOMP: length 7.6
  TOP w0.508: R154.1 118.16,120.62 v1(117.57,120.62)
  IN1 w0.508: v1(117.57,120.62) 116.67,120.62 115.44,121.85 112.16,121.85 v3(111.86,121.54)
  BOTTOM w0.305: U35.E52 111.64,121.32 v3(111.86,121.54)
EDP_TXN0: length 75.4
  IN3 w0.114: v1(116.26,131.72) 116.46,131.92 116.46,132.71 116.25,132.93 116.25,133.2 114.28,135.17 107.91,135.17 105.19,137.9 105.19,148.73 106.58,150.13 106.58,152.16 110.95,156.52 110.95,161.63 122.54,173.22 123.62,173.22 124.48,172.36 125.02,172.36 125.26,172.6 125.26,173.25 125.51,173.5 126.09,173.5 126.34,173.25 126.34,172.6 126.46,172.49 v1(127.31,172.49)
  BOTTOM w0.076: U35.C47 113.85,122.41 113.69,122.57 113.49,122.77 113.42,122.95 113.42,123.2 113.45,123.28 113.45,123.49 113.43,123.56 113.43,123.56 113.43,123.95 113.82,124.35 113.82,126.49 114.06,126.73 114.06,127.35 114.29,127.58 114.29,127.64 114.3,127.65
  BOTTOM w0.127: C12.1 126.82,172.82 127.16,172.49 v1(127.31,172.49) ; v1(116.26,131.72) 115.65,131.11 115.65,129.59 115.12,129.06 115.12,128.47 114.3,127.65
EDP_TXN0_C: length 2.1
  BOTTOM w0.127: CN5.16 125.56,173.52 C12.2
EDP_TXN1: length 74.8
  IN3 w0.114: v1(126.32,170.58) 126.32,169.77 125.73,169.18 124.25,169.18 124,169.43 124,170.11 123.89,170.23 123.5,170.23 123.38,170.11 123.38,168.81 122.99,168.42 121.21,168.42 120.35,167.56 119.08,167.56 113.12,161.6 113.12,157.18 112.5,156.57 112.5,155.91 108.21,151.62 108.21,149.53 106.74,148.06 106.74,138.96 108.79,136.9 114.83,136.9 117.77,133.96 117.77,133.6 118.67,132.7 118.67,130.7 119.31,130.07 119.31,128.67 116.73,126.09 116.08,126.09 115.9,125.9 115.83,125.9 v1(115.56,125.63)
  BOTTOM w0.076: v1(115.56,125.63) 115.23,125.3 115.23,124.62 115.44,124.42 115.44,123.64 115.38,123.47 115.38,123.33 115.44,123.1 115.44,122.97 115.36,122.79 115.36,122.36 115.09,122.09 U35.D46
  BOTTOM w0.127: v1(126.32,170.58) 126.32,170.94 C8.1
EDP_TXN1_C: length 2.1
  BOTTOM w0.127: C8.2 124.53,172.25 124.13,172.66 124.13,172.83 123.53,173.43
EDP_TXN2: length 78.4
  IN3 w0.114: v1(116.27,127.39) 117.01,127.39 117.91,128.29 117.91,132.52 117.13,133.31 117.13,133.59 114.63,136.09 108.46,136.09 106.08,138.48 106.08,148.33 107.55,149.8 107.55,151.88 111.84,156.17 111.84,156.85 112.47,157.47 112.47,161.89 122.05,171.47 122.82,171.47 123,171.29 126.47,171.29 126.68,171.09 128.45,171.09 129.95,172.59 v1(129.95,174.52)
  BOTTOM w0.076: U35.A45 115.04,123.66 115.04,123.44 114.97,123.36 114.79,123.36 114.73,123.42 114.73,123.95 114.83,124.05 114.91,124.05 114.99,124.13 114.99,124.25 114.92,124.33 114.8,124.33 114.73,124.4 114.73,125.89 115.12,126.28 115.12,126.75 115.29,126.92 115.32,126.92 115.34,126.9 115.35,126.92
  BOTTOM w0.127: 115.35,126.92 115.98,127.54 116.12,127.54 v1(116.27,127.39) ; v1(129.95,174.52) 129.95,174.79 130.08,174.92 130.08,175.81 C3225.1
EDP_TXN2_C: length 2.2
  BOTTOM w0.127: C3225.2 128.89,176.44 128.23,177.1 128.23,177.21 CN5.7
EDP_TXN3: length 81.2
  IN3 w0.114: v1(116.64,129.89) 116.44,129.69 116.06,129.69 115.83,129.92 115.83,132.99 114.08,134.74 107.65,134.74 104.7,137.69 104.7,148.91 106.1,150.31 106.1,152.27 110.52,156.69 110.52,158.1 109.89,158.74 109.89,159.89 110.17,160.17 110.17,161.46 115.35,166.64 115.35,168.2 121.21,174.06 124,174.06 124.43,174.49 127.79,174.49 128.33,175.03 131.12,175.03 131.64,175.55 v1(131.64,176.61)
  BOTTOM w0.076: 114.8,127.47 114.79,127.46 114.79,127.4 114.45,127.05 114.45,126.45 114.22,126.23 114.22,123.82 114.05,123.64 113.93,123.64 U35.A47
  BOTTOM w0.127: 114.8,127.47 115.63,128.29 115.63,128.87 v1(116.64,129.89) ; v1(131.64,176.61) 131.27,176.99 C3226.1
EDP_TXN3_C: length 2.4
  BOTTOM w0.127: CN5.4 129.34,178.22 129.34,178.1 129.5,177.95 129.98,177.95 130.21,177.71 C3226.2
EDP_TXP0: length 75.4
  IN3 w0.114: v1(126.8,171.98) 126.8,172.05 126.6,172.26 126.36,172.26 126.11,172.51 126.11,173.16 126,173.27 125.6,173.27 125.49,173.16 125.49,172.51 125.12,172.13 124.39,172.13 123.53,172.99 122.64,172.99 111.18,161.54 111.18,156.43 106.81,152.06 106.81,150.03 105.42,148.64 105.42,137.99 108.01,135.4 114.38,135.4 116.48,133.3 116.48,133.02 116.69,132.8 116.69,131.52 v1(116.26,131.08)
  BOTTOM w0.076: 114.48,127.47 114.47,127.47 114.41,127.47 114.23,127.29 114.23,126.66 113.99,126.42 113.99,124.28 113.59,123.89 113.59,123.59 113.62,123.53 113.62,123.24 113.58,123.17 113.58,122.98 113.63,122.87 113.76,122.74 113.94,122.74 114.2,122.47 114.33,122.47 114.43,122.57 U35.C46
  BOTTOM w0.127: C13.1 126.44,172.34 v1(126.8,171.98) ; v1(116.26,131.08) 116.03,131.08 115.91,130.96 115.91,129.48 115.37,128.95 115.37,128.37 114.48,127.47
EDP_TXP0_C: length 2
  BOTTOM w0.127: 124.24,174.13 124.84,173.54 125.18,173.54 125.64,173.08 C13.2
EDP_TXP1: length 74.7
  IN3 w0.114: v1(115.56,126.32) 115.56,126.24 115.67,126.13 115.8,126.13 115.99,126.32 116.63,126.32 119.08,128.77 119.08,129.97 118.45,130.61 118.45,132.61 117.54,133.51 117.54,133.87 114.74,136.67 108.7,136.67 106.51,138.86 106.51,148.15 107.98,149.63 107.98,151.71 112.27,156.01 112.27,156.66 112.89,157.28 112.89,161.69 118.99,167.79 120.26,167.79 121.12,168.65 122.9,168.65 123.15,168.9 123.15,170.21 123.4,170.45 123.98,170.45 124.23,170.21 124.23,169.53 124.35,169.41 125.63,169.41 126.09,169.87 126.09,170.2 125.71,170.58 v1(125.56,170.58)
  BOTTOM w0.076: U35.C45 114.92,122.41 114.84,122.5 114.84,122.62 114.92,122.7 115.1,122.7 115.17,122.77 115.28,123 115.28,123.08 115.24,123.2 115.21,123.31 115.21,123.5 115.27,123.67 115.27,124.35 115.07,124.55 115.07,125.83 v1(115.56,126.32)
  BOTTOM w0.127: C10.1 125.68,171.07 125.79,170.96 125.79,170.71 125.66,170.58 v1(125.56,170.58)
EDP_TXP1_C: length 2
  BOTTOM w0.127: CN5.20 123.78,172.48 123.95,172.48 124.37,172.06 C10.2
EDP_TXP2: length 78.4
  IN3 w0.114: v1(116.27,128.03) 116.68,127.62 116.92,127.62 117.68,128.38 117.68,132.43 116.9,133.22 116.9,133.5 114.53,135.86 108.37,135.86 105.85,138.38 105.85,148.43 107.32,149.9 107.32,151.97 111.61,156.27 111.61,156.94 112.24,157.57 112.24,161.98 121.96,171.7 122.92,171.7 123.09,171.52 126.57,171.52 126.77,171.32 128.36,171.32 129.72,172.68 129.72,174.11 v1(129.32,174.52)
  BOTTOM w0.076: U35.B45 114.86,123.2 114.72,123.2 114.56,123.36 114.56,125.96 114.95,126.35 114.95,126.82 115.16,127.02 115.16,127.08 115.17,127.1
  BOTTOM w0.127: C3224.1 129.47,175.36 129.67,175.36 129.83,175.2 129.83,175.03 v1(129.32,174.52) ; 115.17,127.1 115.87,127.8 116.04,127.8 v1(116.27,128.03)
EDP_TXP2_C: length 2.2
  BOTTOM w0.127: CN5.8 127.94,176.8 128.1,176.8 128.17,176.8 128.81,176.16 C3224.2
EDP_TXP3: length 81.2
  IN3 w0.114: v1(131.17,176.17) 131.37,175.96 131.37,175.6 131.03,175.25 128.23,175.25 127.7,174.72 124.34,174.72 123.91,174.29 121.11,174.29 115.12,168.29 115.12,166.74 109.94,161.56 109.94,160.26 109.66,159.98 109.66,158.64 110.29,158.01 110.29,156.78 105.87,152.36 105.87,150.41 104.48,149.01 104.48,137.59 107.56,134.51 113.98,134.51 115.6,132.89 115.6,129.82 115.96,129.46 116.44,129.46 v1(116.64,129.26)
  BOTTOM w0.076: 114.98,127.29 114.96,127.27 114.96,127.27 114.9,127.27 114.61,126.98 114.61,126.38 114.39,126.16 114.39,123.75 113.86,123.22 U35.B47
  BOTTOM w0.127: v1(116.64,129.26) 116.37,129.26 115.88,128.77 115.88,128.19 114.98,127.29 ; v1(131.17,176.17) 130.8,176.53 C3227.1
EDP_TXP3_C: length 2.4
  BOTTOM w0.127: C3227.2 130.08,177.48 129.87,177.69 129.39,177.69 129.14,177.95 128.91,177.95 CN5.5
EDP_VDD_EN: length 120
  TOP w0.127: v1(155.12,138.26) 154.68,138.26 152.08,135.66 152.08,134.89 147.36,130.18 147.36,127.39 145.48,125.51 v1(144.84,125.51) 144.62,125.51 v1(143.82,124.71)
  IN1 w0.089: v1(143.82,124.71) 143.82,124.1 141.53,121.81 141.03,121.81 139.81,120.59 139.81,119.46 138.27,117.93 135.59,117.93 135.33,117.67 132.97,117.67 132.77,117.47 132.77,115.84 133.06,115.55 v3(133.06,115.32)
  IN2 w0.114: v1(114,156.14) 113.66,156.48 113.66,161.82 116.96,165.11 125.82,165.11 127.35,166.64 133.41,166.64 134.84,165.22 135.37,165.22 136.1,164.48 137.09,164.48 137.34,164.23 138.11,164.23 138.95,165.08 144.76,165.08 146.75,163.09 150.16,163.09 152.22,165.15 154.56,165.15 155.22,164.49 156.38,164.49 156.93,163.94 156.93,144.01 157.56,143.38 157.56,140.71 155.12,138.27 v1(155.12,138.26)
  BOTTOM w0.127: v1(114,156.14) 113.55,156.14 113.34,156.36 R37.1 ; v3(133.06,115.32) 133.53,114.85 U35.U13
EDP_VDD_EN_R: length 3.4
  BOTTOM w0.127: U1.3 112.64,158.45 112.71,158.52 R38.2 113.33,158.13 113.34,158.13 R37.2 113.76,157.64 v1(114.08,157.32)
ENSWREG: length 4.7
  TOP w0.203: U15.34 39.3,68.55 39.58,68.27 39.58,65.59 R11258.1
EVDD10: length 1.9
  TOP w0.203: U15.20 34.09,72.06 33.92,71.89 C244.2
  vias: v1(31.63,71.19)
FAN1_DAC: length 238.7
  TOP w0.127: v1(181.06,32) 180.3,32 178.36,33.93 175.97,33.93 175.32,34.59 175.32,34.84 v1(175.11,35.05) v1(174.3,35.86)
  IN1 w0.089: v1(81.97,21.1) 81.97,22.41 83.27,23.71 102.51,23.71 103.22,23 107.34,23 108.56,21.78 112.59,21.78 113.48,20.89 118.12,20.89 122.83,16.17 124.87,16.17 129.75,21.05 159.03,21.05 163.91,25.93 169.99,25.93 171.98,27.92 174.09,27.92 178.43,32.26 180.8,32.26 v1(181.06,32)
  BOTTOM w0.127: v1(174.3,35.86) 173.56,35.86 173.21,35.5 172.57,35.5 172.47,35.4 U45.81 ; v1(81.97,21.1) 79.56,23.51 79.56,30.37 78.92,31.01 78.92,35.76 78.48,36.2 78.48,40.34 77.63,41.19 77.63,60.08 78.9,61.35 78.9,64.94 76.76,67.08 76.76,75.97 77.58,76.78 80.7,76.78 80.84,76.92 81.86,76.92 88.22,83.28 88.22,90.8 85.65,93.36 85.65,109.98 82.78,112.85 82.78,123.01 82.2,123.59 U12.4
FAN1_RPM: length 290.5
  IN2 w0.114: v1(180.17,30.04) 179.79,29.66 178.01,29.66 177.81,29.46 177.81,28.67 177.35,28.21 170.87,28.21 168.13,25.47 110.09,25.47 109.88,25.67 108.62,25.67 105.59,28.7 82.59,28.7 77.34,23.45 74.53,23.45 67.1,16.02 56.19,16.02 54.03,18.18 48.95,18.18 42.47,24.66 42.47,26.05 40.47,28.06 40.47,30.79 39.2,32.06 39.2,39.15 39.71,39.66 39.71,40.53 39.53,40.71 39.53,54.27 38.99,54.81 38.99,56.47 37.72,57.74 37.72,59.07 38.46,59.81 38.91,59.81 40.32,61.21 40.32,62.41 44.17,66.27 44.17,66.42 46.67,68.91 46.67,70.38 47.51,71.22 47.51,73.9 48.24,74.63 48.24,75.56 44.47,79.32 44.47,102.22 48.19,105.94 48.46,105.94 57.73,115.21 64.8,115.21 v1(68.15,118.56) 68.58,118.99 78.7,118.99 v1(79.51,118.18)
  BOTTOM w0.127: CN8.2 63.95,120.4 v1(64.95,119.4) 65.09,119.26 67.45,119.26 v1(68.15,118.56) ; U45.47 179.98,29.86 v1(180.17,30.04) ; v1(79.51,118.18) 78.42,119.27 C719.2 R609.2
FB_CAL_PD_VDDQ: length 2.2
  TOP w0.381: v1(188.27,139.49) 188.27,140.19 R4117.2 188.9,140.82 v1(188.9,140.86)
  BOTTOM w0.381: U3002.J27 188.91,140.86 v1(188.9,140.86)
FB_CAL_PU_GND: length 1.8
  TOP w0.127: R4118.2 190.48,140.09 v1(189.76,140.81)
  BOTTOM w0.305: v1(189.76,140.81) 190.13,140.44 U3002.H27
FB_CAL_TERM_GND: length 1.8
  TOP w0.508: R4119.2 190.04,139.73 v1(190.65,139.12)
  BOTTOM w0.381: U3002.H25 190.23,138.69 v1(190.65,139.12)
FB_DLLAVDD: length 30.2
  TOP w0.508: v1(206.44,155.46) 206.21,155.69 C4721.1 206.21,157.07 206.04,157.25 C4719.1 L4207.1
  IN3 w0.508: v1(188.94,139.93) 194.19,139.93 196.78,142.51 197.29,142.51 206.44,151.67 v1(206.44,155.46)
  BOTTOM w0.254: v1(188.94,139.93) 188.48,140.39 U3002.K27
FB_GND_SENSE: length 6.7
  BOTTOM w0.127: U3002.F2 192.21,119.16 192.21,118.51 193.6,117.11 194.49,117.11 195.38,116.22 195.38,115.47 195.64,115.22 R4116.1
FB_PLLAVDD: length 34.4
  TOP w0.305: C4112.2 189.42,132.7 v1(189.31,132.81)
  TOP w0.508: v1(166.93,140.87) C4116.1 165.78,140.87 165.66,140.99 L4100.1 L4206.1
  IN2 w0.508: v1(189.31,132.81) 189.31,133.6 188.14,134.77 188.14,137.56 186.49,139.21 183.08,139.21 v1(182.24,140.05) 182.24,139.91 181.51,139.19 177.88,139.19 177.04,140.02 175.47,140.02 174.62,140.87 v1(166.93,140.87)
  BOTTOM w0.305: v1(189.31,132.81) 189.31,132.58 189.59,132.3 189.97,132.3 U3002.H17
  BOTTOM w0.381: U3002.U27 v1(182.24,140.05)
FBA_CMD0: length 28.3
  TOP w0.152: VRAM3004.L12 v3(198.53,159.42)
  IN3 w0.114: v3(183.07,143.36) 183.49,143.78 183.49,145.15 183.9,145.56 188.78,145.56 191.32,148.1 192.03,148.1 197.96,154.03 198.65,154.03 199.07,154.45 199.07,157.22 198.95,157.34 198.95,159 v3(198.53,159.42)
  BOTTOM w0.152: VRAM3004.L12 v3(198.53,159.42) ; U3002.U30 183.04,143.36 v3(183.07,143.36)
FBA_CMD1: length 27.3
  TOP w0.152: VRAM3004.K10 196.93,160.22 v3(196.93,160.19)
  IN3 w0.114: v3(183.07,144.12) 182.94,144.26 182.94,145.31 183.65,146.02 188.47,146.02 191.06,148.61 191.89,148.61 197.33,154.05 197.33,159.79 v3(196.93,160.19)
  BOTTOM w0.152: VRAM3004.K10 196.93,160.22 v3(196.93,160.19) ; v3(183.07,144.12) 183.1,144.12 U3002.T31
FBA_CMD2: length 30.7
  TOP w0.152: v3(197.73,160.22) VRAM3004.K11
  IN3 w0.114: v3(197.73,160.21) 197.33,160.61 196.59,160.61 196.22,160.24 196.22,154.29 191.33,149.4 190.68,149.4 189.05,147.77 186.17,147.77 184.9,146.5 183.5,146.5 182.67,145.67 182.67,142.3 183.06,141.91 v1(183.17,141.91)
  BOTTOM w0.152: v1(183.17,141.91) 182.81,141.91 U3002.U29 ; v3(197.73,160.22) VRAM3004.K11
FBA_CMD3: length 24.9
  TOP w0.152: v3(196.93,162.55) 196.99,162.55 VRAM3004.H11
  IN3 w0.114: v3(196.93,162.55) 195.76,161.39 195.76,154.45 191.17,149.85 190.49,149.85 188.86,148.23 185.98,148.23 184.82,147.06 v1(184.56,147.06)
  BOTTOM w0.152: VRAM3004.H11 196.99,162.55 v3(196.93,162.55) ; U3002.R34 184.46,146.27 184.46,146.96 v1(184.56,147.06)
FBA_CMD4: length 25.9
  TOP w0.152: VRAM3004.H10 196.21,162.53 v3(196.11,162.53)
  IN3 w0.114: v3(196.11,162.53) 195.31,161.73 195.31,154.64 190.98,150.31 190.3,150.31 188.72,148.74 185.32,148.74 v3(184.21,147.62)
  BOTTOM w0.152: v3(196.11,162.53) 196.21,162.53 VRAM3004.H10 ; U3002.R33 183.93,145.74 183.93,146.3 184.13,146.5 184.13,147.54 v3(184.21,147.62)
FBA_CMD5: length 29.7
  TOP w0.152: v3(197.73,162.62) VRAM3004.G12
  IN3 w0.114: v1(184.21,148.28) 185.17,149.24 188.58,149.24 190.11,150.77 190.79,150.77 194.8,154.78 194.8,162.12 195.7,163.02 197.32,163.02 v3(197.73,162.62)
  BOTTOM w0.152: v3(197.73,162.62) VRAM3004.G12 ; U3002.U32 183.07,144.98 183.07,145.6 183.32,145.86 183.32,146.41 183.31,146.42 183.31,146.43 183.22,146.52 183.22,147.29 v1(184.21,148.28)
FBA_CMD6: length 26.7
  TOP w0.152: v3(191.32,161.82) 191.33,161.82 VRAM3004.H4
  IN3 w0.114: v3(191.32,161.82) 190.93,161.43 190.93,160.03 190.56,159.66 188.27,159.66 188.02,159.4 188.02,155.49 187.86,155.34 186.5,155.34 186.35,155.18 186.35,154.96 186.5,154.81 187.86,154.81 188.02,154.66 188.02,154.45 187.84,154.27 185.93,154.27 v1(184.97,153.31)
  BOTTOM w0.152: VRAM3004.H4 191.33,161.82 v3(191.32,161.82) ; U3002.U33 182.63,145.56 183.04,145.97 183.04,146.29 182.94,146.4 182.94,147.65 184.18,148.89 184.18,150.79 184.97,151.58 v1(184.97,153.31)
FBA_CMD7: length 29.9
  TOP w0.152: v3(192.95,161.85) 192.9,161.85 VRAM3004.H5
  IN3 w0.114: v3(182.23,141.67) 182.23,142.08 182.45,142.3 182.45,146.07 183.19,146.81 183.19,147.97 184.97,149.75 188.44,149.75 189.92,151.23 190.6,151.23 194.34,154.97 194.34,160.45 v3(192.95,161.85)
  BOTTOM w0.152: VRAM3004.H5 192.9,161.85 v3(192.95,161.85) ; U3002.U28 182.23,141.64 v3(182.23,141.67)
FBA_CMD8: length 31.1
  TOP w0.152: VRAM3004.J4 192.13,161.81 v3(192.13,161.82)
  IN3 w0.114: v1(181.42,140.82) 181.83,141.23 181.83,141.99 182.23,142.39 182.23,145.53 182.2,145.56 182.2,146.35 182.56,146.7 182.56,148 184.77,150.21 188.25,150.21 189.73,151.68 190.41,151.68 193.88,155.16 193.88,160.06 v3(192.13,161.82)
  BOTTOM w0.152: U3002.V28 181.42,140.83 v1(181.42,140.82) ; VRAM3004.J4 192.13,161.81 v3(192.13,161.82)
FBA_CMD9: length 28.6
  TOP w0.152: v3(192.16,161.01) 192.16,161.04 VRAM3004.J5
  IN3 w0.114: v3(181.42,141.6) 181.42,141.88 182.02,142.48 182.02,145.44 181.87,145.59 181.87,146.59 182.11,146.83 182.11,148.29 182.56,148.74 182.56,149.37 184.31,151.12 185.09,151.12 185.83,151.86 188.61,151.86 189.35,152.6 189.98,152.6 192.33,154.95 192.33,156.38 192.56,156.61 192.56,160.6 v3(192.16,161.01)
  BOTTOM w0.152: v3(181.42,141.6) 181.42,141.68 U3002.V29 ; VRAM3004.J5 192.16,161.04 v3(192.16,161.01)
FBA_CMD10: length 26.7
  TOP w0.152: VRAM3004.K4 192.13,160.22 v3(192.13,160.19)
  IN3 w0.114: v1(181.42,142.49) 181.8,142.88 181.8,145.35 181.56,145.59 181.56,148.51 181.97,148.91 181.97,149.55 184,151.58 184.9,151.58 185.64,152.32 188.42,152.32 189.16,153.05 189.78,153.05 190.95,154.22 190.95,155.71 191.7,156.46 191.7,159.76 v3(192.13,160.19)
  BOTTOM w0.152: U3002.V30 181.42,142.53 v1(181.42,142.49) ; v3(192.13,160.19) 192.13,160.22 VRAM3004.K4
FBA_CMD11: length 24.7
  TOP w0.152: v3(193,160.17) 192.98,160.17 VRAM3004.K5
  IN3 w0.114: v3(193,160.17) 193.43,159.74 193.43,155.35 190.22,152.14 189.54,152.14 188.07,150.67 187.61,150.67 187.46,150.82 187.46,151.25 187.3,151.4 187.08,151.4 186.92,151.25 186.92,150.82 186.77,150.67 186.54,150.67 186.39,150.82 186.39,151.24 186.23,151.4 186.01,151.4 185.86,151.24 185.86,150.82 185.7,150.67 184.56,150.67 v1(183.57,149.68)
  BOTTOM w0.152: v3(193,160.17) 192.98,160.17 VRAM3004.K5 ; U3002.U34 182.63,147.84 183.57,148.79 v1(183.57,149.68)
FBA_CMD12: length 27.4
  TOP w0.152: v3(191.33,160.21) VRAM3004.L3
  IN3 w0.114: v3(191.33,160.21) 191.33,160.05 190.3,159.02 189.54,159.02 189.24,158.72 189.24,153.78 188.23,152.78 187.78,152.78 187.62,152.93 187.62,153.66 187.47,153.82 187.25,153.82 187.09,153.66 187.09,152.93 186.94,152.78 186.71,152.78 186.56,152.93 186.56,153.66 186.4,153.82 186.18,153.82 186.02,153.66 186.02,152.93 185.87,152.78 185.45,152.78 184.84,152.17 v1(184.33,152.17)
  BOTTOM w0.152: v3(191.33,160.21) VRAM3004.L3 ; v1(184.33,152.17) 184.33,151.59 183.57,150.83 183.57,150.34 182.99,149.75 182.99,148.73 182.23,147.97 182.23,144.14 U3002.U31
FBA_CMD13: length 36.8
  TOP w0.152: R4542.1 v1(187.89,170.58) ; v3(190.53,161.01) 190.53,161.02 VRAM3004.J2
  IN1 w0.114: v1(187.89,170.58) 187.89,168.55 188.14,168.29 188.14,162.83 188.52,162.45 189.08,162.45 189.31,162.22 189.31,161.54 189.84,161.01 v3(190.53,161.01)
  IN3 w0.114: v1(183.65,152.04) 183.65,153.13 186.31,155.8 187.36,155.8 187.56,156 187.56,156.2 187.36,156.41 186.67,156.41 186.52,156.56 186.52,156.79 186.67,156.94 187.41,156.94 187.56,157.09 187.56,157.32 187.41,157.47 186.67,157.47 186.52,157.63 186.52,157.86 186.67,158.01 187.41,158.01 187.56,158.16 187.56,159.84 188.34,160.61 190.13,160.61 v3(190.53,161.01)
  BOTTOM w0.152: v1(183.65,152.04) 183.65,151.55 183.11,151.02 183.11,150.54 182.53,149.96 182.53,148.75 181.9,148.11 181.9,146.21 U3002.V34 ; VRAM3004.J2 190.53,161.02 v3(190.53,161.01)
FBA_CMD14: length 37
  TOP w0.152: VRAM3004.J3 190.53,161.82 v3(190.53,161.82) ; R4538.1 v1(190.18,170.58)
  IN1 w0.114: v3(190.53,161.82) 190.53,161.85 190.15,162.22 190.15,165.4 189.29,166.26 189.29,168.93 190.18,169.82 v1(190.18,170.58)
  IN3 w0.114: v1(182.56,151.28) 182.56,152.8 186.06,156.31 186.06,158.34 186.21,158.49 186.95,158.49 187.1,158.65 187.1,158.88 186.95,159.03 186.21,159.03 186.06,159.18 186.06,159.41 186.21,159.56 186.95,159.56 187.1,159.72 187.1,159.94 186.95,160.09 186.33,160.09 186.17,160.25 186.17,160.47 186.33,160.63 187.46,160.63 188.25,161.41 190.13,161.41 v3(190.53,161.82)
  BOTTOM w0.152: v3(190.53,161.82) 190.53,161.82 VRAM3004.J3 ; v1(182.56,151.28) 182.56,150.64 182.05,150.13 182.05,148.74 181.62,148.31 181.62,146.48 181.4,146.27 181.4,145.77 U3002.V33
FBA_CMD15: length 25.4
  TOP w0.152: v3(190.56,162.58) 190.56,162.64 VRAM3004.G3
  IN3 w0.114: v1(181.97,150.72) 181.97,152.98 185.6,156.61 185.6,160.55 187.38,162.33 189.26,162.33 189.35,162.24 189.99,162.24 190.33,162.58 v3(190.56,162.58)
  BOTTOM w0.152: VRAM3004.G3 190.56,162.64 v3(190.56,162.58) ; v1(181.97,150.72) 181.59,150.34 181.59,148.72 181.17,148.31 181.17,147.6 180.65,147.09 180.65,146.6 180.8,146.45 180.8,145.73 180.55,145.48 180.55,145.11 180.13,144.69 U3002.Y32
FBA_CMD16: length 22.6
  TOP w0.152: v3(171.34,159.39) 171.29,159.39 VRAM3001.G12
  IN3 w0.114: v3(171.34,159.39) 171.74,158.99 172.27,158.99 172.49,158.77 172.49,148.72 176.83,144.37 176.83,143.74 177.64,142.93 178.27,142.93 178.67,143.33 v1(178.89,143.33)
  BOTTOM w0.152: v1(178.89,143.33) 178.91,143.33 U3002.AA31 ; v3(171.34,159.39) 171.29,159.39 VRAM3001.G12
FBA_CMD17: length 26.7
  TOP w0.152: VRAM3001.H10 172.86,160.22 v3(172.88,160.22)
  IN3 w0.114: v3(178.93,141.69) 178.81,141.69 178.49,142.01 177.81,142.01 176.87,142.95 176.18,142.95 175.99,143.14 175.99,144.51 174.55,145.94 173.67,145.94 171.69,147.92 171.69,157.97 171.47,158.19 171.13,158.19 170.94,158.38 170.94,159.6 171.13,159.79 172.45,159.79 v3(172.88,160.22)
  BOTTOM w0.152: U3002.AA29 v3(178.93,141.69) ; v3(172.88,160.22) 172.86,160.22 VRAM3001.H10
FBA_CMD18: length 29.2
  TOP w0.152: VRAM3001.H11 172.09,160.19 v3(172.09,160.19)
  IN3 w0.114: v1(179.71,141.65) 179.31,141.24 178.36,141.24 178.11,141.5 177.6,141.5 177.01,142.09 175.44,142.09 175.19,142.33 175.19,142.89 173.54,144.55 173.54,145.43 170.89,148.09 170.89,157.99 170.14,158.74 170.14,160.4 170.33,160.59 VRAM3001.H11 v3(172.09,160.19)
  BOTTOM w0.152: VRAM3001.H11 172.09,160.19 v3(172.09,160.19) ; v1(179.71,141.65) 179.71,141.62 U3002.AA28
FBA_CMD19: length 20.5
  TOP w0.152: v3(172.09,162.59) VRAM3001.K11
  IN3 w0.114: v3(177.61,146.76) 177.34,146.76 174.63,149.47 174.63,156.8 173.99,157.44 173.99,161.42 173.48,161.92 172.75,161.92 v3(172.09,162.59)
  BOTTOM w0.152: U3002.AC34 177.63,146.74 v3(177.61,146.76) ; v3(172.09,162.59) VRAM3001.K11
FBA_CMD20: length 21.2
  TOP w0.152: VRAM3001.K10 172.92,162.19 v3(173.06,162.33)
  IN3 w0.114: v3(177.98,147.25) 177.52,147.25 175.09,149.68 175.09,156.99 174.45,157.63 174.45,161.62 173.74,162.33 v3(173.06,162.33)
  BOTTOM w0.152: v3(177.98,147.25) 178.06,147.17 178.06,145.77 U3002.AC33 ; v3(173.06,162.33) 172.92,162.19 VRAM3001.K10
FBA_CMD21: length 25.1
  TOP w0.152: v3(171.31,162.58) 171.3,162.58 VRAM3001.L12
  IN3 w0.114: v3(177.69,147.78) 175.55,149.92 175.55,157.18 174.91,157.82 174.91,161.87 174,162.78 172.7,162.78 172.48,163 171.73,163 v3(171.31,162.58)
  BOTTOM w0.152: v3(171.31,162.58) 171.3,162.58 VRAM3001.L12 ; v3(177.69,147.78) 178.18,147.78 178.93,147.03 178.93,146.67 178.67,146.41 178.67,145.84 178.87,145.64 178.87,145 U3002.AA32
FBA_CMD22: length 19.7
  TOP w0.152: VRAM3001.K4 177.68,161.79 v3(177.73,161.79)
  IN3 w0.114: v1(178.84,149.88) 178.68,150.04 178.68,153.82 178.89,154.03 178.89,158.77 178.67,158.99 178.31,158.99 178.09,159.21 178.09,159.57 177.87,159.79 177.51,159.79 177.29,160.01 177.29,161.35 v3(177.73,161.79)
  BOTTOM w0.152: U3002.AA33 179.33,145.58 178.95,145.96 178.95,146.3 179.2,146.55 179.2,147.26 178.62,147.85 178.62,149.66 v1(178.84,149.88) ; v3(177.73,161.79) 177.68,161.79 VRAM3001.K4
FBA_CMD23: length 24.5
  TOP w0.152: VRAM3001.K5 176.2,162.19 v3(175.95,161.94)
  IN3 w0.114: v3(180.5,141.63) 180.12,142.01 180.12,142.76 179.36,143.53 179.36,144.32 178.92,144.75 178.92,147.19 176,150.11 176,157.37 175.36,158.01 175.36,161.36 v3(175.95,161.94)
  BOTTOM w0.152: v3(175.95,161.94) 176.2,162.19 VRAM3001.K5 ; v3(180.5,141.63) 180.5,141.61 U3002.Y28
FBA_CMD24: length 23.2
  TOP w0.152: VRAM3001.J4 176.9,161.77 v3(176.9,161.82)
  IN3 w0.114: v3(176.9,161.82) 176.21,161.12 176.21,159.02 176.46,158.77 176.46,150.32 179.34,147.43 179.34,144.92 179.89,144.38 179.89,143.35 180.55,142.69 v3(180.55,142.49)
  BOTTOM w0.152: VRAM3001.J4 176.9,161.77 v3(176.9,161.82) ; U3002.Y29 180.53,142.49 v3(180.55,142.49)
FBA_CMD25: length 20.9
  TOP w0.152: VRAM3001.J5 176.84,161.04 v3(176.84,161)
  IN3 w0.114: v3(176.84,161) 176.47,160.63 176.47,159.23 176.71,158.99 177.07,158.99 177.29,158.77 177.29,154.14 176.92,153.77 176.92,150.51 179.76,147.66 179.76,145.05 180.55,144.27 v1(180.55,144.12)
  BOTTOM w0.152: U3002.W31 180.6,144.12 v1(180.55,144.12) ; v3(176.84,161) 176.84,161.04 VRAM3001.J5
FBA_CMD26: length 23.4
  TOP w0.152: v3(177.69,160.19) VRAM3001.H4
  IN3 w0.114: v3(180.55,143.3) 180.96,143.71 180.96,144.35 180.18,145.12 180.18,148.02 179.64,148.56 179.64,149.39 180.12,149.87 180.12,153.71 181.77,155.36 181.77,158.8 180.77,159.79 178.34,159.79 177.94,160.19 v3(177.69,160.19)
  BOTTOM w0.152: v3(177.69,160.19) VRAM3001.H4 ; U3002.Y30 180.49,143.3 v3(180.55,143.3)
FBA_CMD27: length 20.3
  TOP w0.152: VRAM3001.H5 176.87,160.21 v3(176.87,160.18)
  IN3 w0.114: v1(179.13,148.94) 178.22,149.85 178.22,150.51 178,150.73 177.53,150.73 177.37,150.89 177.37,151.11 177.53,151.27 178.06,151.27 178.22,151.42 178.22,151.64 178.06,151.8 177.53,151.8 177.37,151.96 177.37,152.18 177.53,152.33 178.06,152.33 178.22,152.49 178.22,152.71 178.06,152.87 177.53,152.87 177.37,153.02 177.37,153.24 177.53,153.4 177.94,153.4 178.09,153.55 178.09,158.75 178.08,158.75 178.08,158.78 177.87,158.99 177.51,158.99 177.29,159.21 177.29,159.64 176.87,160.06 v3(176.87,160.18)
  BOTTOM w0.152: v3(176.87,160.18) 176.87,160.21 VRAM3001.H5 ; v1(179.13,148.94) 179.13,147.93 179.48,147.57 179.48,146.29 U3002.AA34
FBA_CMD28: length 24.9
  TOP w0.152: v3(178.49,159.39) VRAM3001.G3
  IN3 w0.114: v1(179.48,149.88) 179.63,150.03 179.63,150.49 179.48,150.64 179.29,150.64 179.14,150.79 179.14,151.02 179.29,151.18 179.48,151.18 179.63,151.33 179.63,151.56 179.48,151.71 179.29,151.71 179.14,151.86 179.14,152.09 179.29,152.24 179.48,152.24 179.63,152.39 179.63,152.62 179.48,152.78 179.29,152.78 179.14,152.93 179.14,153.16 179.29,153.31 179.48,153.31 179.63,153.46 179.63,154.17 179.41,154.4 179.41,154.61 179.58,154.77 179.79,154.77 180.05,154.51 180.27,154.51 181.31,155.55 181.31,156.15 181.16,156.31 180.8,156.31 180.65,156.46 180.65,156.69 180.8,156.84 181.16,156.84 181.31,156.99 181.31,157.22 181.16,157.37 180.8,157.37 180.65,157.53 180.65,157.75 180.8,157.91 181.16,157.91 181.31,158.06 181.31,158.52 180.84,158.99 179.03,158.99 178.63,159.39 v3(178.49,159.39)
  BOTTOM w0.152: U3002.Y31 179.74,144.13 179.74,149.62 v1(179.48,149.88) ; v3(178.49,159.39) VRAM3001.G3
FBA_CMD29: length 30.3
  TOP w0.152: R4543.1 v1(179.38,170.45) ; v3(178.51,160.98) 178.51,161.01 VRAM3001.J2
  IN1 w0.114: v1(179.38,170.45) 179.38,170.3 179.28,170.2 179.28,162.65 178.89,162.26 178.89,161.53 178.67,161.31 178.67,161.15 v3(178.51,160.98)
  IN3 w0.114: v3(178.51,160.98) 178.9,160.59 180.86,160.59 182.23,159.23 182.23,155.17 180.58,153.52 180.58,149.68 180.14,149.24 180.14,148.79 v1(180.27,148.66)
  BOTTOM w0.152: VRAM3001.J2 178.51,161.01 v3(178.51,160.98) ; U3002.Y34 179.99,146.27 179.99,147.82 180.27,148.1 v1(180.27,148.66)
FBA_CMD30: length 35
  TOP w0.152: v3(177.69,160.99) VRAM3001.J3 ; R4541.1 v1(176.71,170.45)
  IN1 w0.114: v3(177.69,160.99) 177.32,161.35 177.32,162.22 176.84,162.71 175.82,162.71 175.32,163.21 175.32,168.8 176.71,170.2 v1(176.71,170.45)
  IN3 w0.114: v3(177.69,160.99) VRAM3001.J3 180.95,161.39 182.68,159.66 182.68,154.98 181.04,153.34 v1(181.04,149.75)
  BOTTOM w0.152: U3002.Y33 180.13,145.59 180.52,145.99 180.52,146.3 180.29,146.53 180.29,147.34 180.73,147.77 180.73,148.41 181.13,148.81 181.13,149.66 v1(181.04,149.75) ; v3(177.69,160.99) VRAM3001.J3
FBA_CMD31: length 25.2
  TOP w0.152: v3(178.49,163.39) VRAM3001.L3
  IN3 w0.114: v3(178.49,163.39) 179.48,162.4 180.96,162.4 183.19,160.17 183.19,154.84 181.5,153.16 181.5,149.08 180.63,148.2 180.63,145.06 181.39,144.29 v3(181.39,144.11)
  BOTTOM w0.152: v3(181.39,144.11) 181.45,144.11 U3002.V31 ; v3(178.49,163.39) VRAM3001.L3
FBA_DBI0: length 17.3
  IN1 w0.114: v3(189.71,156.98) 189.71,156.78 189.03,156.1 188.52,156.1 187.13,154.71 187.13,150.73 185.5,149.09 185.5,146.36 185.99,145.87 185.99,143.74 v1(185.57,143.32)
  BOTTOM w0.152: U3002.P30 185.51,143.32 v1(185.57,143.32) ; VRAM3000.D2 189.71,156.99 v3(189.71,156.98)
FBA_DBI1: length 18
  TOP w0.152: v3(198.51,156.99) VRAM3004.P13
  IN1 w0.114: v3(198.51,156.99) 198.51,156.76 199.27,156 199.27,154.12 197.64,152.5 197.26,152.5 192.23,147.46 192.23,146.51 191.19,145.47 191.19,144.4 v3(191.42,144.17)
  BOTTOM w0.152: U3002.F31 191.42,144.14 v3(191.42,144.17)
FBA_DBI2: length 30.3
  IN3 w0.114: v1(198.56,149.96) 199.01,149.96 203.27,154.21 203.27,161.12 203,161.38 203,163.56 200.66,165.9 199.41,165.9 v3(199.33,165.82)
  BOTTOM w0.152: v1(198.56,149.96) 194.17,149.96 191.93,147.71 191.93,146.24 U3002.F34 ; v3(199.33,165.82) VRAM3000.P13
FBA_DBI3: length 23.6
  TOP w0.152: VRAM3004.D2 189.71,164.99 189.13,164.99 189.03,164.89 188.38,164.89 188.14,164.65 188.14,164.36 187.76,163.98 v1(187.64,163.98)
  BOTTOM w0.102: 186.62,147.47 186.62,146.76 186.26,146.4 186.26,145.77 186.39,145.63 186.39,144.97 U3002.M32
  BOTTOM w0.152: 186.62,147.47 186.62,148.18 186.54,148.26 186.54,149.81 187.64,150.91 v1(187.64,163.98)
FBA_DBI4: length 16.7
  TOP w0.152: v3(179.29,156.99) VRAM3001.D2
  IN1 w0.114: v3(179.29,156.99) 179.69,156.59 180.32,156.59 180.65,156.26 180.65,153.8 176.41,149.56 176.41,144.19 176.41,144.19 v3(176.41,144.16)
  BOTTOM w0.152: U3002.AD31 v3(176.41,144.16)
FBA_DBI5: length 18.8
  IN1 w0.114: v3(169.74,156.99) 169.33,156.58 168.66,156.58 168.15,156.08 168.15,153.49 169.65,151.99 169.65,145.7 170.7,144.65 170.7,143.04 170.93,142.8 170.93,142.04 v1(171.32,141.65)
  BOTTOM w0.152: v1(171.32,141.65) U3002.AL29 ; VRAM3005.P13 169.74,157.04 v3(169.74,156.99)
FBA_DBI6: length 27
  TOP w0.152: VRAM3001.P13 169.69,165.79 v3(169.69,166.59)
  IN3 w0.114: v3(169.69,166.59) 168.53,166.59 167.09,165.15 167.09,164.4 166.83,164.15 v1(166.83,149.55)
  BOTTOM w0.152: U3002.AM32 169.93,144.54 169.54,144.93 169.12,144.93 168.94,145.11 168.94,146.22 168.08,147.09 168.08,148.31 v1(166.83,149.55)
FBA_DBI7: length 26
  BOTTOM w0.152: U3002.AF34 174.83,146.43 174.83,147.68 174.53,147.98 174.53,150.49 v1(176.3,152.26) 177.15,153.11 179.78,153.11 181.69,155.02 181.69,164.01 180.69,165.01 179.27,165.01 VRAM3005.D2
FBA_DEBUG0: length 1.6
  TOP w0.127: R4103.2 184.48,145.53 v1(183.91,144.96)
  BOTTOM w0.127: U3002.R32 v1(183.91,144.96)
FBA_DEBUG0_K: length 1.3
  TOP w0.127: v1(184.73,141.64) 184.71,141.63 TP4106.1
  BOTTOM w0.305: U3002.R28 v1(184.73,141.64)
FBA_DEBUG1: length 0.6
  BOTTOM w0.127: v3(178.06,144.9) 177.99,144.9 U3002.AC32
  vias: v1(177.98,145.54)
FBA_DEBUG1_K: length 1.3
  TOP w0.127: v1(177.25,140.84) 177.35,140.74 TP4107.1
  BOTTOM w0.152: U3002.AC28 177.25,140.86 v1(177.25,140.84)
FBA_EDC0: length 16.2
  IN1 w0.114: v1(186.39,143.32) 186.3,143.41 186.3,146.01 185.81,146.5 185.81,148.96 187.45,150.6 187.45,154.14 188.4,155.09 188.91,155.09 189.16,155.34 189.16,155.63 v3(189.71,156.18)
  BOTTOM w0.152: U3002.M31 186.41,143.32 v1(186.39,143.32) ; VRAM3000.C2 189.71,156.19 v3(189.71,156.18)
FBA_EDC1: length 17.1
  TOP w0.152: v3(198.53,156.17) 198.53,156.22 VRAM3004.R13
  IN1 w0.114: v3(198.53,156.17) 198.94,155.76 198.94,154.27 197.64,152.97 197.29,152.97 191.91,147.59 191.91,146.64 190.81,145.54 190.81,144.42 v1(190.56,144.17)
  BOTTOM w0.152: v1(190.56,144.17) 190.56,144.16 U3002.G31
FBA_EDC2: length 32.1
  IN3 w0.114: v3(199.33,166.62) 199.46,166.75 200.46,166.75 201.91,165.3 202.82,165.3 203.38,164.74 203.38,161.5 203.58,161.3 203.58,154 v1(198.39,148.81)
  BOTTOM w0.152: v1(198.39,148.81) 194.62,148.81 194.07,148.27 193.82,148.27 192.81,147.25 192.81,146.5 193.01,146.29 193.01,146 192.63,145.61 U3002.E33 ; v3(199.33,166.62) VRAM3000.R13
FBA_EDC3: length 23.9
  TOP w0.152: v1(187.64,165.25) 188.17,165.78 189.69,165.78 VRAM3004.C2
  BOTTOM w0.102: U3002.M33 186.83,145.58 186.47,145.93 186.47,146.29 186.68,146.5 186.68,146.5 186.87,146.69 186.87,147.47
  BOTTOM w0.152: 186.87,147.47 186.87,147.84 186.98,147.94 186.98,149.64 188.14,150.8 188.14,164.76 187.66,165.25 v1(187.64,165.25)
FBA_EDC4: length 15.3
  TOP w0.152: VRAM3001.C2 v3(179.29,156.19)
  IN1 w0.114: v3(175.55,144.17) 175.55,149.14 180.02,153.61 180.02,155.46 v3(179.29,156.19)
  BOTTOM w0.152: U3002.AE31 v3(175.55,144.17)
FBA_EDC5: length 16.1
  IN1 w0.114: v3(169.74,156.19) 169.32,155.77 168.64,155.77 168.47,155.61 168.47,153.68 169.97,152.18 169.97,145.83 171.03,144.77 171.03,143.74 v1(171.38,143.39)
  BOTTOM w0.152: U3002.AK30 171.73,143.04 v1(171.38,143.39) ; VRAM3005.R13 169.74,156.24 v3(169.74,156.19)
FBA_EDC6: length 25
  TOP w0.152: v3(170.49,165.79) 170.49,165.79 VRAM3001.R13
  IN3 w0.114: v3(170.49,165.79) 170.43,165.73 168.28,165.73 167.44,164.89 167.44,164.25 167.19,164 167.19,150.24 168.03,149.4 168.03,148.61 v1(169.09,147.54)
  BOTTOM w0.152: U3002.AN33 169.33,145.52 169.72,145.92 169.72,146.32 169.86,146.45 169.86,146.78 v1(169.09,147.54)
FBA_EDC7: length 27.8
  BOTTOM w0.102: U3002.AF33 175.29,145.51 175.29,145.8 175.48,145.99 175.48,146.29 175.16,146.61 175.16,147.09
  BOTTOM w0.152: 175.16,147.09 175.16,148.13 174.96,148.33 174.96,150.02 v1(175.32,150.38) 176.09,151.15 177.61,152.67 179.96,152.67 182.12,154.84 182.12,164.47 180.75,165.85 179.89,165.85 179.86,165.82 179.26,165.82 VRAM3005.C2
FBB_CMD0: length 26.5
  TOP w0.152: v3(210.98,118.49) 211.03,118.49 VRAM3007.L12
  IN3 w0.114: v1(193.91,129.08) 194.59,129.08 195.38,128.29 195.38,128.05 202.39,121.04 211.54,121.04 212.19,120.4 212.19,119.06 211.97,118.84 211.33,118.84 v3(210.98,118.49)
  BOTTOM w0.152: v3(210.98,118.49) 211.03,118.49 VRAM3007.L12 ; U3002.D13 193.91,129.07 v1(193.91,129.08)
FBB_CMD1: length 27
  TOP w0.152: VRAM3007.K10 211.78,120.03 v3(211.77,120.03)
  IN3 w0.114: v3(211.77,120.03) 211.23,120.57 202.22,120.57 195.13,127.65 192.77,127.65 192.59,127.83 192.16,127.83 191.9,128.09 191.9,129.56 v3(192.31,129.97)
  BOTTOM w0.152: v3(211.77,120.03) 211.78,120.03 VRAM3007.K10 ; v3(192.31,129.97) 192.73,129.55 U3002.E14
FBB_CMD2: length 27.9
  TOP w0.152: VRAM3007.K11 211.81,119.26 v3(211.77,119.26)
  IN3 w0.114: v1(191.49,129.05) 191.06,128.62 191.06,127.23 191.27,127.02 192.97,127.02 193.1,127.15 194.99,127.15 202.1,120.03 205.58,120.03 205.99,119.63 211.41,119.63 v3(211.77,119.26)
  BOTTOM w0.152: VRAM3007.K11 211.81,119.26 v3(211.77,119.26) ; v1(191.49,129.05) 191.49,129.18 191.85,129.54 U3002.F14
FBB_CMD3: length 23.7
  TOP w0.152: v3(214.18,120.03) 214.18,120.03 VRAM3007.H11
  IN3 w0.114: v3(214.18,120.03) 213.92,120.29 213.92,121.37 212.67,122.63 203.99,122.63 v1(198.25,128.36)
  BOTTOM w0.152: v1(198.25,128.36) 197.74,127.84 U3002.A12 ; VRAM3007.H11 214.18,120.03 v3(214.18,120.03)
FBB_CMD4: length 22.9
  TOP w0.152: VRAM3007.H10 213.42,120.8 v3(213.42,120.88)
  IN3 w0.114: v3(213.42,120.88) 213.42,121.24 212.48,122.17 203.18,122.17 v3(197.06,128.29)
  BOTTOM w0.152: v3(197.06,128.29) 196.98,128.21 195.5,128.21 U3002.B12 ; VRAM3007.H10 213.42,120.8 v3(213.42,120.88)
FBB_CMD5: length 27.3
  TOP w0.152: VRAM3007.G12 214.58,118.86 v3(214.19,119.26)
  IN3 w0.114: v1(197.14,128.95) 197.21,129.03 198.21,129.03 204.15,123.08 212.86,123.08 214.43,121.51 214.43,120.54 214.58,120.4 214.58,119.65 v3(214.19,119.26)
  BOTTOM w0.152: U3002.C14 194.72,129.15 195.26,129.15 195.51,128.9 196.17,128.9 196.38,129.11 196.98,129.11 v1(197.14,128.95) ; v3(214.19,119.26) 214.58,118.86 VRAM3007.G12
FBB_CMD6: length 23.6
  TOP w0.152: v3(214.19,124.83) VRAM3007.H4
  IN3 w0.114: v1(201.61,129.48) 203.38,127.71 210.37,127.71 210.61,127.46 210.61,127.05 210.82,126.84 211.15,126.84 211.38,126.61 211.38,126.26 211.39,126.25 211.39,126.24 211.63,126.01 212.25,126.01 212.27,126.03 212.75,126.03 212.99,125.8 212.99,125.47 213.22,125.23 213.79,125.23 v3(214.19,124.83)
  BOTTOM w0.152: v1(201.61,129.48) 200.92,128.8 198.05,128.8 197.46,129.39 196.3,129.39 196.06,129.15 195.62,129.15 195.23,129.54 U3002.B14 ; v3(214.19,124.83) VRAM3007.H4
FBB_CMD7: length 26.9
  TOP w0.152: VRAM3007.H5 213.5,124.15 v3(213.5,123.99)
  IN3 w0.114: v3(191.42,129.94) 191.84,130.37 192.73,130.37 193.02,130.07 195.23,130.07 195.89,129.41 198.42,129.41 204.28,123.55 213.06,123.55 v3(213.5,123.99)
  BOTTOM w0.152: VRAM3007.H5 213.5,124.15 v3(213.5,123.99) ; U3002.G15 191.42,129.94 v3(191.42,129.94)
FBB_CMD8: length 26.9
  TOP w0.152: v3(213.39,124.83) VRAM3007.J4
  IN3 w0.114: v3(213.39,124.83) 213.19,124.83 212.79,125.23 212.41,125.23 211.89,125.75 211.45,125.75 211.17,126.04 210.77,126.04 210.57,126.23 210.57,126.63 210.37,126.83 209.67,126.83 209.48,127.02 203.4,127.02 199.77,130.64 196.33,130.64 195.52,131.46 193.85,131.46 193.59,131.19 191.95,131.19 v1(191.49,130.73)
  BOTTOM w0.152: v3(213.39,124.83) VRAM3007.J4 ; v1(191.49,130.73) U3002.F15
FBB_CMD9: length 24
  TOP w0.152: VRAM3007.J5 212.61,124.06 v3(212.61,124.01)
  IN3 w0.114: v3(193.12,130.76) 193.3,130.76 193.73,130.32 195.51,130.32 196.09,129.74 199.38,129.74 203.89,125.23 205.41,125.23 205.41,125.23 210.38,125.23 210.75,124.86 211.13,124.86 211.56,124.43 212.19,124.43 v3(212.61,124.01)
  BOTTOM w0.152: v3(212.61,124.01) 212.61,124.06 VRAM3007.J5 ; U3002.E15 193.12,130.73 v3(193.12,130.76)
FBB_CMD10: length 23.5
  TOP w0.152: v3(212.59,124.83) VRAM3007.K4
  IN3 w0.114: v1(193.94,130.8) 194.36,131.23 195.24,131.23 196.27,130.19 199.57,130.19 203.74,126.03 205.54,126.03 205.54,126.03 210.34,126.03 210.57,125.81 210.57,125.49 210.89,125.17 211.32,125.17 211.38,125.24 212.01,125.24 212.42,124.83 v3(212.59,124.83)
  BOTTOM w0.152: v1(193.94,130.8) 193.94,130.75 U3002.D15 ; v3(212.59,124.83) VRAM3007.K4
FBB_CMD11: length 19.4
  TOP w0.152: v3(211.81,124.01) 211.81,124.06 VRAM3007.K5
  IN3 w0.114: v3(211.81,124.01) 211.6,124.01 211.22,124.39 204.08,124.39 v1(199.22,129.26)
  BOTTOM w0.152: U3002.A14 196.03,129.64 197.69,129.64 198.08,129.26 v1(199.22,129.26) ; VRAM3007.K5 211.81,124.06 v3(211.81,124.01)
FBB_CMD12: length 22.1
  TOP w0.152: VRAM3007.L3 211.76,126.41 v3(211.79,126.41)
  IN3 w0.114: v3(202.11,130.07) 209.51,130.07 211.16,128.42 211.16,127.88 211.42,127.62 211.42,127.01 211.79,126.64 v3(211.79,126.41)
  BOTTOM w0.152: U3002.D14 193.91,129.92 197.92,129.92 198.13,129.72 v1(200.85,129.72) 201.1,129.72 201.45,130.07 v3(202.11,130.07) ; v3(211.79,126.41) 211.76,126.41 VRAM3007.L3
FBB_CMD13: length 34
  TOP w0.152: VRAM3007.J2 v3(213.39,126.43)
  IN1 w0.114: v1(222.05,128.54) 220.66,128.54 220.35,128.85 213.72,128.85 213.16,128.29 213.16,126.66 v3(213.39,126.43)
  IN3 w0.114: v3(213.39,126.43) 213.08,126.74 213.08,128.5 210.5,131.08 v1(201.43,131.08)
  BOTTOM w0.152: v1(201.43,131.08) 200.52,130.17 198.09,130.17 197.92,130.34 U3002.A15 ; R11080.1 222.17,128.54 v1(222.05,128.54) ; VRAM3007.J2 v3(213.39,126.43)
FBB_CMD14: length 35
  TOP w0.152: R11086.1 222.23,129.05 v1(222.05,129.23) ; VRAM3007.J3 212.59,126.43 v3(212.59,126.43)
  IN1 w0.114: v3(212.59,126.43) 212.65,126.5 212.65,128.54 213.92,129.81 218.37,129.81 218.75,129.43 221.11,129.43 221.32,129.23 v1(222.05,129.23)
  IN3 w0.114: v3(212.59,126.43) 212.59,127.51 212.6,127.53 212.6,128.34 210.31,130.63 200.46,130.63 v1(200.13,130.96)
  BOTTOM w0.152: v3(212.59,126.43) 212.59,126.43 VRAM3007.J3 ; U3002.B15 195.13,130.35 195.54,130.76 196.15,130.76 196.27,130.63 199.8,130.63 v1(200.13,130.96)
FBB_CMD15: length 24.6
  TOP w0.152: v3(214.19,126.43) VRAM3007.G3
  IN3 w0.114: v1(202.75,131.97) 210.26,131.97 213.54,128.69 213.54,127.08 v3(214.19,126.43)
  BOTTOM w0.152: v1(202.75,131.97) 202.29,132.43 194.72,132.43 194.33,132.04 U3002.C17 ; v3(214.19,126.43) VRAM3007.G3
FBB_CMD16: length 26.3
  TOP w0.152: VRAM3002.G12 211,145.76 v3(211,145.76)
  IN3 w0.114: v1(193.15,133.27) 194.7,133.27 195.5,134.07 195.5,136.78 204.07,145.36 210.6,145.36 v3(211,145.76)
  BOTTOM w0.152: U3002.D18 193.15,133.22 v1(193.15,133.27) ; VRAM3002.G12 211,145.76 v3(211,145.76)
FBB_CMD17: length 30.9
  TOP w0.152: v3(211.83,144.12) 211.83,144.2 VRAM3002.H10
  IN3 w0.114: v3(211.83,144.12) 212.2,144.49 212.2,145.13 211.97,145.36 211.61,145.36 211.4,145.58 211.4,145.96 211.19,146.16 206.47,146.16 206.18,146.45 204.4,146.45 197.48,139.53 196.72,139.53 196.14,138.96 196.14,138.2 195.03,137.08 195.03,135.17 194.31,134.46 194.31,133.94 194.07,133.7 192.77,133.7 v3(192.33,133.26)
  BOTTOM w0.152: v3(211.83,144.12) 211.83,144.2 VRAM3002.H10 ; v3(192.33,133.26) 192.33,133.24 U3002.E18
FBB_CMD18: length 28.5
  TOP w0.152: v3(211.8,144.96) 211.8,144.96 VRAM3002.H11
  IN3 w0.114: v1(191.47,133.22) 191.84,132.86 194.75,132.86 195.95,134.06 195.95,136.35 204.16,144.56 211.4,144.56 v3(211.8,144.96)
  BOTTOM w0.152: U3002.F18 191.5,133.22 v1(191.47,133.22) ; v3(211.8,144.96) 211.8,144.96 VRAM3002.H11
FBB_CMD19: length 24.5
  TOP w0.152: v3(213.42,144.96) 213.42,144.98 VRAM3002.K11
  IN3 w0.114: v1(196.46,134.36) 196.46,135.36 197.92,136.82 197.92,137.48 204.11,143.67 212.84,143.67 213.05,143.89 213.05,144.59 v3(213.42,144.96)
  BOTTOM w0.152: v3(213.42,144.96) 213.42,144.98 VRAM3002.K11 ; v1(196.46,134.36) 196.27,134.54 U3002.A20
FBB_CMD20: length 25.3
  TOP w0.152: VRAM3002.K10 213.51,144.27 v3(213.51,143.97)
  IN3 w0.114: v3(213.51,143.97) 213.51,143.66 213.06,143.22 204.47,143.22 198.5,137.24 198.5,136.78 197.08,135.36 v3(197.08,134.38)
  BOTTOM w0.152: VRAM3002.K10 213.51,144.27 v3(213.51,143.97) ; U3002.B20 195.53,134.94 196.63,134.94 197.08,134.49 v3(197.08,134.38)
FBB_CMD21: length 29.4
  TOP w0.152: v3(214.17,145.74) 214.18,145.74 VRAM3002.L12
  IN3 w0.114: v3(214.17,145.74) 214.68,145.23 214.68,143.78 213.66,142.76 204.93,142.76 199.45,137.28 199.45,137.08 197.55,135.19 197.55,134.04 v3(197.34,133.83)
  BOTTOM w0.152: v3(214.17,145.74) 214.18,145.74 VRAM3002.L12 ; U3002.C18 194.71,133.22 195.3,133.22 195.61,133.53 196.24,133.53 196.51,133.26 197.03,133.26 197.34,133.57 v3(197.34,133.83)
FBB_CMD22: length 24.3
  TOP w0.152: v3(214.2,140.16) VRAM3002.K4
  IN3 w0.114: v1(199.19,134) 201.53,136.34 201.53,136.78 205.62,140.86 209.45,140.86 209.76,140.56 212.32,140.56 212.72,140.16 v3(214.2,140.16)
  BOTTOM w0.152: v3(214.2,140.16) VRAM3002.K4 ; U3002.B18 195.38,132.84 195.79,133.25 196.13,133.25 196.37,133 197.23,133 197.62,133.4 198.58,133.4 v1(199.19,134)
FBB_CMD23: length 30.9
  TOP w0.152: v3(214.04,141.15) 214.04,140.8 VRAM3002.K5
  IN3 w0.114: v3(214.04,141.15) 212.89,142.3 205.11,142.3 199.93,137.12 199.93,136.92 198.02,135.01 198.02,133.9 197.37,133.25 195.74,133.25 195.13,132.64 191.23,132.64 v1(190.62,133.25)
  BOTTOM w0.152: U3002.G18 v1(190.62,133.25) ; VRAM3002.K5 214.04,140.8 v3(214.04,141.15)
FBB_CMD24: length 31.4
  TOP w0.152: v3(213.4,141.01) 213.4,140.16 VRAM3002.J4
  IN3 w0.114: v1(190.61,131.62) 191.41,132.42 195.38,132.42 195.82,132.86 197.36,132.86 198.35,133.85 198.35,134.49 200.39,136.52 200.39,136.93 205.3,141.84 212.56,141.84 v3(213.4,141.01)
  BOTTOM w0.152: v1(190.61,131.62) 190.61,131.62 U3002.G17 ; VRAM3002.J4 213.4,140.16 v3(213.4,141.01)
FBB_CMD25: length 27.6
  TOP w0.152: VRAM3002.J5 212.63,140.92 v3(212.63,140.97)
  IN3 w0.114: v3(212.63,140.97) 212.21,141.39 205.49,141.39 200.84,136.74 200.84,136.32 198.68,134.16 198.68,133.8 197.36,132.48 196.04,132.48 195.76,132.21 192.06,132.21 v3(191.45,131.6)
  BOTTOM w0.152: v3(191.45,131.6) 191.45,131.61 U3002.F17 ; v3(212.63,140.97) 212.63,140.92 VRAM3002.J5
FBB_CMD26: length 26.6
  TOP w0.152: v3(211.8,139.36) 211.8,139.36 VRAM3002.H4
  IN3 w0.114: v3(211.8,139.36) 211.8,139.26 210.7,138.16 210.02,138.16 209.8,137.94 209.8,136.79 208.67,135.66 206.72,135.66 206.57,135.81 206.57,136.22 206.37,136.42 206.1,136.42 205.91,136.22 205.91,135.85 205.71,135.66 205.44,135.66 205.25,135.85 205.25,136.22 205.05,136.42 204.78,136.42 204.59,136.22 204.59,135.81 204.43,135.66 203.45,135.66 200.75,132.96 198.61,132.96 197.36,131.72 193.23,131.72 v3(193.1,131.59)
  BOTTOM w0.152: VRAM3002.H4 211.8,139.36 v3(211.8,139.36) ; v3(193.1,131.59) 193.13,131.59 U3002.D16
FBB_CMD27: length 22.8
  TOP w0.152: v3(211.8,140.16) 212.2,140.56 VRAM3002.H5
  IN3 w0.114: v3(211.8,140.16) 211.67,140.16 211.27,139.76 205.2,139.76 204.82,139.38 204.82,139.17 205.09,138.9 205.09,138.63 204.89,138.44 204.62,138.44 204.37,138.68 204.1,138.68 203.91,138.49 203.91,138.22 204.15,137.97 204.15,137.69 203.96,137.5 203.69,137.5 203.42,137.76 203.21,137.76 201.99,136.54 201.99,135.53 v1(200.46,134)
  BOTTOM w0.152: VRAM3002.H5 211.8,140.16 v3(211.8,140.16) ; U3002.A18 196.03,132.74 197.24,132.74 197.53,132.74 197.72,132.93 199.41,132.93 200.46,133.98 v1(200.46,134)
FBB_CMD28: length 26.5
  TOP w0.152: VRAM3002.G3 211,138.56 v3(211,137.81)
  IN3 w0.114: v3(211,137.81) 210.6,137.41 210.6,136.14 209.61,135.15 208.92,135.15 208.76,135 208.76,134.53 208.57,134.34 208.3,134.34 208.1,134.53 208.1,134.95 207.91,135.15 207.64,135.15 207.44,134.95 207.44,134.53 207.25,134.34 206.98,134.34 206.78,134.53 206.78,135 206.63,135.15 203.61,135.15 200.97,132.51 198.6,132.51 v1(197.21,131.12)
  BOTTOM w0.152: v1(197.21,131.12) 196.73,131.6 196.38,131.6 196.19,131.41 195.5,131.41 195.28,131.62 193.95,131.62 U3002.D17 ; v3(211,137.81) 211,138.56 VRAM3002.G3
FBB_CMD29: length 34.9
  TOP w0.152: VRAM3002.J2 212.6,138.55 v3(212.6,138.56) ; R11065.1 v1(221.8,138.45)
  IN1 w0.114: v3(212.6,138.56) 212.8,138.56 213.22,138.14 214.53,138.14 215.08,137.59 219.42,137.59 220.27,138.45 v1(221.8,138.45)
  IN3 w0.114: v3(212.6,138.56) 212.2,138.16 212.2,136.54 209.53,133.88 206.08,133.88 205.93,134.03 205.93,134.49 205.74,134.69 205.46,134.69 205.27,134.49 205.27,134.07 205.08,133.88 204.8,133.88 204.61,134.07 204.61,134.49 204.42,134.69 204.14,134.69 203.95,134.49 203.95,134.03 203.8,133.88 203,133.88 201.17,132.05 199.52,132.05 199.25,131.77 v3(198.59,131.77)
  BOTTOM w0.152: v3(198.59,131.77) 198.39,131.97 197.41,131.97 197.22,132.17 196.06,132.17 U3002.A17 ; v3(212.6,138.56) 212.6,138.55 VRAM3002.J2
FBB_CMD30: length 34.3
  TOP w0.152: VRAM3002.J3 213.39,138.56 v3(213.4,138.56) ; R11072.1 v1(221.93,139.47)
  IN1 w0.114: v3(213.4,138.56) 214.7,138.56 215.25,138.01 219.08,138.01 220.53,139.47 v1(221.93,139.47)
  IN3 w0.114: v1(198.56,131.13) 199.37,131.13 199.83,131.59 201.48,131.59 203.26,133.37 210.43,133.37 213.02,135.96 213.02,138.19 v3(213.4,138.56)
  BOTTOM w0.152: U3002.B17 195.39,132.04 195.77,131.66 196.09,131.66 196.33,131.9 197.03,131.9 197.3,131.63 198.06,131.63 v1(198.56,131.13) ; v3(213.4,138.56) 213.39,138.56 VRAM3002.J3
FBB_CMD31: length 27.4
  TOP w0.152: v3(214.21,139.34) VRAM3002.L3
  IN3 w0.114: v1(192.29,131.63) 192.64,131.99 197.26,131.99 198.68,133.42 200.53,133.42 205.68,138.58 206.18,138.58 206.56,138.96 211.17,138.96 211.4,139.19 211.4,139.54 211.62,139.76 213.79,139.76 v3(214.21,139.34)
  BOTTOM w0.152: U3002.E17 192.32,131.63 v1(192.29,131.63) ; v3(214.21,139.34) VRAM3002.L3
