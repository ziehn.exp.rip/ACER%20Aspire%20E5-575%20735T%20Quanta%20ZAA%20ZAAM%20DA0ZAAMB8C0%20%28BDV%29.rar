# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_CAS#: length 66.4
  IN1 w0.14: v3(113.92,103.88) 113.92,103.45 114.23,103.14 114.23,102.2 115.88,100.55 115.88,99.08 116.39,98.57 116.39,91.05 116.83,90.6 116.83,73.68 121.55,68.96 121.83,68.96 122.42,68.36 122.42,64.73 121.87,64.17 121.87,61.76 122.35,61.28 122.35,54.77 122.74,54.38 122.74,52.47 122.23,51.96 122.23,48.15 123.12,47.26 123.12,45.46 v1(123.68,44.9)
  BOTTOM w0.203: v3(113.92,103.88) U35.AU48 ; JDIM1.156 123.47,44.7 v1(123.68,44.9)
M_A_CB0: length 4
  TOP w0.127: R10896.2 104.53,43.89 104.53,44.67 v1(104.97,45.12)
  BOTTOM w0.127: JDIM1.92 105.47,44.62 v1(104.97,45.12)
M_A_CB1: length 6.7
  TOP w0.127: v1(104.32,48.85) 103.66,49.5 103.66,50.21 102.81,51.06 R10871.2 102.8,51.05 102.52,50.77 v1(102.52,50.26)
  BOTTOM w0.127: v1(104.32,48.85) 104.99,49.52 104.99,50.2 105.22,50.43 JDIM1.91
M_A_CB2: length 8.2
  TOP w0.127: v1(108.16,48.25) 107.37,47.46 107.37,46.88 106.74,46.25 v1(105.66,46.25) R10875.2
  BOTTOM w0.127: JDIM1.101 107.72,50.49 107.24,50.01 107.24,49.16 v1(108.16,48.25)
M_A_CB3: length 5.8
  TOP w0.127: R10881.2 v1(105.71,51.06) 106.83,51.06 v1(108.16,49.74)
  BOTTOM w0.127: JDIM1.105 108.72,50.3 v1(108.16,49.74)
M_A_CB4: length 4.1
  TOP w0.127: v1(103.97,45.12) 103.36,44.5 v1(103.36,44.31) 103.36,44.05 R10879.2
  BOTTOM w0.127: v1(103.97,45.12) 104.47,44.62 JDIM1.88
M_A_CB5: length 2.5
  TOP w0.127: v1(104.32,50.12) 103.82,50.62 R10884.2
  BOTTOM w0.127: JDIM1.87 104.22,50.21 v1(104.32,50.12)
M_A_CB6: length 4.8
  TOP w0.127: v1(107.47,41.83) 108.44,40.86 109.43,40.86 v1(109.46,40.89) 109.65,41.08 R10888.2
  BOTTOM w0.127: JDIM1.100 v1(107.47,41.83)
M_A_CB7: length 3
  TOP w0.127: v1(108.51,41.8) 109.53,42.82 R10892.2
  BOTTOM w0.127: v1(108.51,41.8) 108.47,41.84 JDIM1.104
M_A_CKE0: length 66.3
  IN1 w0.14: v1(107.88,47.19) 106.3,47.19 105.97,46.86 105.97,46.4 105.8,46.22 105.33,46.22 105.15,46.4 105.15,50.31 105,50.46 104.94,50.46 104.8,50.6 104.8,65.72 104.69,65.83 104.69,91.55 v1(107.32,94.18)
  BOTTOM w0.076: 108.99,100.71 109.16,100.88 109.16,101.19 109.11,101.33 109.11,101.52 U35.BA56
  BOTTOM w0.102: v1(107.32,94.18) 106.86,94.63 106.86,98.2 108.99,100.33 108.99,100.71
  BOTTOM w0.203: v1(107.88,47.19) 108.74,48.05 108.74,49.45 109.72,50.43 JDIM1.109
M_A_CKE1: length 65.1
  IN1 w0.14: v1(107.32,92.91) 105.11,90.7 105.11,66.04 105.23,65.92 105.23,50.98 105.57,50.63 105.57,48.41 106.08,47.9 106.36,47.9 106.46,48 106.46,48.28 106.61,48.43 106.84,48.43 106.99,48.28 106.99,48.03 107.22,47.8 107.9,47.8 109.56,46.14 109.56,44.37 109.71,44.22 110.08,44.22 110.23,44.37 v1(110.23,44.66)
  BOTTOM w0.102: U35.BB56 108.9,100.91 108.79,100.8 108.79,100.4 106.61,98.22 106.61,93.62 v1(107.32,92.91)
  BOTTOM w0.203: v1(110.23,44.66) 109.97,44.4 JDIM1.110
M_A_CLK0: length 67.2
  IN1 w0.089: v1(118.04,47.57) 118.42,47.57 118.51,47.66 118.51,48.96 118.31,49.17 118.31,60.95 117.76,61.5 117.76,64.05 116.92,64.89 116.92,68.88 114.85,70.95 114.85,71.48 113.91,72.42 113.91,98.64 112.45,100.1 112.45,100.46 111.55,101.37 110.8,101.37 109.82,102.35 109.82,104.06 v3(110.26,104.51)
  BOTTOM w0.127: U35.AT53 v3(110.26,104.51) ; v1(118.04,47.57) 118.38,47.57 118.55,47.73 118.55,48.03 116.84,49.74 116.84,50.32 116.72,50.43 JDIM1.137
M_A_CLK0#: length 67.1
  IN1 w0.089: v1(119.31,47.57) 118.95,47.21 118.8,47.21 118.7,47.31 118.7,49.04 118.5,49.25 118.5,61.03 117.95,61.58 117.95,64.13 117.11,64.97 117.11,68.96 115.04,71.03 115.04,71.56 114.1,72.5 114.1,98.71 112.64,100.17 112.64,100.54 111.63,101.56 110.88,101.56 110.01,102.43 110.01,103.64 v1(110.26,103.88)
  BOTTOM w0.127: JDIM1.139 117.22,50.45 117.09,50.32 117.09,49.84 118.8,48.13 118.8,47.75 118.98,47.57 v1(119.31,47.57) ; U35.AU53 v1(110.26,103.88)
M_A_CLK1: length 67.1
  IN1 w0.089: v1(109.37,104.53) 108.88,104.04 108.88,101.87 111.48,99.27 112.14,99.27 113.12,98.29 113.12,72.08 114.05,71.15 114.05,70.63 116.13,68.55 116.13,64.39 116.97,63.56 116.97,53.14 117.52,52.6 117.52,48.21 117.14,47.83 117.14,44.97 116.96,44.78 v1(116.61,44.78)
  BOTTOM w0.127: U35.AT55 v1(109.37,104.53) ; v1(116.61,44.78) 116.99,44.78 117.1,44.67 117.1,44.33 116.97,44.21 JDIM1.138
M_A_CLK1#: length 67.1
  IN1 w0.089: v1(109.37,103.87) 109.07,103.57 109.07,101.95 111.56,99.46 112.22,99.46 113.32,98.37 113.32,72.16 114.24,71.23 114.24,70.71 116.33,68.63 116.33,64.47 117.16,63.63 117.16,53.22 117.71,52.67 117.71,48.13 117.33,47.75 117.33,44.62 117.53,44.42 117.76,44.42 117.88,44.54 v1(117.88,44.78)
  BOTTOM w0.127: v1(117.88,44.78) 117.49,44.78 117.35,44.65 117.35,44.33 117.47,44.21 JDIM1.140 ; U35.AU55 v1(109.37,103.87)
M_A_CS#0: length 69.8
  IN1 w0.14: v1(124.01,48.05) 124.01,48.55 123.89,48.66 123.89,50.81 124.68,51.59 124.68,52.52 124.82,52.66 125.25,52.66 125.41,52.81 125.41,53.03 125.25,53.18 124.82,53.18 124.68,53.32 124.68,54.39 124.39,54.68 124.39,55.36 125.25,56.22 125.6,56.22 126.02,56.64 126.02,61.48 124.86,62.63 124.86,68.28 123.9,69.25 123.64,69.25 122.44,70.44 122.17,70.44 118.41,74.2 118.41,90.22 117.8,90.82 117.8,99.19 117.58,99.41 117.58,100.81 116.9,101.49 116.13,101.49 115.12,102.51 115.12,103.14 115.35,103.37 115.35,104.1 v3(115.78,104.53)
  BOTTOM w0.203: JDIM1.149 121.72,50.26 122.24,49.75 122.24,49.11 123.3,48.05 v1(124.01,48.05) ; U35.AU45 v3(115.78,104.53)
M_A_CS#1: length 71.8
  IN1 w0.14: v1(115.78,103.9) 115.78,103.15 116.13,102.79 116.13,102.25 116.57,101.82 117.1,101.82 118.04,100.88 118.04,100.22 118.46,99.8 118.46,99.46 118.03,99.03 118.03,90.96 118.83,90.16 118.83,74.37 119.13,74.08 119.33,74.08 119.53,74.28 119.73,74.28 119.9,74.11 119.9,73.91 119.69,73.71 119.69,73.51 119.87,73.34 120.06,73.34 120.27,73.54 120.46,73.54 120.63,73.37 120.63,73.17 120.43,72.97 120.43,72.77 120.6,72.6 120.8,72.6 121,72.81 121.2,72.81 121.37,72.63 121.37,72.44 121.17,72.23 121.17,72.04 121.34,71.87 121.54,71.87 121.74,72.07 121.94,72.07 122.11,71.9 122.11,71.7 121.9,71.5 121.9,71.3 122.34,70.86 122.62,70.86 123.81,69.67 124.07,69.67 124.37,69.37 124.56,69.37 124.7,69.51 124.98,69.51 125.15,69.34 125.15,69.11 125,68.96 125,68.74 125.28,68.46 125.74,67.99 125.74,67.75 125.65,67.66 125.42,67.66 125.28,67.52 125.28,67.1 125.42,66.96 125.66,66.96 125.79,66.82 125.79,66.53 125.7,66.44 125.42,66.44 125.28,66.3 125.28,66.06 125.42,65.92 125.69,65.92 125.79,65.81 125.79,65.49 125.7,65.4 125.42,65.4 125.28,65.26 125.28,65.01 125.42,64.87 125.69,64.87 125.79,64.77 125.79,64.45 125.7,64.35 125.42,64.35 125.28,64.21 125.28,63.97 125.42,63.83 125.69,63.83 125.79,63.73 125.79,63.41 125.7,63.31 125.42,63.31 125.28,63.17 125.28,62.8 126.43,61.65 126.43,56.46 125.77,55.8 125.43,55.8 125.1,55.47 125.1,54.48 125.3,54.27 126.14,54.27 126.34,54.08 126.34,52.66 124.34,50.66 v1(124.34,49.93)
  BOTTOM w0.203: v1(115.78,103.9) U35.AU43 ; JDIM1.157 123.72,50.21 124.01,49.93 v1(124.34,49.93)
M_A_DQ0: length 84.4
  IN1 w0.089: v1(95.99,108.39) 95.57,108.81 93.27,108.81 92.61,108.15 89.05,108.15 83.69,102.78 83.69,101.03 82.21,99.55 82.21,88.86 83.2,87.88 83.2,82.16 84.19,81.16 84.19,78.21 83.65,77.67 83.65,70.4 83.17,69.93 83.17,66.7 82.21,65.75 82.21,60.73 82.94,60 82.94,55.49 83.18,55.25 83.18,54.81 83.09,54.73 82.74,54.73 82.61,54.59 82.61,54.39 82.74,54.26 83.07,54.26 83.18,54.14 83.18,53.87 83.09,53.79 82.74,53.79 82.61,53.65 82.61,53.43 82.72,53.32 83.08,53.32 83.18,53.21 83.18,51.82 84.13,50.87 84.13,49.6 83.54,49.01 v1(83.54,45.82)
  BOTTOM w0.076: U35.AL71 100.16,107.88 98.1,107.88 98.03,107.96 97.89,107.96
  BOTTOM w0.114: v1(95.99,108.39) 96.42,107.96 97.89,107.96
  BOTTOM w0.127: JDIM1.8 84.47,44.89 v1(83.54,45.82)
M_A_DQ1: length 85
  IN1 w0.089: v1(97.45,108.62) 97.45,109 97.06,109.39 93.15,109.39 92.49,108.73 88.81,108.73 81.63,101.55 81.63,88.62 82.42,87.84 82.42,66.78 81.63,65.99 81.63,65.5 81.54,65.41 81.17,65.41 81.03,65.27 81.03,65.05 81.14,64.94 81.49,64.94 81.63,64.8 81.63,64.61 81.49,64.47 81.14,64.47 81.03,64.36 81.03,64.11 81.14,64 81.49,64 81.63,63.86 81.63,63.67 81.49,63.53 81.14,63.53 81.01,63.39 81.01,63.2 81.14,63.06 81.54,63.06 81.63,62.97 81.63,62.5 80.19,61.06 80.19,58.19 81.68,56.7 81.68,51.87 82.23,51.33 v1(82.23,49.8)
  BOTTOM w0.076: v1(97.45,108.62) 97.9,109.07 99.25,109.07 99.3,109.01 99.72,109.01 99.94,108.8 100.32,108.8 100.47,108.87 101.04,108.87 101.13,108.96 102.28,108.96 102.46,108.78 102.46,108.23 U35.AL68
  BOTTOM w0.127: JDIM1.3 83.22,50.48 83.09,50.34 82.51,50.34 82.23,50.06 v1(82.23,49.8)
M_A_DQ2: length 86
  IN1 w0.089: v1(86.47,46.03) 85.79,46.71 85.79,51.67 84.85,52.62 84.85,62.25 85.31,62.71 85.31,63.06 85.19,63.17 85,63.17 84.89,63.28 84.89,63.53 85,63.64 85.19,63.64 85.31,63.75 85.31,63.97 85.17,64.11 85,64.11 84.89,64.22 84.89,64.47 85,64.58 85.22,64.58 85.36,64.72 85.36,64.91 85.22,65.05 85.02,65.05 84.89,65.19 84.89,65.38 85.02,65.52 85.22,65.52 85.36,65.66 85.36,65.85 85.22,65.99 85,65.99 84.89,66.1 84.89,66.32 85.02,66.46 85.22,66.46 85.36,66.6 85.36,66.79 85.22,66.93 85.02,66.93 84.89,67.07 84.89,67.26 85.02,67.4 85.22,67.4 85.36,67.54 85.36,67.73 85.22,67.87 85,67.87 84.86,68.01 84.86,68.2 85,68.34 85.22,68.34 85.36,68.48 85.36,68.67 85.22,68.81 85,68.81 84.86,68.95 84.86,69.14 85,69.28 85.22,69.28 85.36,69.42 85.36,77.02 85.86,77.52 85.86,80.24 86.54,80.93 86.54,82.04 85.86,82.72 85.86,87.57 83.88,89.55 83.88,98.86 87.81,102.8 87.81,104.29 88.73,105.2 91.6,105.2 92.88,106.48 94.25,106.48 94.84,107.07 v1(95.59,107.07)
  BOTTOM w0.076: 97.98,106.4 98.22,106.17 99.86,106.17 99.86,106.17 100.86,106.17 101.07,106.39 101.63,106.39 101.93,106.68 U35.AN68
  BOTTOM w0.114: v1(95.59,107.07) 96.26,106.4 97.98,106.4
  BOTTOM w0.127: JDIM1.20 87.47,45.03 v1(86.47,46.03)
M_A_DQ3: length 84.7
  IN1 w0.089: v1(98.76,107.07) 98.76,106.72 97.94,105.9 93.16,105.9 91.85,104.59 90.53,104.59 88.45,102.51 88.45,102.39 88.63,102.21 88.63,102.01 88.49,101.87 88.3,101.87 88.15,102.02 87.96,102.02 87.82,101.88 87.82,101.69 87.97,101.54 87.97,101.35 87.83,101.21 87.63,101.21 87.49,101.35 87.29,101.35 87.16,101.22 87.16,101.02 87.3,100.88 87.3,100.68 87.16,100.54 86.97,100.54 86.81,100.71 86.61,100.71 86.47,100.57 86.47,100.37 86.64,100.21 86.64,100.02 86.5,99.88 86.3,99.88 86.11,100.07 85.92,100.07 85.78,99.93 85.78,99.74 85.97,99.55 85.97,99.35 85.83,99.21 85.64,99.21 85.45,99.41 85.25,99.41 85.11,99.27 85.11,99.07 85.31,98.88 85.31,98.69 85.17,98.55 84.97,98.55 84.79,98.73 84.67,98.73 84.46,98.52 84.46,89.88 86.45,87.89 86.45,82.96 87.13,82.28 87.13,80.26 87.04,80.17 86.69,80.17 86.56,80.04 86.56,79.84 86.69,79.7 86.99,79.7 87.13,79.57 87.13,79.37 86.99,79.24 86.69,79.24 86.56,79.1 86.56,78.9 86.69,78.77 87,78.77 87.13,78.64 87.13,78.46 87,78.34 86.71,78.34 86.56,78.19 86.56,71.89 86.79,71.66 86.79,70.19 86.64,70.04 86.35,70.04 86.21,69.9 86.21,69.71 86.35,69.57 86.79,69.57 86.92,69.43 86.92,69.23 86.8,69.1 86.09,69.1 85.94,68.95 85.94,58.26 85.85,58.17 85.58,58.17 85.45,58.03 85.45,57.84 85.58,57.7 85.8,57.7 85.94,57.56 85.94,57.37 85.8,57.23 85.58,57.23 85.45,57.09 85.45,56.9 85.58,56.76 85.79,56.76 85.94,56.61 85.94,56.02 86.07,55.89 86.43,55.89 86.57,55.75 86.57,55.56 86.43,55.42 85.58,55.42 85.45,55.28 85.45,55.09 85.58,54.95 86.59,54.95 86.74,54.8 86.74,53.74 86.52,53.52 86.52,53.2 86.74,52.98 86.74,50.23 v1(86.5,49.99)
  BOTTOM w0.076: U35.AN69 101.19,106.68 100.96,106.91 100.55,106.91 100.33,107.02 99.91,107.02 99.58,106.69 99.14,106.69 v1(98.76,107.07)
  BOTTOM w0.127: JDIM1.17 86.72,50.22 v1(86.5,49.99)
M_A_DQ4: length 84.9
  IN1 w0.089: v1(96.27,108.96) 96.13,109.1 93.21,109.1 92.55,108.44 88.93,108.44 83.39,102.9 83.39,101.15 81.92,99.67 81.92,88.74 82.71,87.96 82.71,80.54 83.36,79.89 83.36,78.88 83.27,78.79 83,78.79 82.86,78.65 82.86,78.46 83,78.32 83.27,78.32 83.36,78.23 83.36,77.94 83.27,77.85 83,77.85 82.86,77.71 82.86,77.52 83,77.38 83.27,77.38 83.36,77.29 83.36,77 83.27,76.91 83.02,76.91 82.89,76.77 82.89,76.58 83.02,76.44 83.22,76.44 83.36,76.3 83.36,76.11 83.22,75.97 83.02,75.97 82.89,75.83 82.89,75.64 83.02,75.5 83.22,75.5 83.36,75.36 83.36,75.17 83.22,75.03 83.02,75.03 82.89,74.89 82.89,74.7 83.02,74.56 83.22,74.56 83.36,74.42 83.36,74.23 83.22,74.09 83.02,74.09 82.89,73.95 82.89,73.76 83.02,73.62 83.22,73.62 83.36,73.48 83.36,73.29 83.22,73.15 82.97,73.15 82.84,73.01 82.84,72.82 82.97,72.68 83.19,72.68 83.33,72.54 83.33,72.35 83.19,72.21 82.97,72.21 82.84,72.07 82.84,71.88 82.97,71.74 83.15,71.74 83.3,71.59 83.3,71.29 83.15,71.14 82.99,71.14 82.88,71.03 82.88,66.83 81.92,65.87 81.92,62.38 80.48,60.94 80.48,58.31 81.97,56.82 81.97,52.6 82.82,51.75 82.82,50.89 83.11,50.6 83.43,50.6 83.68,50.36 v1(83.68,49.74)
  BOTTOM w0.076: 98.13,108.16 98.23,108.06 99.81,108.06 100.09,108.18 100.27,108.18 100.39,108.13 100.62,108.13 U35.AL70
  BOTTOM w0.114: v1(96.27,108.96) 97.07,108.16 98.13,108.16
  BOTTOM w0.127: v1(83.68,49.74) 84.22,50.28 JDIM1.7
M_A_DQ5: length 85.1
  IN1 w0.089: v1(83.54,44.55) 83.29,44.55 83.04,44.8 83.04,48.32 81.39,49.97 81.39,56.36 79.9,57.85 79.9,64.87 81.18,66.16 81.18,101.57 88.64,109.02 92.4,109.02 93.06,109.68 97.66,109.68 v1(98.72,108.62)
  BOTTOM w0.076: v1(98.72,108.62) 99.12,108.23 99.78,108.23 100.06,108.35 100.31,108.35 100.42,108.3 100.93,108.3 101.09,108.14 101.25,108.14 U35.AL69
  BOTTOM w0.127: JDIM1.4 83.47,44.48 v1(83.54,44.55)
M_A_DQ6: length 83.9
  IN1 w0.089: v1(86.5,48.72) 86.09,49.13 86.09,51.84 85.74,52.18 85.74,54.28 85.15,54.87 85.15,55.76 85.24,55.85 85.54,55.85 85.65,55.96 85.65,56.18 85.51,56.32 85.24,56.32 85.15,56.41 85.15,58.19 85.65,58.69 85.65,69.75 86.26,70.36 86.26,70.74 86.12,70.88 85.79,70.88 85.65,71.02 85.65,71.22 85.79,71.35 86.17,71.35 86.32,71.51 86.32,71.72 86.17,71.88 85.79,71.88 85.65,72.01 85.65,72.21 85.79,72.35 86.13,72.35 86.26,72.48 86.26,72.68 86.13,72.82 85.79,72.82 85.65,72.95 85.65,73.15 85.79,73.29 86.13,73.29 86.26,73.42 86.26,73.62 86.13,73.76 85.79,73.76 85.65,73.89 85.65,74.09 85.79,74.23 86.13,74.23 86.26,74.36 86.26,74.56 86.13,74.7 85.79,74.7 85.65,74.83 85.65,75.03 85.79,75.17 86.13,75.17 86.26,75.3 86.26,75.5 86.13,75.64 85.79,75.64 85.65,75.77 85.65,75.97 85.79,76.11 86.13,76.11 86.26,76.24 86.26,76.44 86.13,76.58 85.79,76.58 85.65,76.71 85.65,76.91 85.79,77.05 86.18,77.05 86.26,77.13 86.26,80.24 86.84,80.81 86.84,82.16 86.16,82.84 86.16,87.77 84.17,89.76 84.17,98.74 90.33,104.89 91.72,104.89 93.02,106.19 95.31,106.19 95.56,106.45 97.97,106.45 98.13,106.6 v1(98.13,107.07)
  BOTTOM w0.076: U35.AN70 100.68,106.74 100.54,106.74 100.29,106.85 99.99,106.85 99.64,106.5 98.7,106.5 v1(98.13,107.07)
  BOTTOM w0.127: v1(86.5,48.72) 86.98,48.72 87.72,49.46 JDIM1.21
M_A_DQ7: length 82.9
  IN1 w0.089: v1(86.47,44.76) 85.5,45.73 85.5,51.51 84.56,52.45 84.56,69.25 85.06,69.76 85.06,77.14 85.57,77.65 85.57,80.36 85.95,80.75 85.95,81.34 84.89,82.41 84.89,85.87 85.57,86.54 85.57,87.45 83.58,89.43 83.58,98.98 85.69,101.09 85.69,101.28 85.41,101.56 85.41,101.76 85.55,101.9 85.75,101.9 86.03,101.62 86.22,101.62 86.36,101.75 86.36,101.95 86.02,102.29 86.02,102.49 86.15,102.63 86.35,102.63 86.69,102.28 86.89,102.28 87.05,102.45 87.05,102.59 86.78,102.86 86.78,103.76 88.58,105.56 91.52,105.56 92.74,106.78 94.11,106.78 94.93,107.59 96.35,107.59 96.86,107.08 v1(96.86,107.07)
  BOTTOM w0.076: U35.AN71 99.97,106.58 99.72,106.33 98.43,106.33 98.24,106.53
  BOTTOM w0.114: v1(96.86,107.07) 97.28,106.65 98.12,106.65 98.24,106.53
  BOTTOM w0.127: v1(86.47,44.76) JDIM1.16
M_A_DQ8: length 78.4
  IN1 w0.089: v1(88.51,48.82) 87.92,49.41 87.92,68.32 88.41,68.81 88.41,72.03 88.2,72.25 87.88,72.25 87.74,72.38 87.74,72.58 87.88,72.72 88.27,72.72 88.41,72.85 88.41,73.05 88.27,73.19 87.88,73.19 87.74,73.32 87.74,73.52 87.88,73.66 88.27,73.66 88.41,73.79 88.41,73.99 88.27,74.13 87.88,74.13 87.74,74.26 87.74,74.46 87.88,74.6 88.27,74.6 88.41,74.73 88.41,74.93 88.27,75.07 87.88,75.07 87.74,75.2 87.74,75.4 87.88,75.54 88.27,75.54 88.41,75.67 88.41,75.87 88.27,76 87.88,76 87.74,76.14 87.74,76.34 87.88,76.47 88.27,76.47 88.41,76.61 88.41,76.81 88.27,76.94 87.88,76.94 87.74,77.08 87.74,77.28 87.88,77.41 88.32,77.41 88.41,77.5 88.41,77.8 88.31,77.9 88.31,87.7 85.64,90.37 85.64,97.35 91.22,102.93 92.59,102.93 93.85,104.19 94.17,104.19 v1(94.89,104.9)
  BOTTOM w0.076: 97.63,105.83 100.56,105.83 U35.AR70
  BOTTOM w0.114: 97.63,105.83 95.81,105.83 v1(94.89,104.9)
  BOTTOM w0.127: v1(88.51,48.82) 88.87,48.82 89.72,49.68 JDIM1.29
M_A_DQ9: length 79.1
  IN1 w0.089: v1(96.79,104.93) 96.79,104.93 96.41,105.3 93.43,105.3 92.64,104.52 92.64,104.1 92.19,103.65 91.11,103.65 85.06,97.6 85.06,90.13 87.05,88.14 87.05,83.2 87.72,82.53 87.72,78.09 87.15,77.52 87.15,72.14 87.39,71.91 87.39,70.76 87.78,70.36 87.78,69 86.54,67.76 86.54,56.63 87.33,55.83 87.33,46.88 87.69,46.53 87.69,44.48 87.85,44.32 88.2,44.32 v1(88.47,44.6)
  BOTTOM w0.076: U35.AR68 101.98,105.45 101.69,105.16 100.07,105.16 99.88,105.35 97.2,105.35 96.79,104.93 v1(96.79,104.93)
  BOTTOM w0.127: v1(88.47,44.6) JDIM1.24
M_A_DQ10: length 76.5
  IN1 w0.089: v1(96.37,103.13) 96.37,102.96 95.9,102.48 94.5,102.48 93.2,101.19 91.83,101.19 87.31,96.66 87.31,91.06 89.97,88.39 89.97,79.52 90.75,78.75 90.75,78.44 90.66,78.35 90.49,78.35 90.35,78.22 90.35,78.02 90.49,77.88 90.61,77.88 90.75,77.75 90.75,77.53 90.63,77.41 90.49,77.41 90.35,77.28 90.35,77.08 90.49,76.94 90.61,76.94 90.75,76.81 90.75,76.61 90.61,76.47 90.49,76.47 90.35,76.34 90.35,76.14 90.49,76 90.66,76 90.75,75.92 90.75,70.69 90.84,70.6 91.1,70.6 91.24,70.47 91.24,70.27 91.1,70.13 90.87,70.13 90.73,70 90.73,69.8 90.87,69.66 91.13,69.66 91.24,69.55 91.24,69.33 90.75,68.84 90.75,68.36 90.1,67.71 90.1,64.78 90.59,64.28 90.59,63.98 90.68,63.89 90.98,63.89 91.12,63.75 91.12,63.56 90.98,63.42 90.68,63.42 90.59,63.33 90.59,55.22 90.3,54.93 90.3,48.23 91.97,46.56 v1(91.97,45.87)
  BOTTOM w0.076: 98.14,103.79 98.55,103.79 98.92,104.17 100.12,104.17 U35.AU71
  BOTTOM w0.114: v1(96.37,103.13) 96.37,103.15 97.01,103.79 98.14,103.79
  BOTTOM w0.127: v1(91.97,45.87) 92.39,45.87 92.97,45.28 JDIM1.42
M_A_DQ11: length 78.1
  IN1 w0.089: v1(91.97,44.6) 92.53,44.6 92.68,44.75 92.68,46.31 91.72,47.27 91.72,51.93 92.11,52.33 92.11,80.86 91.98,81 91.76,81 91.62,81.14 91.62,81.33 91.76,81.47 92,81.47 92.11,81.58 92.11,81.83 92,81.94 91.76,81.94 91.62,82.08 91.62,82.27 91.76,82.41 92,82.41 92.11,82.52 92.11,82.77 92,82.88 91.76,82.88 91.62,83.02 91.62,83.21 91.76,83.35 92,83.35 92.11,83.46 92.11,83.71 92,83.82 91.76,83.82 91.62,83.96 91.62,84.15 91.76,84.29 92,84.29 92.11,84.4 92.11,84.65 92,84.76 91.76,84.76 91.62,84.9 91.62,85.09 91.76,85.23 91.98,85.23 92.11,85.37 92.11,85.56 91.98,85.7 91.76,85.7 91.62,85.84 91.62,86.03 91.76,86.17 91.98,86.17 92.11,86.31 92.11,86.5 91.98,86.64 91.76,86.64 91.62,86.78 91.62,86.97 91.76,87.11 92.03,87.11 92.11,87.2 92.11,87.49 88.18,91.42 88.18,96.3 92.18,100.3 93.55,100.3 94.79,101.53 96.21,101.53 96.58,101.91 97.91,101.91 v1(98.35,102.35)
  BOTTOM w0.076: 100.3,103.2 100.34,103.15 100.94,103.15 101.19,103.4 101.19,103.63 101.38,103.82 101.62,103.82 102.06,104.25 U35.AU68
  BOTTOM w0.114: 100.3,103.2 99.81,103.2 99.25,102.64 98.64,102.64 v1(98.35,102.35)
  BOTTOM w0.127: v1(91.97,44.6) JDIM1.38
M_A_DQ12: length 76.7
  IN1 w0.089: v1(96.16,104.9) 95.41,104.16 94.93,104.16 94.65,103.88 93.96,103.88 92.71,102.64 91.34,102.64 85.93,97.23 85.93,90.49 88.6,87.82 88.6,78.03 88.7,77.93 88.7,68.42 88.62,68.33 88.37,68.33 88.21,68.17 88.21,67.97 88.32,67.86 88.62,67.86 88.7,67.77 88.7,67.48 88.62,67.39 88.35,67.39 88.21,67.25 88.21,67.06 88.35,66.92 88.59,66.92 88.7,66.81 88.7,66.56 88.59,66.45 88.35,66.45 88.21,66.31 88.21,66.12 88.35,65.98 88.59,65.98 88.7,65.87 88.7,65.6 88.62,65.51 88.35,65.51 88.21,65.37 88.21,65.15 88.32,65.04 88.59,65.04 88.7,64.93 88.7,64.68 88.59,64.57 88.32,64.57 88.21,64.46 88.21,64.21 88.32,64.1 88.59,64.1 88.7,63.99 88.7,63.74 88.59,63.63 88.32,63.63 88.21,63.52 88.21,63.27 88.32,63.16 88.55,63.16 88.7,63.01 88.7,62.83 88.58,62.71 88.35,62.71 88.21,62.57 88.21,60 88.3,59.91 88.49,59.91 88.63,59.77 88.63,59.58 88.49,59.44 88.35,59.44 88.21,59.3 88.21,59.11 88.35,58.97 88.57,58.97 88.7,58.83 88.7,58.64 88.57,58.5 88.3,58.5 88.21,58.41 88.21,55.59 88.3,55.51 88.57,55.51 88.7,55.37 88.7,55.17 88.57,55.04 88.35,55.04 88.21,54.9 88.21,54.7 88.35,54.57 88.57,54.57 88.7,54.43 88.7,54.23 88.57,54.1 88.35,54.1 88.21,53.96 88.21,53.76 88.35,53.63 88.57,53.63 88.7,53.49 88.7,53.29 88.57,53.16 88.3,53.16 88.21,53.07 88.21,52.32 88.3,52.23 88.57,52.23 88.7,52.09 88.7,51.9 88.57,51.76 88.35,51.76 88.21,51.62 88.21,51.43 88.35,51.29 88.57,51.29 88.7,51.15 88.7,50.95 88.58,50.82 88.36,50.82 88.21,50.67 88.21,50.39 v1(88.51,50.09)
  BOTTOM w0.076: v1(96.16,104.9) 96.81,105.55 U35.AR71
  BOTTOM w0.127: JDIM1.25 88.72,50.31 v1(88.51,50.09)
M_A_DQ13: length 78.5
  IN1 w0.089: v1(88.47,45.87) 88.47,46.48 88.24,46.71 88.24,46.95 88.47,47.19 88.47,47.49 88.32,47.64 87.74,47.64 87.63,47.76 87.63,48.03 87.75,48.15 87.9,48.15 88.02,48.27 88.02,48.9 87.63,49.29 87.63,68.44 88.12,68.93 88.12,70.79 87.98,70.92 87.82,70.92 87.68,71.06 87.68,71.26 87.82,71.39 87.99,71.39 88.12,71.52 88.12,71.76 87.98,71.9 87.81,71.9 87.45,72.26 87.45,77.4 88.02,77.97 88.02,87.58 85.35,90.25 85.35,97.47 91.1,103.22 92.33,103.22 93.6,104.49 93.84,104.49 v1(94.25,104.9)
  BOTTOM w0.076: U35.AR69 101.37,105.45 100.83,105.99 97.86,105.99 97.76,106.09
  BOTTOM w0.114: v1(94.25,104.9) 95.44,106.09 97.76,106.09
  BOTTOM w0.127: v1(88.47,45.87) 89.47,44.87 JDIM1.28
M_A_DQ14: length 76.8
  IN1 w0.089: v1(91.01,49.47) 90.6,49.88 90.6,53.58 90.89,53.87 90.89,62.69 91.53,63.33 91.53,70.8 91.04,71.3 91.04,79.25 90.93,79.37 90.54,79.37 90.4,79.5 90.4,79.7 90.54,79.84 90.99,79.84 91.1,79.95 91.1,80.19 90.99,80.31 90.54,80.31 90.4,80.44 90.4,80.64 90.54,80.78 90.93,80.78 91.04,80.89 91.04,81.13 90.93,81.25 90.54,81.25 90.4,81.38 90.4,81.58 90.54,81.72 90.93,81.72 91.04,81.83 91.04,82.07 90.93,82.19 90.54,82.19 90.4,82.32 90.4,82.52 90.54,82.66 90.93,82.66 91.04,82.77 91.04,83.01 90.93,83.13 90.54,83.13 90.4,83.26 90.4,83.46 90.54,83.6 90.9,83.6 91.04,83.73 91.04,83.93 90.9,84.07 90.54,84.07 90.4,84.2 90.4,84.4 90.54,84.54 90.93,84.54 91.04,84.65 91.04,84.87 90.9,85.01 90.54,85.01 90.4,85.14 90.4,85.34 90.54,85.48 90.9,85.48 91.04,85.61 91.04,85.81 90.9,85.95 90.54,85.95 90.4,86.08 90.4,86.28 90.54,86.42 90.85,86.42 90.99,86.55 90.99,86.75 90.85,86.89 90.54,86.89 90.4,87.02 90.4,87.22 90.54,87.36 90.95,87.36 91.04,87.44 91.04,87.74 87.6,91.18 87.6,96.54 91.95,100.9 93.32,100.9 94.56,102.13 95.96,102.13 96.96,103.13 v1(97.01,103.13)
  BOTTOM w0.089: 97.73,103.57 98.59,103.57 98.98,103.95 100.56,103.95 U35.AU70
  BOTTOM w0.114: 97.73,103.57 97.52,103.57 97.08,103.13 v1(97.01,103.13)
  BOTTOM w0.127: v1(91.01,49.47) 91.29,49.47 91.72,49.9 JDIM1.37
M_A_DQ15: length 77.4
  IN1 w0.089: v1(91.01,48.2) 91.42,48.61 91.42,52.27 91.82,52.67 91.82,54.87 91.18,55.51 91.18,62.57 91.82,63.21 91.82,71.08 91.68,71.22 91.53,71.22 91.4,71.35 91.4,71.55 91.53,71.69 91.71,71.69 91.82,71.8 91.82,72.04 91.71,72.16 91.53,72.16 91.4,72.29 91.4,72.49 91.53,72.62 91.71,72.62 91.82,72.74 91.82,72.98 91.71,73.09 91.53,73.09 91.4,73.23 91.4,73.43 91.53,73.56 91.71,73.56 91.82,73.68 91.82,73.92 91.71,74.03 91.53,74.03 91.4,74.17 91.4,74.37 91.53,74.5 91.68,74.5 91.82,74.64 91.82,74.84 91.68,74.97 91.53,74.97 91.4,75.11 91.4,75.31 91.53,75.44 91.68,75.44 91.82,75.58 91.82,75.78 91.68,75.91 91.53,75.91 91.4,76.05 91.4,76.25 91.53,76.38 91.68,76.38 91.82,76.52 91.82,76.72 91.68,76.85 91.53,76.85 91.4,76.99 91.4,77.19 91.53,77.32 91.68,77.32 91.82,77.46 91.82,77.66 91.68,77.79 91.53,77.79 91.4,77.93 91.4,78.13 91.53,78.26 91.68,78.26 91.82,78.4 91.82,78.6 91.68,78.73 91.53,78.73 91.4,78.87 91.4,79.07 91.53,79.2 91.68,79.2 91.82,79.34 91.82,79.54 91.68,79.67 91.53,79.67 91.4,79.81 91.4,80.01 91.53,80.14 91.73,80.14 91.82,80.23 91.82,80.52 91.33,81.01 91.33,87.86 87.89,91.3 87.89,96.42 92.07,100.6 93.45,100.6 94.67,101.83 96.07,101.83 96.77,102.52 97.25,102.52 97.45,102.72 98.09,102.72 v1(98.5,103.13)
  BOTTOM w0.076: U35.AU69 101.1,103.85 100.72,103.85 100.64,103.77 99.13,103.77 98.5,103.14 v1(98.5,103.13)
  BOTTOM w0.127: JDIM1.41 92.72,49.11 91.81,48.2 v1(91.01,48.2)
M_A_DQ16: length 73.2
  IN1 w0.089: v1(93.22,48.21) 93.66,48.64 93.66,49.21 94.04,49.59 94.04,51.98 93.59,52.43 93.59,67.81 94.12,68.35 94.12,73 95,73.88 95,86.68 89.66,92.03 89.66,95.69 92.59,98.62 97.27,98.62 98.59,97.3 v1(99.37,97.3)
  BOTTOM w0.076: 100.18,98.8 100.59,99.2 102.67,99.2 103.84,100.37 103.84,100.98 U35.BB65
  BOTTOM w0.102: 100.18,98.8 99.79,98.41 99.79,97.72 v1(99.37,97.3)
  BOTTOM w0.127: JDIM1.49 94.72,49.41 93.53,48.21 v1(93.22,48.21)
M_A_DQ17: length 74.6
  IN1 w0.089: v1(93.97,44.6) 93.64,44.27 93.4,44.27 93.27,44.39 93.27,46.58 92.46,47.39 92.46,51.79 92.71,52.03 92.71,87.74 88.78,91.67 88.78,96.05 92.42,99.69 99.13,99.69 v1(99.5,100.06)
  BOTTOM w0.076: U35.AW65 103.94,102.96 103.65,102.67 103.65,102.49 103.55,102.39 103.55,101.96 103.49,101.85 103.38,101.73 103.09,101.73 102.76,101.4 102.48,101.4 102.31,101.22 102.31,101.02 102,100.72 100.16,100.72 v1(99.5,100.06)
  BOTTOM w0.127: v1(93.97,44.6) JDIM1.46
M_A_DQ18: length 75.8
  IN1 w0.089: v1(96.7,44.6) 96.07,45.23 96.07,47.26 96.42,47.61 96.42,50.95 96.16,51.21 96.16,59.65 95.94,59.87 95.94,65.46 96.67,66.18 96.67,66.58 96.58,66.67 96.21,66.67 96.07,66.81 96.07,67 96.21,67.14 96.53,67.14 96.67,67.27 96.67,67.47 96.53,67.61 96.21,67.61 96.07,67.74 96.07,67.94 96.21,68.08 96.55,68.08 96.67,68.19 96.67,68.43 96.55,68.55 96.21,68.55 96.07,68.68 96.07,68.88 96.21,69.02 96.53,69.02 96.67,69.15 96.67,69.35 96.53,69.49 96.21,69.49 96.07,69.62 96.07,69.82 96.21,69.96 96.55,69.96 96.67,70.07 96.67,70.31 96.55,70.43 96.21,70.43 96.07,70.56 96.07,70.76 96.21,70.9 96.55,70.9 96.67,71.01 96.67,71.25 96.55,71.37 96.21,71.37 96.07,71.5 96.07,71.7 96.21,71.84 96.58,71.84 96.67,71.93 96.67,73.31 97.94,74.58 97.94,75.86 98.02,75.95 98.34,75.95 98.48,76.09 98.48,76.28 98.34,76.42 98.11,76.42 97.97,76.56 97.97,76.75 98.11,76.89 98.45,76.89 98.58,77.03 98.58,77.22 98.45,77.36 98.11,77.36 97.97,77.5 97.97,77.69 98.11,77.83 98.45,77.83 98.58,77.97 98.58,78.16 98.45,78.3 98.11,78.3 97.97,78.43 97.97,78.63 98.11,78.77 98.45,78.77 98.58,78.9 98.58,79.1 98.45,79.24 98.11,79.24 97.97,79.37 97.97,79.57 98.11,79.71 98.45,79.71 98.58,79.84 98.58,80.04 98.45,80.18 98.02,80.18 97.94,80.27 97.94,90.94 99.27,92.27 99.27,94.08 99.78,94.58 99.78,97.33 100.62,98.17 v1(100.64,98.17)
  BOTTOM w0.076: U35.AW63 104.88,102.74 104.88,102.27 104.99,102.15 104.99,101.68 105.06,101.45 105.06,101.31 105,101.19 105,100.93 105.18,100.75 105.18,100.39 104.76,99.97 104.2,99.97 102.91,98.68 102.02,98.68 101.51,98.17 v1(100.64,98.17)
  BOTTOM w0.127: JDIM1.58 96.97,44.33 v1(96.7,44.6)
M_A_DQ19: length 75.1
  IN1 w0.089: v1(97.43,49.99) 97.43,51.18 97.06,51.55 97.06,58.92 97.61,59.48 97.61,60.11 97.7,60.2 98.07,60.2 98.21,60.34 98.21,60.53 98.07,60.67 97.71,60.67 97.58,60.81 97.58,61 97.71,61.14 98.07,61.14 98.21,61.28 98.21,61.47 98.07,61.61 97.71,61.61 97.58,61.75 97.58,61.94 97.71,62.08 98.07,62.08 98.21,62.22 98.21,62.41 98.07,62.55 97.71,62.55 97.58,62.69 97.58,62.88 97.71,63.02 98.07,63.02 98.21,63.16 98.21,63.35 98.07,63.49 97.71,63.49 97.58,63.63 97.58,63.82 97.71,63.96 98.07,63.96 98.21,64.1 98.21,64.29 98.07,64.43 97.7,64.43 97.61,64.52 97.61,65.17 98.21,65.77 98.21,73.62 100.3,75.71 100.3,81.05 100.16,81.19 99.61,81.19 99.5,81.3 99.5,81.55 99.61,81.66 100.19,81.66 100.3,81.77 100.3,82.02 100.19,82.13 99.61,82.13 99.5,82.24 99.5,82.49 99.61,82.6 100.19,82.6 100.3,82.71 100.3,82.96 100.19,83.07 99.61,83.07 99.5,83.18 99.5,83.43 99.61,83.54 100.19,83.54 100.3,83.65 100.3,83.87 100.16,84.01 99.61,84.01 99.5,84.12 99.5,84.37 99.61,84.48 100.16,84.48 100.3,84.62 100.3,84.81 100.16,84.95 99.61,84.95 99.5,85.06 99.5,85.31 99.61,85.42 100.16,85.42 100.3,85.56 100.3,85.75 100.16,85.89 99.61,85.89 99.5,86 99.5,86.25 99.61,86.36 100.16,86.36 100.3,86.5 100.3,86.69 100.16,86.83 99.61,86.83 99.5,86.94 99.5,87.19 99.61,87.3 100.16,87.3 100.3,87.44 100.3,87.63 100.16,87.77 99.61,87.77 99.5,87.88 99.5,88.13 99.61,88.24 100.16,88.24 100.3,88.38 100.3,88.57 100.16,88.71 99.61,88.71 99.5,88.82 99.5,89.07 99.61,89.18 100.21,89.18 100.3,89.27 100.3,93.81 100.64,94.15 v1(100.64,94.36)
  BOTTOM w0.076: U35.AY63 105.48,102.08 105.48,101.96 105.7,101.74 105.7,100.21 104.65,99.16 104.45,99.16
  BOTTOM w0.102: 104.45,99.16 104.2,99.16 103.18,98.14 102.55,98.14 101.91,97.51 101.91,95.63 v1(100.64,94.36)
  BOTTOM w0.127: JDIM1.59 97.22,50.19 v1(97.43,49.99)
M_A_DQ20: length 74
  IN1 w0.089: v1(98.1,98.83) 97.85,99.08 92.63,99.08 89.36,95.81 89.36,91.91 94.71,86.56 94.71,78.62 94.57,78.48 94,78.48 93.86,78.34 93.86,78.15 94,78.01 94.57,78.01 94.71,77.87 94.71,77.68 94.57,77.54 94,77.54 93.86,77.4 93.86,77.21 94,77.07 94.57,77.07 94.71,76.93 94.71,76.74 94.57,76.6 93.97,76.6 93.86,76.49 93.86,76.24 93.97,76.13 94.57,76.13 94.71,75.99 94.71,74.1 93.83,73.22 93.83,68.47 93.3,67.93 93.3,50.83 93.66,50.47 93.66,49.94 93.19,49.48 93.22,49.48 v1(93.22,49.48)
  BOTTOM w0.076: v1(98.1,98.83) 98.56,98.37 99.5,98.37 100.5,99.37 102.59,99.37 103.66,100.44 103.66,101.14 103.71,101.27 103.71,101.28 103.94,101.51 U35.BA65
  BOTTOM w0.127: JDIM1.45 93.72,49.98 v1(93.22,49.48)
M_A_DQ21: length 74.2
  IN1 w0.089: v1(93.97,45.87) 93.97,46.44 92.77,47.64 92.77,50.57 93,50.8 93,87.86 89.07,91.79 89.07,95.93 92.52,99.38 98.81,99.38 v1(99.37,98.83)
  BOTTOM w0.076: U35.AY65 103.71,102.16 103.71,101.92 103.66,101.79 103.66,101.46 103.55,101.35 103.55,101.3 103.49,101.2 103.49,101.01 103.46,100.97
  BOTTOM w0.102: 103.46,100.97 103.46,100.49 102.52,99.55 100.09,99.55 v1(99.37,98.83)
  BOTTOM w0.127: v1(93.97,45.87) 94.97,44.87 JDIM1.50
M_A_DQ22: length 74.6
  IN1 w0.089: v1(100.64,95.63) 100.23,95.22 100.23,94.17 99.97,93.91 99.97,92.11 99.18,91.32 99.18,81.21 100.01,80.38 100.01,80.06 99.92,79.97 99.31,79.97 99.17,79.83 99.17,79.64 99.31,79.5 99.87,79.5 100.01,79.36 100.01,79.17 99.87,79.03 99.31,79.03 99.17,78.89 99.17,78.7 99.31,78.56 99.87,78.56 100.01,78.42 100.01,78.23 99.87,78.09 99.31,78.09 99.17,77.95 99.17,77.76 99.31,77.62 99.87,77.62 100.01,77.48 100.01,77.29 99.87,77.15 99.31,77.15 99.17,77.01 99.17,76.82 99.31,76.68 99.82,76.68 100.01,76.49 100.01,75.83 97.92,73.74 97.92,71.57 97.83,71.48 97.48,71.48 97.34,71.35 97.34,71.15 97.48,71.01 97.78,71.01 97.92,70.88 97.92,70.68 97.78,70.54 97.48,70.54 97.34,70.41 97.34,70.21 97.48,70.07 97.78,70.07 97.92,69.94 97.92,69.74 97.78,69.6 97.48,69.6 97.34,69.47 97.34,69.27 97.48,69.13 97.78,69.13 97.92,69 97.92,68.8 97.78,68.66 97.48,68.66 97.34,68.53 97.34,68.33 97.48,68.19 97.78,68.19 97.92,68.06 97.92,67.86 97.78,67.72 97.48,67.72 97.34,67.59 97.34,67.39 97.48,67.25 97.78,67.25 97.92,67.12 97.92,66.92 97.78,66.78 97.48,66.78 97.34,66.65 97.34,66.45 97.48,66.31 97.83,66.31 97.92,66.23 97.92,65.89 97.28,65.25 97.28,64.38 97.2,64.29 96.69,64.29 96.55,64.16 96.55,63.96 96.69,63.82 97.15,63.82 97.28,63.69 97.28,63.49 97.15,63.35 96.69,63.35 96.55,63.22 96.55,63.02 96.69,62.88 97.2,62.88 97.28,62.79 97.28,59.78 96.74,59.24 96.74,51.45 97.03,51.17 97.03,49.12 v1(97.43,48.72)
  BOTTOM w0.076: U35.BA63 105.27,101.52 105.53,101.26 105.53,100.28 104.59,99.34 104.12,99.34 103.11,98.32 102.48,98.32 101.53,97.38 101.53,96.52 v1(100.64,95.63)
  BOTTOM w0.127: v1(97.43,48.72) 97.78,48.72 98.46,49.4 98.46,50.18 98.22,50.42 JDIM1.63
M_A_DQ23: length 73.5
  IN1 w0.089: v1(100.64,96.9) 100.24,96.9 100.13,96.79 100.13,95.57 100.01,95.45 100.01,94.39 99.57,93.95 99.57,92.15 98.88,91.45 98.88,89.01 98.79,88.93 98.37,88.93 98.23,88.79 98.23,88.59 98.37,88.46 98.75,88.46 98.89,88.32 98.89,88.12 98.75,87.99 98.37,87.99 98.23,87.85 98.23,87.65 98.37,87.52 98.75,87.52 98.89,87.38 98.89,87.18 98.75,87.05 98.37,87.05 98.23,86.91 98.23,86.71 98.37,86.58 98.75,86.58 98.89,86.44 98.89,86.24 98.75,86.11 98.37,86.11 98.23,85.97 98.23,85.77 98.37,85.64 98.75,85.64 98.89,85.5 98.89,85.3 98.75,85.17 98.37,85.17 98.23,85.03 98.23,84.83 98.37,84.7 98.75,84.7 98.89,84.56 98.89,84.36 98.75,84.23 98.37,84.23 98.23,84.09 98.23,83.89 98.37,83.76 98.75,83.76 98.89,83.62 98.89,83.42 98.75,83.29 98.37,83.29 98.23,83.15 98.23,82.95 98.37,82.82 98.72,82.82 98.86,82.68 98.86,82.46 98.75,82.35 98.37,82.35 98.23,82.21 98.23,82.01 98.37,81.88 98.78,81.88 98.89,81.76 98.89,81.52 98.78,81.41 98.37,81.41 98.23,81.27 98.23,81.08 98.88,80.43 98.88,75.11 96.96,73.19 96.96,72.85 97.05,72.76 97.45,72.76 97.59,72.62 97.59,72.4 97.48,72.29 97.05,72.29 96.96,72.2 96.96,66.06 96.26,65.36 96.26,59.96 96.45,59.77 96.45,51.33 96.71,51.08 96.71,45.87 v1(96.7,45.87)
  BOTTOM w0.076: U35.BB63 105.35,101.01 105.35,100.33 104.82,99.8 104.29,99.8 103,98.52 102.25,98.52 v1(100.64,96.9)
  BOTTOM w0.127: v1(96.7,45.87) 97.21,45.87 97.97,45.1 JDIM1.62
M_A_DQ24: length 64.9
  IN1 w0.089: v1(102.72,96.47) 101.66,95.41 101.66,93.78 101.21,93.33 101.21,75.36 100.21,74.36 100.21,73.65 100.12,73.56 99.41,73.56 99.27,73.42 99.27,73.23 99.41,73.09 100.07,73.09 100.21,72.95 100.21,72.76 100.07,72.62 99.41,72.62 99.27,72.48 99.27,72.29 99.41,72.15 100.06,72.15 100.21,72 100.21,71.62 100.06,71.47 99.49,71.47 99.24,71.21 99.24,53.59 99.15,53.5 98.45,53.5 98.31,53.36 98.31,53.17 98.45,53.03 99.15,53.03 99.27,52.92 99.27,52.67 99.15,52.56 98.45,52.56 98.31,52.42 98.31,52.23 98.45,52.09 99.15,52.09 99.24,52 99.24,51.36 99.5,51.1 99.5,49.6 99.38,49.48 v1(98.9,49.48)
  BOTTOM w0.076: U35.BA61 106.3,101.51 106.03,101.25 106.03,100.02 105.98,99.97
  BOTTOM w0.102: v1(102.72,96.47) 103.18,96.93 103.18,97.55 104.27,98.64 104.64,98.64 105.98,99.97
  BOTTOM w0.127: v1(98.9,49.48) 99.4,49.97 99.4,50.29 99.22,50.46 JDIM1.67
M_A_DQ25: length 66.3
  IN1 w0.089: v1(99.09,45.64) 98.73,45.64 98.23,46.15 98.23,51.2 98.02,51.41 98.02,55.16 98.16,55.3 98.77,55.3 98.91,55.44 98.91,55.64 98.77,55.77 98.17,55.77 98.02,55.93 98.02,58.42 98.81,59.2 98.81,73.37 100.89,75.46 100.89,93.44 101.28,93.82 101.28,96.3 v1(102.72,97.74)
  BOTTOM w0.076: 105.71,99.98 105.86,100.13 105.86,101.77 106.07,101.98 106.07,102.52 106.4,102.85 U35.AW61
  BOTTOM w0.102: v1(102.72,97.74) 103.1,97.74 104.19,98.83 104.56,98.83 105.71,99.98
  BOTTOM w0.127: v1(99.09,45.64) 98.86,45.64 98.62,45.4 98.62,44.6 98.97,44.24 JDIM1.66
M_A_DQ26: length 65.2
  IN1 w0.089: v1(102.97,47.35) 103.92,47.35 104.07,47.5 104.07,47.87 103.92,48.03 103.05,48.03 102.7,48.38 102.7,50.19 102.17,50.72 102.17,65.25 103.47,66.56 103.47,69.82 103.29,69.99 103.14,69.99 103,70.13 103,70.33 103.14,70.46 103.34,70.46 103.47,70.6 103.47,70.8 103.34,70.93 103.14,70.93 103,71.07 103,71.27 103.14,71.4 103.34,71.4 103.47,71.54 103.47,71.74 103.34,71.87 103.14,71.87 103,72.01 103,72.21 103.14,72.34 103.34,72.34 103.47,72.48 103.47,72.67 103.34,72.81 103.14,72.81 103,72.95 103,73.14 103.14,73.28 103.38,73.28 103.47,73.37 103.47,92.83 104.24,93.6 104.24,93.88 v1(104.65,94.28)
  BOTTOM w0.076: U35.BB59 107.66,101.05 107.66,100.21 107.12,99.67 107.12,99.59
  BOTTOM w0.102: v1(104.65,94.28) 105.72,95.35 105.72,98.13 107.12,99.54 107.12,99.59
  BOTTOM w0.127: JDIM1.84 103.47,46.86 102.98,47.35 v1(102.97,47.35)
M_A_DQ27: length 67.4
  IN1 w0.089: v1(104.65,94.92) 103.94,94.21 103.94,93.65 103.18,92.89 103.18,74.36 102.71,73.89 102.71,73.28 102.62,73.19 102.3,73.19 102.16,73.05 102.16,72.86 102.3,72.72 102.64,72.72 102.78,72.58 102.78,72.39 102.64,72.25 102.3,72.25 102.16,72.11 102.16,71.92 102.3,71.78 102.64,71.78 102.78,71.65 102.78,71.45 102.64,71.31 102.3,71.31 102.16,71.18 102.16,70.5 102.92,69.74 102.92,69.45 102.83,69.36 102.56,69.36 102.42,69.22 102.42,69.03 102.56,68.89 102.83,68.89 102.92,68.8 102.92,66.43 101.87,65.39 101.87,50.6 102.41,50.07 102.41,48.26 102.57,48.1 102.57,46.48 v1(102.97,46.08)
  BOTTOM w0.076: U35.AW59 106.97,103.04 106.77,102.83 106.77,102.32 106.69,102.22 106.69,101.97 106.74,101.84 106.74,101.61 106.73,101.6 106.73,101.6 106.73,101.6 106.69,101.51 106.69,101.31 106.73,101.22 106.73,100.86 106.53,100.66 106.53,99.68
  BOTTOM w0.102: 106.53,99.68 104.78,97.94 104.45,97.94 103.94,97.43 103.94,95.62 v1(104.65,94.92)
  BOTTOM w0.127: JDIM1.80 102.47,45.58 v1(102.97,46.08)
M_A_DQ28: length 64.6
  IN1 w0.089: v1(102.72,95.2) 102.04,94.52 102.04,93.75 101.5,93.21 101.5,75.24 100.5,74.24 100.5,71.26 100.41,71.17 99.87,71.17 99.74,71.04 99.74,70.84 99.87,70.7 100.35,70.7 100.48,70.58 100.48,70.36 100.35,70.23 99.87,70.23 99.74,70.1 99.74,69.9 99.87,69.76 100.37,69.76 100.48,69.66 100.48,69.38 100.36,69.27 99.82,69.27 99.56,69.01 99.56,51.45 99.8,51.21 99.8,47.07 99.65,46.91 v1(99.09,46.91)
  BOTTOM w0.076: U35.BB61 106.19,100.98 106.19,99.92 106.05,99.78
  BOTTOM w0.102: 106.05,99.78 104.72,98.44 104.42,98.44 103.43,97.46 103.43,95.91 v1(102.72,95.2)
  BOTTOM w0.127: JDIM1.70 99.97,46.03 v1(99.09,46.91)
M_A_DQ29: length 66
  IN1 w0.089: v1(100.22,50.12) 100.22,50.69 100.5,50.97 100.5,52.06 100.35,52.22 100,52.22 99.85,52.37 99.85,53.44 100,53.6 100.36,53.6 100.5,53.73 100.5,53.93 100.36,54.07 99.99,54.07 99.85,54.2 99.85,54.4 99.99,54.54 100.36,54.54 100.5,54.67 100.5,54.87 100.36,55.01 99.99,55.01 99.85,55.14 99.85,55.34 99.99,55.48 100.36,55.48 100.5,55.61 100.5,55.81 100.36,55.95 100.02,55.95 99.85,56.12 99.85,57.63 99.94,57.72 100.36,57.72 100.5,57.86 100.5,58.05 100.36,58.19 99.94,58.19 99.85,58.28 99.85,59.79 99.94,59.88 100.36,59.88 100.5,60.02 100.5,60.21 100.36,60.35 99.94,60.35 99.85,60.44 99.85,62.94 99.94,63.03 100.36,63.03 100.5,63.17 100.5,63.36 100.36,63.5 99.99,63.5 99.85,63.64 99.85,63.83 99.99,63.97 100.36,63.97 100.5,64.11 100.5,64.3 100.36,64.44 99.94,64.44 99.85,64.53 99.85,67.68 100.13,67.96 100.62,67.96 100.74,68.09 100.74,68.37 100.62,68.5 99.99,68.5 99.85,68.64 99.85,68.83 99.99,68.97 100.7,68.97 100.79,69.06 100.79,73.91 101.79,74.91 101.79,93 v1(102.72,93.93)
  BOTTOM w0.076: U35.AY61 106.53,102.25 106.53,101.94 106.53,101.92 106.56,101.84 106.56,101.63 106.53,101.54 106.53,101.28 106.56,101.19 106.56,100.93 106.36,100.73 106.36,99.8 106.11,99.55
  BOTTOM w0.102: v1(102.72,93.93) 103.69,94.9 103.69,97.44 104.37,98.13 104.69,98.13 106.11,99.55
  BOTTOM w0.127: JDIM1.71 v1(100.22,50.12)
M_A_DQ30: length 66
  IN1 w0.089: v1(103.1,49.91) 103.4,50.21 103.4,50.75 103.31,50.83 102.6,50.83 102.46,50.97 102.46,51.17 102.6,51.3 103.24,51.3 103.4,51.46 103.4,51.69 103.24,51.84 102.6,51.84 102.46,51.98 102.46,52.17 102.6,52.31 103.26,52.31 103.4,52.45 103.4,52.64 103.26,52.78 102.6,52.78 102.46,52.92 102.46,53.11 102.6,53.25 103.5,53.25 103.65,53.4 103.65,53.57 103.52,53.69 102.57,53.69 102.46,53.81 102.46,54.42 102.55,54.51 102.8,54.51 102.94,54.65 102.94,54.84 102.8,54.98 102.55,54.98 102.46,55.07 102.46,55.36 102.55,55.45 102.8,55.45 102.94,55.59 102.94,55.78 102.8,55.92 102.55,55.92 102.46,56.01 102.46,59.09 102.55,59.18 103,59.18 103.14,59.31 103.14,59.51 103,59.65 102.55,59.65 102.46,59.74 102.46,62.58 102.61,62.73 102.93,62.73 103.05,62.84 103.05,63.06 102.91,63.2 102.6,63.2 102.46,63.34 102.46,63.53 102.6,63.67 102.89,63.67 103.03,63.81 103.03,64 102.89,64.14 102.55,64.14 102.46,64.23 102.46,65.13 103.76,66.43 103.76,92.55 104.2,92.98 104.2,93.2 v1(104.65,93.65)
  BOTTOM w0.076: U35.BA59 107.74,101.51 107.83,101.33 107.89,101.18 107.89,100.89 107.82,100.82 107.82,100.14 107.37,99.69 107.37,99.52
  BOTTOM w0.102: v1(104.65,93.65) v1(105.43,94.43) 106.03,95.03 106.03,98.18 107.37,99.52
  BOTTOM w0.127: v1(103.1,49.91) 103.22,50.04 JDIM1.83
M_A_DQ31: length 67
  IN1 w0.089: v1(104.65,93.01) 104.06,92.42 104.06,66.31 103.49,65.74 103.49,64.33 103.57,64.24 104.02,64.24 104.16,64.1 104.16,63.91 104.02,63.77 103.57,63.77 103.49,63.68 103.49,63.39 103.57,63.3 104.02,63.3 104.16,63.16 104.16,62.97 104.02,62.83 103.57,62.83 103.49,62.74 103.49,60.3 103.57,60.21 104.02,60.21 104.16,60.08 104.16,59.88 104.02,59.74 103.57,59.74 103.43,59.61 103.43,59.41 103.57,59.27 104.02,59.27 104.16,59.14 104.16,58.94 104.02,58.8 103.57,58.8 103.49,58.72 103.49,57.37 103.94,56.92 103.94,56.4 103.83,56.28 103.32,56.28 103.18,56.14 103.18,55.95 103.32,55.81 103.83,55.81 103.97,55.67 103.97,55.48 103.83,55.34 103.32,55.34 103.18,55.2 103.18,55.01 103.32,54.87 103.85,54.87 103.94,54.78 103.94,52.6 103.69,52.34 103.69,48.79 103.54,48.64 v1(103.1,48.64)
  BOTTOM w0.076: 107.66,99.54 107.66,99.72 107.99,100.04 107.99,100.74 108.05,100.81 108.05,101.22 108.02,101.29 107.89,101.72 107.89,101.92 107.62,102.18 U35.AY59
  BOTTOM w0.102: 107.66,99.54 106.36,98.24 106.36,94.72 v1(104.65,93.01)
  BOTTOM w0.127: JDIM1.79 102.22,48.85 102.44,48.64 v1(103.1,48.64)
M_A_DQ32: length 68.4
  IN1 w0.089: v1(127.15,46.58) 126.4,46.58 126.27,46.71 126.27,47.11 126.42,47.26 127.64,47.26 127.82,47.44 127.82,48.97 128.2,49.35 128.2,51.63 129.38,52.81 129.38,54.29 130.18,55.09 130.18,62.45 128.87,63.76 128.87,67.76 127.41,69.22 127.41,69.97 125.46,71.92 124.98,71.92 123.51,73.39 123.51,74.36 120.88,77 120.88,89.55 119.38,91.05 119.38,92.86 119.37,92.86 v1(119.37,93.02)
  BOTTOM w0.076: 118.27,99.28 118.44,99.46 118.44,99.81 118.23,100.02 118.23,101.23 118.3,101.36 118.3,101.38 118.4,101.63 118.4,101.92 118.67,102.18 U35.AY39
  BOTTOM w0.102: v1(119.37,93.02) 118.67,93.72 118.67,93.99 118.04,94.63 118.04,99.05 118.27,99.28
  BOTTOM w0.127: JDIM1.170 126.97,44.22 126.67,44.52 126.67,46.1 v1(127.15,46.58)
M_A_DQ33: length 66
  IN1 w0.089: v1(127.15,48.01) 126.79,48.01 126.68,48.13 126.68,50.93 128.17,52.43 128.17,54.86 128.66,55.35 128.66,63.05 127.93,63.78 127.93,67.87 126.73,69.07 126.73,69.82 125.22,71.33 124.74,71.33 122.92,73.15 122.92,74.12 120.29,76.75 120.29,89.63 118.73,91.2 118.73,98.52 118.94,98.74 v1(119.38,98.74)
  BOTTOM w0.076: U35.AW39 119.32,103.04 119.52,102.83 119.52,102.32 119.6,102.16 119.6,101.98 119.54,101.82 119.54,101.68 119.61,101.46 119.61,101.34 119.56,101.23 119.56,100.85 119.76,100.65 119.76,100.29 119.66,100.19
  BOTTOM w0.102: v1(119.38,98.74) 119.38,99.91 119.66,100.19
  BOTTOM w0.127: JDIM1.173 127.72,50.46 127.89,50.29 127.89,48.75 v1(127.15,48.01)
M_A_DQ34: length 68.1
  IN1 w0.089: v1(119.38,98.1) 119.78,98.1 120.33,97.56 120.33,91.49 122.54,89.27 122.54,77.69 125.19,75.04 125.19,74.08 125.68,73.59 126.16,73.59 129.31,70.44 129.31,69.87 129.56,69.63 130.43,69.63 131.23,68.82 131.23,64.66 132.85,63.04 132.85,60.03 132.3,59.48 131.96,59.48 131.85,59.38 131.85,59.14 131.96,59.04 132.43,59.04 132.64,58.82 132.64,56.41 132.52,56.28 131.96,56.28 131.85,56.17 131.85,55.92 131.96,55.81 132.43,55.81 132.57,55.67 132.57,55.45 132.46,55.34 131.98,55.34 131.86,55.21 131.86,53.03 132.21,52.67 132.21,52.47 131.02,51.27 131.02,48.91 131.15,48.79 v1(131.42,48.79)
  BOTTOM w0.076: U35.AY37 119.79,102.29 119.79,102.03 119.72,101.81 119.72,101.68 119.78,101.45 119.78,101.31 119.73,101.19 119.73,100.92 119.93,100.72 119.93,99.99 119.83,99.9
  BOTTOM w0.102: 119.83,99.9 119.79,99.86 119.79,98.52 v1(119.38,98.1)
  BOTTOM w0.127: v1(131.42,48.79) 130.74,48.79 130.41,49.12 130.41,50.21 130.22,50.39 JDIM1.183
M_A_DQ35: length 68.7
  IN1 w0.089: v1(121.15,94.97) 120.73,94.97 120.52,94.75 120.52,91.59 122.83,89.27 122.83,77.81 125.88,74.76 125.88,74.64 125.53,74.29 125.53,74.2 125.77,73.96 125.87,73.96 126.18,74.27 126.4,74.27 126.56,74.11 126.56,73.89 126.48,73.81 126.48,73.68 126.69,73.47 126.81,73.47 126.91,73.57 127.1,73.57 127.24,73.43 127.24,73.24 127.15,73.14 127.15,73.02 127.35,72.81 127.48,72.81 127.57,72.9 127.77,72.9 127.91,72.77 127.91,72.57 127.81,72.48 127.81,72.35 128.02,72.14 128.14,72.14 128.24,72.24 128.43,72.24 128.57,72.1 128.57,71.91 128.48,71.81 128.48,71.69 128.68,71.48 128.81,71.48 128.9,71.57 129.1,71.57 129.24,71.44 129.24,71.24 129.14,71.15 129.14,71.02 129.35,70.81 129.5,70.81 129.58,70.9 129.79,70.9 129.98,70.71 129.98,70.5 129.69,70.2 129.69,70.03 129.8,69.92 130.07,69.92 130.18,70.03 130.44,70.03 131.55,68.92 131.55,64.75 133.79,62.52 133.79,60.66 133.24,60.11 133.24,59.7 132.96,59.42 132.96,55.68 133.28,55.36 133.28,55.19 133.1,55.01 132.24,55.01 132.15,54.92 132.15,54.59 132.21,54.53 133.2,54.53 133.33,54.4 133.33,52.52 133.1,52.29 132.46,52.29 131.42,51.25 v1(131.42,50.06)
  BOTTOM w0.076: U35.AW37 119.89,102.82 120.2,102.51 120.2,101.96 120.42,101.74 120.42,100.72 120.42,100.72 120.42,95.7 v1(121.15,94.97)
  BOTTOM w0.127: JDIM1.187 131.22,50.25 v1(131.42,50.06)
M_A_DQ36: length 66.4
  IN1 w0.089: v1(127.15,49.48) 127.75,49.48 127.91,49.64 127.91,50.32 127.68,50.54 127.45,50.54 127.37,50.63 127.37,50.93 127.45,51.01 127.68,51.01 127.77,51.1 127.77,51.61 129.06,52.9 129.06,54.15 128.71,54.5 128.71,54.76 128.96,55.01 128.96,55.53 129.05,55.61 129.3,55.61 129.38,55.7 129.38,56 129.3,56.08 129.05,56.08 128.96,56.17 128.96,56.47 129.05,56.55 129.27,56.55 129.36,56.64 129.36,56.94 129.27,57.02 129.05,57.02 128.96,57.11 128.96,57.41 129.05,57.49 129.27,57.49 129.36,57.58 129.36,57.88 129.27,57.96 129.05,57.96 128.96,58.05 128.96,58.58 129.05,58.67 129.24,58.67 129.33,58.76 129.33,59.05 129.24,59.14 129.05,59.14 128.96,59.23 128.96,59.52 129.05,59.61 129.22,59.61 129.31,59.7 129.31,59.99 129.22,60.08 129.05,60.08 128.96,60.17 128.96,60.46 129.05,60.55 129.24,60.55 129.33,60.64 129.33,60.93 129.24,61.02 129.05,61.02 128.96,61.11 128.96,61.4 129.05,61.49 129.22,61.49 129.31,61.58 129.31,61.87 129.22,61.96 129.05,61.96 128.96,62.05 128.96,63.16 128.23,63.9 128.23,64.19 128.31,64.28 128.49,64.28 128.58,64.37 128.58,64.66 128.49,64.75 128.31,64.75 128.23,64.84 128.23,65.13 128.31,65.22 128.49,65.22 128.58,65.31 128.58,65.6 128.49,65.69 128.31,65.69 128.23,65.78 128.23,66.07 128.31,66.16 128.49,66.16 128.58,66.25 128.58,66.54 128.49,66.63 128.31,66.63 128.23,66.72 128.23,67.99 127.02,69.19 127.02,69.94 125.34,71.62 124.86,71.62 123.22,73.27 123.22,74.24 120.58,76.87 120.58,89.59 118.96,91.22 118.96,94.51 v1(119.37,94.92)
  BOTTOM w0.076: U35.BB39 118.56,100.98 118.56,100.16 118.77,99.95 118.77,99.25 118.66,99.14
  BOTTOM w0.102: 118.66,99.14 118.47,98.95 118.47,95.82 v1(119.37,94.92)
  BOTTOM w0.127: v1(127.15,49.48) 126.67,49.97 126.67,50.38 126.72,50.43 JDIM1.169
M_A_DQ37: length 67.1
  IN1 w0.089: v1(119.37,94.29) 119.78,93.89 119.78,90.99 121.17,89.6 121.17,77.12 123.8,74.48 123.8,73.51 125.1,72.21 125.59,72.21 127.7,70.09 127.7,69.34 128.19,68.85 128.36,68.85 129.22,67.99 129.22,63.83 130.48,62.57 130.48,52.68 129.99,52.2 129.24,52.2 128.58,51.54 128.58,47.52 128.14,47.08 128.14,45.46 127.99,45.31 v1(127.15,45.31)
  BOTTOM w0.076: U35.BA39 118.67,101.59 118.52,101.45 118.52,101.44 118.52,101.44 118.4,101.19 118.4,100.09 118.61,99.88 118.61,99.35 118.49,99.23
  BOTTOM w0.102: v1(119.37,94.29) 118.23,95.43 118.23,98.98 118.49,99.23
  BOTTOM w0.127: v1(127.15,45.31) 127.43,45.31 127.97,44.77 JDIM1.174
M_A_DQ38: length 67.7
  IN1 w0.089: v1(129.77,44.73) 129.32,45.17 129.32,46.28 130.12,47.07 130.3,47.07 131.83,48.61 131.83,51.24 132.58,52 133.22,52 133.62,52.4 133.62,55.9 133.41,56.12 133.41,59.46 133.55,59.6 133.55,60.01 134.11,60.56 134.11,62.61 131.87,64.85 131.87,69.23 123.12,77.98 123.12,89.7 120.71,92.11 120.71,93.25 v1(121.15,93.7)
  BOTTOM w0.076: U35.BA37 119.99,101.52 120.26,101.26 120.26,100.79 120.26,100.79 120.26,94.59 v1(121.15,93.7)
  BOTTOM w0.127: v1(129.77,44.73) 129.97,44.52 JDIM1.182
M_A_DQ39: length 67.1
  IN1 w0.089: v1(129.77,46) 129.77,46.14 132.12,48.49 132.12,51.05 132.78,51.7 133.34,51.7 133.91,52.28 133.91,56.27 134.52,56.88 134.52,62.61 132.17,64.96 132.17,69.34 123.42,78.1 123.42,89.89 121.15,92.16 v1(121.15,92.43)
  BOTTOM w0.076: U35.BB37 119.99,100.89 120.09,100.79 120.09,99.84 120,99.74 120,99.57
  BOTTOM w0.102: v1(121.15,92.43) 120.88,92.43 120,93.31 120,99.57
  BOTTOM w0.127: v1(129.77,46) 130.1,46 130.74,45.36 130.74,44.34 130.97,44.11 JDIM1.186
M_A_DQ40: length 79
  IN1 w0.089: v1(121.15,96.87) 121.39,96.87 121.73,96.53 121.73,92.25 124.5,89.48 124.5,88.59 124.73,88.36 124.73,79.32 124.47,79.06 124.47,78.86 124.57,78.76 124.77,78.76 132.64,70.89 132.64,70.13 133.12,69.65 133.12,69.05 133.6,68.57 133.6,68.28 133.69,68.19 133.95,68.19 134.04,68.1 134.04,67.81 133.95,67.72 133.69,67.72 133.6,67.63 133.6,67.34 133.69,67.25 133.95,67.25 134.04,67.16 134.04,66.87 133.95,66.78 133.69,66.78 133.6,66.69 133.6,66.4 133.69,66.31 133.95,66.31 134.04,66.22 134.04,65.93 133.95,65.84 133.75,65.84 133.6,65.69 133.6,65.45 133.75,65.3 133.92,65.3 134.07,65.15 134.07,64.31 135.46,62.93 135.46,56.28 134.8,55.62 134.8,51.91 133.54,50.64 133.54,49.42 132.77,48.66 132.77,48.29 130.49,46.01 130.49,44.28 130.33,44.13 129.59,44.13 129.47,44.01 129.47,43.81 129.62,43.66 130.33,43.66 130.49,43.5 130.49,43.3 130.64,43.15 130.9,43.15 131.08,43.33 131.08,45.62 131.37,45.92 v1(131.73,45.92)
  BOTTOM w0.076: U35.AY35 121.22,102.29 121.22,102.02 121.29,101.84 121.29,101.63 121.25,101.54 121.25,101.28 121.29,101.19 121.29,100.62 121.08,100.41 121.08,99.64 121.71,99.01 121.71,97.43 v1(121.15,96.87)
  BOTTOM w0.127: JDIM1.194 132.97,44.34 132.26,45.05 132.26,45.38 v1(131.73,45.92)
M_A_DQ41: length 79.6
  IN1 w0.089: v1(132.72,50.06) 132.72,50.8 133.02,51.11 133.59,51.11 134.51,52.03 134.51,56.02 135.12,56.63 135.12,62.86 133.31,64.67 133.31,67.13 133.22,67.22 132.91,67.22 132.77,67.36 132.77,67.55 132.91,67.69 133.22,67.69 133.31,67.78 133.31,68.45 132.83,68.92 132.83,69.53 131.99,70.37 131.99,70.49 132.25,70.75 132.25,70.87 132.04,71.08 131.91,71.08 131.7,70.86 131.5,70.86 131.36,71 131.36,71.19 131.58,71.41 131.58,71.54 131.37,71.74 131.25,71.74 131,71.49 130.87,71.49 130.66,71.7 130.66,71.82 130.92,72.08 130.92,72.2 130.71,72.41 130.58,72.41 130.33,72.16 130.21,72.16 130,72.36 130,72.49 130.25,72.74 130.25,72.87 130.04,73.07 129.92,73.07 129.67,72.82 129.54,72.82 129.33,73.03 129.33,73.15 129.59,73.41 129.59,73.53 129.38,73.74 129.25,73.74 129,73.49 128.88,73.49 128.67,73.69 128.67,73.82 128.92,74.07 128.92,74.2 128.71,74.4 128.59,74.4 128.34,74.15 128.21,74.15 128,74.36 128,74.48 128.26,74.74 128.26,74.86 128.05,75.07 127.92,75.07 127.67,74.82 127.55,74.82 127.34,75.02 127.34,75.15 127.59,75.4 127.59,75.53 127.38,75.73 127.26,75.73 127.01,75.48 126.88,75.48 126.67,75.69 126.67,75.81 126.93,76.07 126.93,76.19 126.72,76.4 126.59,76.4 126.34,76.15 126.22,76.15 126.01,76.35 126.01,76.48 126.26,76.73 126.26,76.86 126.05,77.06 125.93,77.06 125.68,76.81 125.55,76.81 125.34,77.02 125.34,77.14 125.6,77.4 125.6,77.52 125.39,77.73 125.26,77.73 125.01,77.48 124.89,77.48 124.68,77.68 124.68,77.81 124.93,78.06 124.93,78.19 124.72,78.39 124.6,78.39 124.35,78.14 124.22,78.14 124.01,78.35 124.01,79.01 124.39,79.39 124.39,79.78 124.3,79.87 124.1,79.87 124.01,79.96 124.01,80.25 124.1,80.34 124.3,80.34 124.39,80.43 124.39,80.72 124.3,80.81 124.1,80.81 124.01,80.9 124.01,81.19 124.1,81.28 124.35,81.28 124.44,81.37 124.44,81.66 124.35,81.75 124.1,81.75 124.01,81.84 124.01,82.13 124.1,82.22 124.35,82.22 124.44,82.31 124.44,82.6 124.35,82.69 124.1,82.69 124.01,82.78 124.01,83.07 124.1,83.16 124.35,83.16 124.44,83.25 124.44,83.54 124.35,83.63 124.1,83.63 124.01,83.72 124.01,84.01 124.1,84.1 124.35,84.1 124.44,84.19 124.44,84.48 124.35,84.57 124.1,84.57 124.01,84.66 124.01,84.95 124.1,85.04 124.35,85.04 124.44,85.13 124.44,85.42 124.35,85.51 124.1,85.51 124.01,85.59 124.01,85.89 124.1,85.98 124.35,85.98 124.44,86.06 124.44,86.36 124.35,86.45 124.1,86.45 124.01,86.53 124.01,86.83 124.1,86.92 124.35,86.92 124.44,87 124.44,87.3 124.35,87.39 124.1,87.39 124.01,87.47 124.01,87.77 124.1,87.86 124.35,87.86 124.44,87.94 124.44,88.24 124.35,88.33 124.1,88.33 124.01,88.41 124.01,88.8 124.21,89 124.21,89.47 121.55,92.12 121.55,95.83 v1(121.15,96.24)
  BOTTOM w0.076: U35.AW35 121.12,102.85 120.8,102.52 120.8,101.98 120.59,101.77 120.59,100.65 120.59,100.65 120.59,96.8 v1(121.15,96.24)
  BOTTOM w0.127: v1(132.72,50.06) 132.97,50.06 133.22,50.31 JDIM1.195
