# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V_RTC_1: length 2.1
  TOP w0.127: R308.2 74.11,51.77 v1(74.2,51.86)
  TOP w0.635: R308.2 75.14,50.95 D7.1
+3V_RTC_2:
  vias: v1(77.32,51.28)
+3V_S5: length 635.1
  TOP w0.305: 178.36,35.31 U8.5
  TOP w0.508: R697.2 R708.2 R705.2 47.9,81.4 v1(46.92,81.4) ; R11206.1 R11208.1 R11193.1 R11203.1 R11197.1 R11194.1 29.65,103.52 v1(30.03,103.14) ; v1(152.71,86.35) 145.44,86.35 143.08,88.71 142.72,88.71 142.33,89.1 139.83,89.1 135.82,93.11 135.82,94.89 v1(134.42,96.29) ; v1(74.35,55.14) 74.86,55.65 74.86,59.96 74.35,60.47 74.35,74.67 80.32,80.64 80.32,85.24 79.94,85.62 79.94,89.05 86.16,95.27 86.16,99.56 v1(89.19,102.59) ; v1(155,106.95) 155.33,106.95 155.85,107.48 R198.2 R185.2 R186.2 R179.2 155.85,112.7 154.14,114.41 v1(152.69,114.41) 151.44,114.41 150.96,113.94 v1(149.92,113.94) ; 147.33,111.5 147.45,111.5 147.91,111.04 148.04,111.04 148.51,110.57 R211.1 ; 147.33,111.5 148.24,112.41 148.48,112.41 148.99,112.92 R188.2 149.63,113.94 v1(149.92,113.94) ; 147.33,111.5 146.74,110.92 R195.1 146.15,110.86 R193.1 R240.2 ; v1(29.65,100.86) 29.27,100.48 28.12,100.48 27.61,100.99 R11251.2 ; R291.1 161.13,99.11 156.65,94.63 154.62,94.63 153.1,96.16 v1(153.1,96.36) 153.1,97.17 R205.2 ; v1(190.3,54.3) 190.5,54.5 197.8,54.5 198.08,54.22 205.9,54.22 206.94,55.26 206.94,57.68 206.43,58.19 206.43,59.33 207.14,60.04 v1(207.27,60.04) ; v1(137.34,129.31) v1(138.23,129.31) ; R577.2 R152.2 142.09,118.89 142.5,118.49 ; v1(56.57,10.05) 59.23,12.71 R439.2 ; R11278.2 v1(38.28,111.14) ; 142.5,118.49 144.7,118.49 145.18,118 R182.2 ; 142.5,118.49 140.87,116.86 R160.2 R582.1 ; v1(158.81,140.61) 155.89,137.69 155.89,136.42 154.49,135.02 153.98,135.02 149.78,130.82 v1(149.78,130.52) 149.33,130.07 148.65,130.07 v1(148.09,129.51) v1(148.09,127.27) 148.09,124.68 v1(146.23,122.83) 146.87,122.19 v1(146.87,117.39) 146.63,117.62 R182.2 ; 178.36,35.31 177.75,35.31 C168.2 177.74,35.11 v1(177.37,34.75) ; R779.1 v1(190.65,35.36) ; R212.1 149.75,114.1 v1(149.92,113.94) ; R182.2 R187.2 ; v1(152.46,87.9) 152.01,87.9 151.2,88.72 R628.1 ; R440.2 v1(50.72,14.62) ; R11205.1 35.88,111.28 v1(36.3,111.7) 35.88,112.13 R11198.1
  IN1 w0.508: v1(158.81,140.61) 160.58,142.39 160.58,146.17 164.9,150.49 164.9,165.75 167.57,168.42 167.57,170.83 167.94,171.2 177.72,171.2 181.54,175.03 186.15,175.03 188.56,177.44 190.43,177.44 193.27,180.28 196.96,180.28 198.18,181.5 198.18,182.29 v1(202.1,186.22) ; v1(190.65,35.36) 190.34,35.36 188.86,33.88 184.83,33.88 183.76,34.96 179.39,34.96 179.18,34.75 v1(177.37,34.75) ; v1(50.72,14.62) 50.72,14.62 48.69,16.66 43.91,16.66 40.23,20.34 40.23,30.77 39.05,31.95 39.05,32.81 35,36.86 35,41.02 34.09,41.93 34.09,49.93 v1(33.33,50.69) ; v1(177.86,48.66) 177.86,48.53 178.31,48.08 180.7,48.08 v1(181.29,48.66) ; v1(185.2,54.56) 185.2,54.55 185.5,54.25 190.25,54.25 v1(190.3,54.3)
  IN2 w0.508: v1(50.72,14.62) 52.37,12.97 54.16,12.97 56.57,10.56 v1(56.57,10.05) ; v1(149.92,113.94) 149.92,115.84 150.91,116.83 v1(150.91,117.62) ; v1(148.09,127.27) 150.18,125.19 v1(150.18,124.18) ; v1(155,106.95) 155,106.32 155.63,105.68 155.63,100.45 153.98,98.8 153.98,98.32 153.1,97.44 v1(153.1,96.36) 153.56,95.9 155.96,95.9 156.39,95.47 156.39,94.76 154.62,92.98 154.62,90.19 153.28,88.86 153.28,88.4 152.79,87.9 v1(152.46,87.9) 152.46,86.61 v1(152.71,86.35) 152.71,77.36 153.98,76.09 153.98,69.36 158.62,64.73 159.63,64.73 161.73,62.63
  IN3 w0.508: v1(198.31,30.5) 198.31,33.92 196.02,36.21 191.5,36.21 v1(190.65,35.36) ; v1(46.92,81.4) 47.71,81.4 50.73,78.38 53.4,78.38 56.19,81.17 57.97,81.17 58.6,81.81 v1(59.01,81.81) ; v1(177.37,34.75) 176.56,35.56 176.56,39.24 177.96,40.63 177.96,42.59 179.25,43.88 179.25,44.94 177.87,46.33 177.87,48.65 v1(177.86,48.66) 177.86,50.58 v1(174.59,53.84)
  BOTTOM w0.279: C763.1 201.48,185.19 201.48,184.8 201.24,184.57 U43.5 ; Q43.5 Q43.2 135.69,15.01 135.38,15.32
  BOTTOM w0.305: U49.5 198.32,32.52 198.56,32.28 198.56,31.77 198.49,31.71 ; C811.2 191.45,54.26 191.46,54.26 U48.5 ; U50.5 158.44,33.15 158.04,33.56 C813.2
  BOTTOM w0.508: v1(150.18,124.18) 149.97,123.97 R578.1 ; 26.85,112.03 35.97,112.03 v1(36.3,111.7) 36.86,111.14 v1(38.28,111.14) ; R570.1 145.61,122.6 145.84,122.83 v1(146.23,122.83) ; R542.2 138.87,128.3 138.49,128.68 R541.2 v1(138.23,129.31) ; R542.2 139.25,128.54 139.5,128.8 139.5,129.56 140.04,130.09 145.9,130.09 146.49,129.51 v1(148.09,129.51) ; R542.2 R543.2 ; v1(168.81,62.71) 168.81,62.4 169.06,62.16 R725.2 ; C164.2 146.86,131.73 147.25,131.34 148.96,131.34 v1(149.78,130.52) ; R586.1 R177.2 150.55,117.01 150.91,117.37 v1(150.91,117.62) ; R586.1 R585.1 R167.1 R166.1 146.61,117.13 v1(146.87,117.39) ; R586.1 149.54,116.86 R169.2 R165.2 ; PR104.1 206.91,59.68 v1(207.27,60.04) ; v2(50.63,56.43) 50.58,56.38 49.46,56.38 47.76,54.68 47.76,52.57 44.61,49.42 35.64,49.42 34.37,50.69 v1(33.33,50.69) ; v1(152.58,39.77) 154.49,37.87 154.49,36.19 155.89,34.79 155.89,34.44 156.39,33.93 C813.2 ; R250.2 v1(134.42,96.29) R651.1 ; v1(177.86,48.66) 177.73,48.53 R11118.2 ; 134.57,21.45 134.54,21.47 R402.1 ; v1(202.1,186.22) R716.1 C763.1 ; v1(152.69,114.41) 153.47,115.2 153.47,115.72 153.91,116.16 R290.2 R280.2 R275.2 R283.2 ; v1(198.31,30.5) C812.2 198.31,31.52 198.49,31.71 ; R540.2 v1(137.34,129.31) ; v1(59.01,81.81) 58.85,81.81 PR292.2 ; R733.2 R734.2 181.92,46.63 181.51,47.04 181.51,47.67 181.29,47.9 v1(181.29,48.66) ; R682.1 90.56,102.2 89.58,102.2 v1(89.19,102.59) ; v1(148.09,127.27) R580.1 ; v1(190.3,54.3) 190.35,54.26 C811.2
  BOTTOM w1.016: 30.66,100.48 36.63,94.51 40.95,94.51 42.22,93.24 42.22,84.35 45.17,81.4 v1(46.92,81.4) 46.92,78.76 50.6,75.08 50.6,71.01 49.46,69.87 49.46,69.11 47.05,66.69 47.05,65.55
  vias: v1(26.6,115.21) v1(26.85,114.19) v1(27.23,115.21) v1(49.41,64.08) v1(49.41,63.44) v1(51.36,56.46) v1(138.49,39.64) v1(139.12,39.64) v1(139.76,39.64) v1(163.01,63.89) v1(163.65,63.89) v1(166.6,51.61) v1(167.24,51.61) v1(184.56,54.63) v2(50.68,57.2) v2(51.44,57.2) v2(55.81,56.26) v2(56.27,55.67) v2(56.85,56.26)
+3V_WLAN:
  vias: v1(204.15,189.12)
+3VPCU: length 559.4
  TOP w0.381: PR179.2 150.7,180.31 v1(150.37,180.64) ; PR9.2 154.84,167.7 154.84,164.82 v1(155.96,163.7) ; PR16.2 154.06,175.64 v1(154.13,175.56)
  TOP w0.508: R438.2 50.48,17.55 50.07,17.95 50.07,20.44 50.86,21.23 ; 59.24,19.2 59.23,19.19 R437.2 58.47,17.42 C555.1 ; v1(82.99,22.24) 82.99,28.59 80.7,30.88 80.7,33.29 79.94,34.06 v1(79.94,35) 80.75,35 82.73,36.98 82.73,44.06 80.19,46.6 80.19,49.3 79.69,49.79 R304.2 ; 66.35,18.18 66.22,18.31 R429.2 ; 53.52,20.47 53.41,20.35 R436.2 ; PC246.1 v1(209.78,177.34) ; R428.2 62.04,19.19 62.03,19.2 ; v1(206.95,190.5) R231.1 C345.2 ; 55.3,20.47 55.31,20.46 R427.2 ; v1(152.2,20.59) 154.23,20.59 160.03,14.8 168.35,14.8 171.98,18.43 178.87,18.43 v1(179.51,17.8) ; PR14.2 159.38,176.99 159.11,177.26 v1(158.81,177.26) ; v1(155.5,114.73) 155.45,114.73 155.12,115.06 150.96,115.06 150.55,115.46 150.55,115.94 R210.2 ; R757.2 218.63,70.37 217.73,71.27 217.73,71.75 v1(217.71,71.77) ; Q24.1 49.08,69.36 49.46,69.74 R260.1 C4782.2 48.2,69.62 v1(47.68,69.62) ; v1(158.04,100.22) 159.2,101.38 167.08,101.38 167.7,102 168.46,102 ; v1(66.6,55.52) 68.76,53.36 74.48,53.36 v1(75.37,52.47) ; PR6284.1 v1(54.07,43.82) ; R434.2 69.36,14.72 68.76,14.12 68.76,12.85 69.27,12.34 R435.2
  TOP w1.016: 70.03,15.77 67.49,15.77 66.35,16.91 66.35,18.82 65.97,19.2 58.1,19.2 56.83,20.47 51.62,20.47 50.86,21.23 50.86,26.82 48.44,29.23
  IN1 w0.762: v1(47.68,69.62) 47.68,67.84 43.67,63.82 42.4,63.82 37.62,59.05 37.62,57.71 38.26,57.07 38.26,53.79 39.05,53 39.1,53 39.6,52.5 39.6,50.87 41.33,49.14 v2(50.45,49.14)
  IN2 w0.508: v1(158.04,100.22) 157.66,100.6 157.66,107.72 156.77,108.6 156.77,113.46 v1(155.5,114.73) 154.11,116.12 154.11,133.5 153.35,134.26 153.35,142.01 155.96,144.62 v1(155.96,163.7) 154.9,163.7 154.23,164.36 152.56,164.36 150.34,162.14 131.83,162.14 131.39,162.58 130.61,162.58 129.85,161.82 123.75,161.82 123.22,162.35 120.92,162.35 118.73,160.17 117.28,160.17 115.5,158.39 115.5,154.65 112.96,152.11 v1(112.96,151.15) ; 199.45,28.72 198.81,28.09 198.81,25.95 199.19,25.57 199.19,24.15 192.84,17.8 v1(179.51,17.8) ; 199.45,28.72 199.07,29.1 v1(199.07,29.99) ; 199.45,28.72 v1(200.11,28.72) ; v1(160.25,55.7) v1(160.25,52.09) ; 54.07,45.32 v1(54.07,43.82)
  IN2 w0.762: v2(204.05,182.29) 204.91,183.15 204.91,188.46 v1(206.95,190.5)
  IN2 w1.016: 47.05,43.33 45.9,42.18 45.9,35.83 47.68,34.06 47.68,31.39
  IN2 w2.032: 226.88,154.58 226.88,157.12 225.1,158.9 208.37,158.9 207.08,160.19 207.08,169.73 207.66,170.31 207.66,177.76 205.49,179.93
  IN3 w0.508: v1(154.13,175.56) 154.62,175.56 156.52,173.65 156.52,172.23 155.25,170.96 155.25,164.41 v1(155.96,163.7)
  BOTTOM w0.305: v1(199.07,29.99) 198.94,29.86 198.43,29.86 197.92,29.36 RP1.10 ; RP1.2 v1(200.11,28.72)
  BOTTOM w0.381: PR6279.1 58.07,40.81 58.6,40.28 62.69,40.28 63.23,40.81 65.84,40.81 69.75,44.72 ; v1(207.57,60.68) PR101.1
  BOTTOM w0.508: R52.2 110.55,149.88 111.57,150.9 R53.1 112.58,151.53 v1(112.96,151.15) ; v1(150.37,180.64) 153.85,177.16 153.85,175.84 v1(154.13,175.56) 154.72,176.14 157,176.14 158.12,177.26 v1(158.81,177.26) ; v1(206.95,190.5) 206.69,190.77 Q22.1 ; v1(82.99,22.24) 85.53,22.24 89.97,26.69 102.05,26.69 R2870.1 106.59,23.02 R11289.2 ; v1(160.25,52.09) 157.28,52.09 157.16,51.96 155.25,51.96 152.96,49.68 152.96,43.45 151.5,41.99 151.5,38.44 152.2,37.74 v1(152.2,30.42) v1(152.2,24.22) v1(152.2,20.59) ; PR1250.1 159.8,56.26 159.85,56.21 159.85,56.15 160.25,55.76 v1(160.25,55.7) ; R388.1 215.07,40.53 v1(215.94,41.4) 216.59,42.06 216.59,46.94 215.59,47.95 214.69,47.95 213.09,49.55 v1(213.09,59.2) ; PR6295.1 v1(75.37,52.47) ; v1(228.66,109.24) 228.14,109.24 R695.1
  vias: v1(47.68,30.37) v1(47.68,29.74) v1(173.34,61.92) v1(173.34,61.27) v1(174.3,41.8) v1(174.3,41.04) v1(175.67,96.87) v1(176.23,96.57) v1(176.33,97.23) v1(205.62,182.47) v2(50.22,48.28) v2(63.66,55.01) v2(63.66,54.12) v2(63.66,53.23) v2(64.42,55.01) v2(64.42,54.12) v2(64.42,53.23) v2(65.18,55.01) v2(65.18,54.12) v2(65.18,53.23) v2(204.02,181.43) v2(204.02,180.39)
+3VPCU_EC: length 51.1
  TOP w0.762: 165.66,32.91 164.39,31.64 164.39,26.82 165.44,25.78 169.35,25.78 170.64,27.07 177.09,27.07 178.11,26.05 v2(178.11,25.45)
  IN2 w0.762: v2(189.16,30.96) 188.22,30.96 185.06,27.79 179.87,27.79 178.11,26.04 v2(178.11,25.45) ; v2(170.07,41.17) 170.1,41.19 170.1,41.69 174.02,45.61 179.43,45.61 180.65,46.83 v2(180.65,47.26)
  BOTTOM w0.203: U45.114 179.98,44.5
  vias: v1(167.32,32.91) v1(167.95,32.91) v1(170.11,40.41) v1(181.18,41.42) v1(181.82,41.42) v1(185.35,47.39) v1(185.86,46.83)
+3VPCU_ECPLL:
  vias: v1(186.75,44.47)
+5V: length 322.1
  TOP w0.203: U13.17 21.16,69.75 21.04,69.87 v1(21.04,70.35)
  TOP w0.305: v1(10.61,85.85) 11.12,86.35 U37.5 ; v1(14.04,85.76) U40.5
  TOP w0.508: v1(37.66,36.97) PR153.1
  IN2 w0.508: 60,119.02 65.94,119.02 66.68,119.76 72.12,119.76 78.47,126.11 v1(78.47,126.31) ; v1(14.04,85.76) 15.02,85.76 15.55,85.23 15.55,79.78 20.92,74.41 v1(20.92,73.17) 20.92,72.5 22.41,71.01 22.41,70 21.27,68.85 21.27,67.84 19.61,66.19 v1(19.61,65.17)
  IN2 w1.016: 27.11,65.68 27.87,66.44 27.87,73.12 28.66,73.91 30.33,73.91 31.46,75.04 31.46,98.1 34.22,100.86 35.49,100.86 37.78,103.14 37.78,105.56 51.52,119.3 58.45,119.3 ; 223.07,155.09 214.05,155.09 213.75,155.39 211.97,155.39 210.12,157.24 207.71,157.24 205.44,159.51 205.44,170.12 204.89,170.67 204.31,170.67 203.07,171.92 203.07,172.42 199.07,176.42 199.07,178.84 197.64,180.26 192.74,180.26 191.38,178.9 186.3,178.9 185.1,177.69 181.79,177.69 178.57,174.47 161.52,174.47 160.84,175.15 158.81,175.15 153.85,180.11 153.85,180.87 151.69,183.03 148.39,183.03 147.76,182.39 143.44,182.39 142.93,182.9 140.14,182.9 139.63,182.39 139.63,181.5 138.74,180.61 136.84,180.61 136.3,181.15 135.03,181.15 134.6,180.72 133.38,180.72 132.26,179.6 132.26,178.96 131.76,178.45 128.71,178.45 127.56,177.31 126.17,177.31 123.5,174.64 120.2,174.64
  IN3 w1.016: 225.61,154.58 228.28,151.91 228.28,141.75 227.41,140.89 227.41,128.92
  BOTTOM w0.508: v1(196.53,48.78) 196.53,47.77 195.41,46.66 193.83,46.66 193.47,47.02 R343.2 ; v1(227.92,124.76) 226.24,124.76 225.88,124.39 225.88,123.07 226.23,122.71 R148.1 226.23,122.2 C187.2 Q18.1 ; v1(20.92,73.17) 21,73.09 C4753.1 C4749.2 21,70.39 v1(21.04,70.35) ; v1(14.04,85.76) 14.03,85.77 C720.2 13.64,86.88 13.26,86.51 Q21.3 11.99,86.51 11.62,86.88 C713.2 11.11,86.34 v1(10.61,85.85) ; v1(27.62,36.97) v1(37.66,36.97) ; U12.2 80.22,126.13 79.99,126.36 78.52,126.36 v1(78.47,126.31) 78.42,126.26 C321.2
  vias: v1(20.68,58.44) v1(20.68,57.8) v1(27.11,64.79) v1(27.11,64.15) v1(61.19,19.15) v1(115.88,173.37) v1(116.95,173.63) v1(117.58,173.63) v1(200.72,50.69) v1(200.72,50.06) v1(212.53,36.24) v1(212.55,36.9) v1(219.72,101.57) v1(221.29,85.69) v1(221.54,84.98) v1(221.54,84.22) v1(222.1,101.44) v1(222.1,100.81) v1(222.31,84.98) v1(222.31,84.22) v1(222.74,101.44) v1(222.74,100.81) v1(223.83,155.59) v1(224.47,155.59) v2(56.09,18.33) v2(56.09,17.57) v2(56.85,18.33) v2(56.85,17.57) v2(57.61,17.57) v2(82.86,13.61) v2(82.86,12.85) v2(83.62,13.61) v2(83.62,12.85) v2(214.18,50.74) v2(214.92,50.77) v2(214.92,50.03) v2(214.92,49.27) v2(215.65,50.03) v2(215.65,49.27) v2(231.45,110.26) v2(231.45,109.49)
+5V_HDD:
  vias: v1(220.78,47.14)
+5V_KB: length 1.2
  BOTTOM w0.762: Q18.3 225.25,125.78 v1(224.9,126.13)
+5V_KB_R:
  vias: v1(228.15,127.53)
+5V_ODD:
  vias: v1(224.08,104.41)
+5V_PVDD: length 8
  BOTTOM w0.203: U23.41 199.99,41.58 199.83,41.42 198.69,41.42 C510.1 ; 199.07,45.1 199.66,45.1 200.45,44.32 200.45,44.18 201.04,43.58 U23.46
  BOTTOM w0.508: C501.1 199.07,45.1
  vias: v1(198.18,42.92)
+5V_S5: length 321.3
  TOP w0.305: PR274.1 PR264.2
  TOP w0.508: PR204.1 132.81,177.28 132.14,177.95 130.59,177.95 119.94,167.31 119.94,163.98 119.22,163.26 PR61.2 ; v1(32.95,100.98) 31.04,100.98 v1(29.59,102.44) 28.76,103.27 R11201.2 ; v1(50.07,55.47) 49.69,55.09 PR264.2 ; v1(144.74,169.51) 145.22,170 PR6301.2 ; PR61.2 120.53,162.28 120.96,162.71 122.81,162.71 123.25,162.28 125.98,162.28 PR62.2 129.41,161.73 130.23,162.55 131.76,162.55 132.24,162.07 135.33,162.07 135.72,161.68 PR55.2 137.25,162.45 145.34,162.45 147.45,164.56 v1(148.21,164.56) ; PR61.2 119.22,161.38 118.29,160.45 118.29,156.86 117.51,156.08 116.49,156.08 114.36,153.94 114.36,151.53 113.34,150.51 109.71,150.51 v1(109.25,150.97)
  IN1 w0.508: v1(34.09,95.52) 32.95,96.67 v1(32.95,100.98) 32.95,101.37 41.83,110.25 v1(56.11,110.25)
  IN2 w0.508: v1(144.74,169.51) 145.19,169.06 145.67,169.06 148.21,166.52 v1(148.21,164.56) ; v1(109.25,150.97) 109.25,149.94 107.65,148.34 107.65,147.63 105.67,145.65 105.67,140.72 102.67,137.71 102.44,137.71 98.61,133.88 98.61,131.6 97.83,130.82 96.1,130.82 94.58,129.3 94.58,125.56 90.57,121.56 89.08,121.56 78.16,110.64 56.5,110.64 v1(56.11,110.25)
  IN2 w2.032: 181.29,34.44 178.11,31.26 177.25,31.26 175.66,29.67 170.3,29.67 169.35,28.72 163.76,28.72 162.24,27.2 ; 110.3,27.2 109.18,27.2 106.25,30.12 80.96,30.12 76.38,25.55 74.61,25.55 69.4,20.34
  BOTTOM w0.508: v1(50.07,55.47) 50.07,55.39 48.8,54.12 48.8,51.96 43.97,47.14 43.97,43.68 39.43,39.14 33.33,39.14 v2(32.7,39.77)
  BOTTOM w0.762: 201.73,65.55 209.61,65.55 211.51,63.65 211.51,50.95 211,50.44 v2(211,48.79)
  vias: v1(190.84,48.23) v1(190.76,47.21) v1(191.19,47.7) v1(191.5,48.25) v2(31.81,40.66) v2(31.81,39.77) v2(32.7,40.66) v2(55.43,23.13) v2(55.43,21.86) v2(56.32,22.5) v2(57.08,23.13) v2(57.08,21.74) v2(214.43,26.82) v2(214.43,26.05) v2(215.19,26.82) v2(215.19,26.05)
+5V_S5_V2:
  vias: v1(35.46,103.93) v1(37.57,99.97)
+5VA: length 3
  BOTTOM w0.203: U23.26 206.58,38.53 206.89,38.22 207.57,38.22 207.8,37.99
  BOTTOM w0.508: C532.1 207.8,37.99
  vias: v1(205.8,32.53) v1(205.79,31.48) v1(207.7,31.39) v1(208.59,34.18) v1(209.15,33.83)
+5VODD: length 1
  BOTTOM w0.127: C733.1 230.21,110.78 v1(230.21,111.73)
+5VPCU: length 477.6
  TOP w0.203: PU6010.14 50.05,38.33 49.84,38.12 v1(49.84,38.04)
  TOP w0.254: PR103.2 217.95,176.43 217.68,176.7
  TOP w0.305: v1(52.69,54.35) 52.71,54.38 55.23,54.38 55.86,53.74 57.33,53.74 58.15,54.55 PR6292.1
  TOP w0.381: PR6281.2 56.45,37.27 57,36.72 v1(57.21,36.72) ; v1(65.79,69.23) 65.72,69.16 64.93,69.16 64.55,69.54 PR93.2 ; v1(40.67,51.58) 40.3,51.95 PR6290.2
  TOP w0.508: PR68.2 45.32,51.38 45.14,51.2 v1(44.86,51.2) ; v1(222.56,83.46) 220.96,83.46 217.1,87.32 217.1,88.12 214.85,90.37 214.85,94.37 214.34,94.87 214.34,99.24 216.72,101.62 216.72,106.95 v1(218.81,109.05) ; 217.68,176.7 216.96,176.7 PR111.1 216.56,176.52 213.82,176.52 213.11,175.81 213.11,171.9 214.43,170.58 214.43,156.36 v1(214.69,156.1) ; R360.1 R356.1 v1(16.95,21.08) ; v1(153.52,66.44) 152.79,67.17 152.79,70.59 155.12,72.92 158.09,72.92 159.82,74.65 162.54,74.65 163.12,74.06 164.5,74.06 165.72,72.84 169.08,72.84 171.37,70.56 172.67,70.56 176.07,67.15 182.7,67.15 188.34,61.51 188.34,60.7 188.91,60.13 188.91,58.56 190.81,56.66 202.32,56.66 207.02,61.36 208.21,61.36 211.33,64.49 v1(211.33,65.42) ; PR6300.1 40.95,92.98 v1(40.82,92.86)
  TOP w0.762: v1(65.79,69.23) 65.97,69.23 67.09,70.35 67.09,72.22 PR88.1
  IN1 w0.508: v1(211.33,65.42) 215.99,65.42 219.02,68.45 219.02,72.76 219.91,73.65 219.91,79.28 222.56,81.93 v1(222.56,83.46)
  IN2 w0.508: v1(153.52,66.44) 155.12,66.44 158.04,63.52 158.04,60.84 v1(157.36,60.16) 157.36,59.5 158.81,58.06 158.81,53.01 157.67,51.87 156.14,51.87 155.8,51.53 155.8,49.34 153.98,47.52 153.98,45.36 151.67,43.05 145.23,43.05 144.98,42.8 138.23,42.8 136.28,40.85 125.56,40.85 124.9,41.51 124.9,41.93 124.39,42.44 119.79,42.44 118.67,43.56 82.7,43.56 78.42,47.84 78.42,68.35 77.04,69.72 69.78,69.72 68.97,68.9 66.12,68.9 v1(65.79,69.23) 64.14,69.23 63.76,68.85 53.4,68.85 52.51,67.96 50.81,67.96 48.95,66.11 48.95,65.27 46.88,63.2 46.88,62.69 44.94,60.75 44.94,59.1 46.16,57.88 46.16,55.19 v1(46.44,54.91)
  IN3 w0.381: v1(52.69,54.35) 52.61,54.27 48.49,54.27 47.63,53.41 46.49,53.41 46.06,53.84 46.06,54.53 v1(46.44,54.91) ; v1(54.29,36.01) 59.39,36.01 60.1,36.72 63.44,36.72 64.06,36.09 v1(68.41,36.09)
  IN3 w0.508: v1(214.69,156.1) 215.93,154.86 222.02,154.86 226.44,150.43 226.44,142.22 225.91,141.69 225.91,122.56 227.16,121.32 227.16,114.6 222.69,110.13 219.64,110.13 218.81,109.3 v1(218.81,109.05)
  BOTTOM w0.381: v1(49.84,38.04) 50.81,38.04 51.64,37.21 53.09,37.21 v1(54.29,36.01) ; v1(57.21,36.72) 59.24,36.72 59.75,37.23 65.21,37.23 65.72,36.72 68.13,36.72 ; 68.13,20.21 67.72,20.62 PR6282.1
  BOTTOM w0.508: v1(38.03,50.95) 38.66,51.58 v1(40.67,51.58) 40.95,51.3 42.07,51.3 42.63,50.74 44.41,50.74 v1(44.86,51.2) 45.83,52.17 45.83,54.28 45.9,54.36 45.9,54.38 v1(46.44,54.91) ; PR81.2 157.89,60.65 157.4,60.16 v1(157.36,60.16) ; v1(16.95,21.08) 16.82,21.2 16.82,23.39 17.33,23.9 18.98,23.9 19.87,24.78 19.87,26.56
  vias: v1(20.28,29.28) v1(37.39,95.47) v1(65.46,18.1) v2(19.89,28.7) v2(19.89,27.93) v2(20.66,28.7) v2(20.66,27.93) v2(34.73,34.56) v2(34.73,33.8) v2(35.16,91.1) v2(35.54,91.74) v2(35.49,34.56) v2(35.49,33.8) v2(35.49,33.04) v2(35.95,92.43) v2(35.92,91.1) v2(36.3,91.74) v2(36.71,92.43) v2(36.68,91.1)
+A3VPCU:
  vias: v1(170.14,31.44)
+VCCATS_1P8: length 8.4
  TOP w0.381: R180.1 145.92,112.16 146.35,111.73 v1(146.41,111.73)
  TOP w0.508: v1(145,113.94) 145.1,113.84 C250.1 145.44,112.97 R180.1
  BOTTOM w0.203: v1(145,113.94) 144.52,114.42 142.91,114.42 141.53,113.05 140.63,113.05 U35.AA1
+VCCCORE: length 35.9
  TOP w0.127: v1(149.13,177.01) 148.99,177.15 PR31.2
  IN1 w0.203: v1(149.13,177.01) 148.39,176.27 148.39,174.52 147.71,173.83 147.71,172.33 146.72,171.34 146.72,168.96 144.96,167.2 144.96,165.63 146.23,164.36 146.23,161.69 145.22,160.67 145.22,150.16 v1(144.71,149.65)
  BOTTOM w0.127: 122.93,119.69 U35.G32 122.61,119.37 ; 123.07,119.54 U35.J30 ; U35.J30 122.75,119.23 ; U35.J30 123.07,118.91 ; U35.J30 123.38,119.23 ; 117.26,119.23 U35.J40 117.9,119.23 ; 123.21,119.69 U35.G30 123.52,119.37
  BOTTOM w0.203: v1(115.67,124.97) 115.66,124.97 U35.A44
  vias: v1(117.35,114.14) v1(117.53,113.53) v1(117.99,114.09) v1(118.1,117.94) v1(118.17,113.46) v1(118.37,114.6) v1(118.51,109.33) v1(118.51,108.69) v1(118.75,114.09) v1(118.8,113.46) v1(118.94,117.94) v1(119.35,114.36) v1(119.36,119.17) v1(119.49,113.74) v1(119.7,117.94) v1(119.79,113.18) v1(120.02,114.35) v1(120.15,113.71) v1(120.34,109.3) v1(120.5,113.18) v1(120.83,114.19) v1(121.14,113.18) v1(121.23,109.3) v1(121.34,125.88) v1(121.34,125.24) v1(121.34,124.61) v1(121.77,113.18) v1(122.12,109.3) v1(122.15,108.65) v1(122.99,125.24) v1(122.99,124.61) v1(123.63,125.24) v1(123.63,124.61) v1(132.04,148.05) v2(123.25,129.56) v2(123.25,128.8) v2(123.5,134.26) v2(123.5,133.5) v2(124.26,135.02) v2(124.26,134.26) v2(124.26,133.5) v2(125.02,135.78) v2(125.79,135.78) v2(126.55,135.78) v2(135.34,143.12) v2(135.34,141.6) v2(135.41,144.7) v2(135.79,143.89) v2(135.79,142.34) v2(135.82,140.71) v2(136.4,144.67) v2(136.4,143.12) v2(136.35,141.57) v2(136.94,142.34) v2(136.86,140.71) v2(136.96,143.81) v2(137.29,144.9) v2(137.93,144.29) v2(138.74,144.93) v2(139.43,144.27) v2(139.93,144.95) v2(140.65,140.61) v2(140.72,141.73) v2(140.85,143.2) v2(141.41,144.01) v2(141.43,142.49) v2(141.38,141.02) v2(141.99,143.05) v2(141.97,141.7) v3(113.09,117.24) v3(113.72,118) v3(113.72,117.24) v3(114.36,118) v3(114.36,117.24) v3(114.99,118) v3(117.57,118.42) v3(118.53,118.41) v3(119.37,118.47) v3(119.48,107.14) v3(120.24,118.39) v3(120.32,107.13) v3(120.62,117.91) v3(121.25,107.14) v3(122.11,107.11)
+VCCDSW_1P0: length 6.3
  BOTTOM w0.076: U35.AL1 141.93,107.61 142.42,108.1 142.42,109.14 143.47,110.18 143.69,110.18
  BOTTOM w0.127: C712.1 144.54,110.18 143.69,110.18
+VCCEOPIO: length 1.7
  TOP w0.508: v1(94.96,106.59) 94.94,106.57 C708.1 C709.1
  vias: v1(71.3,96.54) v1(106.36,110.51) v1(106.36,109.87) v1(106.36,109.24) v1(106.99,110.51) v1(106.99,109.87) v1(106.99,109.24) v2(70.92,97.94) v2(70.92,97.17) v2(71.68,97.94) v2(71.68,97.17) v2(72.45,97.94) v2(72.45,97.17)
+VCCGT: length 55.2
  TOP w0.127: v1(128.96,167.53) 129.98,168.55 v1(133.74,168.55) 134.09,168.55 134.3,168.35 PR187.2
  TOP w0.508: PC159.1 v1(132.91,145.57)
  IN1 w0.203: v1(128.96,167.53) 128.35,168.14 126.32,168.14 122.97,164.79 120.43,164.79 117.68,162.05 117.68,161.21 116.13,159.66 116.13,158.97 115.6,158.44 115.6,155.01 109.66,149.07 109.66,148.71 v1(109.78,148.58)
  BOTTOM w0.152: v1(113.4,124.49) 113.19,124.27 U35.A48 ; v1(108.38,100.58) 108.38,101.37 U35.BB57
  BOTTOM w0.178: U35.AK70 99.6,108.57 99.55,108.62 v1(99.57,108.62) ; U35.A58 108.23,124.21 108.16,124.28 v1(108.16,124.48)
  BOTTOM w0.203: v1(109.78,148.58) 109.05,147.85 108.79,147.85 107.88,146.93 107.88,143.17 108.39,142.67 ; v1(110.1,124.57) 110.1,124.29 110.46,123.93 110.46,123.64 U35.A53 ; v1(103.05,100.73) 103.05,101.19 U35.BB66 ; U35.A62 105.6,123.54 105.6,124.7 v1(105.4,124.9) ; U35.A66 103.27,124.34 v1(103.23,124.39)
  BOTTOM w0.254: v3(104.77,104.58) 104.77,104.58 105.14,104.2 U35.AU63 ; v3(107.56,104.55) 107.91,104.2 U35.AU58
  vias: v1(88.58,116.61) v1(88.58,115.97) v1(88.58,115.34) v1(88.58,114.7) v1(88.83,117.24) v1(89.21,116.61) v1(89.21,115.97) v1(89.21,115.34) v1(89.21,114.7) v1(89.46,117.24) v1(89.85,116.61) v1(89.85,115.97) v1(89.85,115.34) v1(89.85,114.7) v1(90.48,117.11) v1(90.48,116.35) v1(90.48,115.72) v1(90.48,115.08) v1(91.12,117.11) v1(91.75,117.11) v1(92.39,117.11) v1(93,117.88) v1(93.02,117.11) v1(93.27,121.84) v1(93.66,117.11) v1(93.91,121.84) v1(94.29,117.11) v1(94.54,122.75) v1(94.54,121.84) v1(95.18,121.84) v1(95.81,121.84) v1(102.49,115.29) v1(103.13,117.11) v1(103.13,115.29) v1(103.76,117.11) v1(103.76,115.29) v1(104.4,117.11) v1(104.4,115.29) v1(105.03,117.11) v1(106.99,142.97) v1(109.44,109.38) v1(109.39,108.74) v1(109.78,113.48) v1(110.28,109.35) v1(110.28,108.72) v1(110.39,114.13) v1(110.42,113.48) v1(110.42,112.85) v1(111.03,114.13) v1(111.05,113.48) v1(111.05,112.85) v1(111.2,109.35) v1(111.2,108.72) v1(111.66,114.13) v1(111.69,113.48) v1(111.69,112.85) v1(112.11,108.72) v1(112.3,114.13) v1(112.32,113.48) v1(112.32,112.85) v1(112.47,109.33) v1(112.96,112.85) v1(113,108.69) v1(113.15,109.33) v1(113.91,109.33) v1(113.91,108.69) v1(114.52,109.15) v2(109.02,145.82) v2(109.02,144.55) v2(109.4,146.45) v2(109.4,145.18) v2(109.4,143.91) v2(109.78,145.82) v2(109.78,144.55) v2(110.17,146.45) v2(110.17,145.18) v2(110.17,143.91) v2(110.55,145.82) v2(110.55,144.55) v2(110.93,146.45) v2(110.93,145.18) v2(110.93,143.91) v2(111.31,147.09) v2(111.31,145.82) v2(111.31,144.55) v2(111.69,146.45) v2(111.69,145.18) v2(111.69,143.91) v2(112.07,147.09) v2(112.07,145.82) v2(112.07,144.55) v2(112.45,146.45) v2(112.45,145.18) v2(112.45,143.91) v2(112.83,147.09) v2(112.83,145.82) v2(112.83,144.55) v2(113.21,146.45) v2(113.21,145.18) v2(113.21,143.91) v2(113.67,147.09) v2(113.77,145.82) v2(113.85,144.62) v2(114.26,146.53) v2(114.36,145.21) v2(114.69,145.87) v3(107.24,116.22) v3(107.5,118.48) v3(107.5,117.87) v3(107.88,116.22) v3(108.01,115.59) v3(108.01,114.7) v3(108.01,113.68) v3(108.01,112.67) v3(108.41,118.48) v3(108.41,117.87) v3(108.62,115.56) v3(108.62,114.7) v3(108.64,112.67) v3(109.32,118.48) v3(109.32,117.87) v3(109.66,115.72) v3(109.76,114.11) v3(109.78,112.85) v3(110.24,118.48) v3(110.24,117.87) v3(110.67,115.72) v3(111.15,118.48) v3(111.15,117.87) v3(111.56,115.69) v3(112.93,114.11) v3(112.96,113.48)
+VCCHDA: length 36.5
  TOP w0.508: R789.1 R683.1 154.52,89.55 C748.2 153.35,89.06 v1(153.09,88.79) 152.84,88.54 v1(152.46,88.54)
  IN1 w0.508: v1(152.46,88.54) 150.55,88.54 148.77,86.76 142.3,86.76 134.42,94.63 134.42,95.34 130.12,99.64 127.67,99.64
  BOTTOM w0.305: U35.AJ19 129.76,108.73 v3(129.76,108.64)
+VCCIO: length 222
  TOP w0.305: v1(150.37,184.04) 150.55,184.22 PR174.2
  TOP w0.381: v2(78.8,94.76) 78.29,94.25 76.38,94.25 PR138.1
  TOP w0.508: v1(119.39,119.96) 119.39,120.25 R154.2 ; R135.1 135.88,130.19 136.66,130.97 143.5,130.97 147.63,135.1 147.63,135.78 152.84,140.99 156.83,140.99 157.92,142.08 157.92,149.29 156.83,150.39 156.83,164.05 v1(155.89,164.99) ; R465.2 v1(101.4,129.31)
  IN1 w0.508: 110.93,121.3 111.07,121.45 111.07,122.56 109.02,124.61 109.02,125.31 108.9,125.44 108.9,127.76 105.82,130.83 102.55,130.83 101.4,129.69 v1(101.4,129.31) ; v1(116.55,109.61) 115.5,110.66 115.5,111.53 113.72,113.3 113.72,115.59 112.2,117.11 112.2,118.51 112.96,119.27 118.7,119.27 v1(119.39,119.96) ; v1(134.55,173.76) 133.15,172.36 133.15,170.2 135.03,168.32 135.03,165.75 v1(135.06,165.73)
  IN2 w0.508: v1(155.89,164.99) 154.62,166.26 152.71,166.26 149.96,163.51 146.95,163.51 144.74,165.73 v1(135.06,165.73) 135.06,167.66 134.07,168.65 128.07,168.65 125.08,165.65 116.9,165.65 112.96,161.72 112.96,153.66 111.37,152.08 111.37,149.29 109.88,147.8 109.02,147.8 106.52,145.3 106.52,135.07 106.37,134.92 106.37,134.53 104.1,132.25 104.1,131.49 103.18,130.58 102.67,130.58 v1(101.4,129.31)
  BOTTOM w0.127: U35.AM28 v3(123.98,107.13) ; U35.AM30 v3(123.05,107.13)
  BOTTOM w0.305: U35.AM42 U35.AL42 117.58,108.58 v1(116.55,109.61) ; U35.AL30 123.98,108.6 123.98,108.62 ; v1(150.37,184.04) v1(148.77,184.04) 147.88,184.04 145.5,181.66 145.5,176.02 144.15,174.67 139.48,174.67 137.47,172.66 135.39,172.66 134.55,173.5 v1(134.55,173.76) 134.18,173.76 PR200.1 ; v1(123.98,108.65) 123.98,108.62 ; 123.98,108.62 U35.AK28 ; 123.98,108.62 U35.AK30
  BOTTOM w0.508: R465.2 v1(101.4,129.31)
  vias: v1(88.58,104.16) v1(90.28,103.73) v1(91.36,104.17) v1(91.99,104.17) v2(78.67,96.41) v2(78.8,95.65) v2(79.56,95.65) v2(79.56,94.76)
+VCCOPC: length 0.7
  TOP w0.508: v1(99.65,112.8) 99.7,112.8 100.12,113.22 R172.2
  vias: v1(92.39,109.6) v1(92.77,109.06) v1(92.94,110.13) v1(93.58,110.1) v1(106.53,115.34) v1(106.53,114.7) v1(106.53,114.07) v2(72.32,103.4) v2(73.08,103.4) v2(73.84,103.4) v2(74.1,104.41)
+VCCOPC_3V3: length 3.1
  BOTTOM w0.254: PC230.2 56.64,83.29 v1(56.29,83.64) 56.13,83.64 55.86,83.37 PU14.10
  BOTTOM w0.381: PC230.2 PR292.1
+VCCOPC_EN: length 3.4
  TOP w0.127: v1(50.65,83.94) 50.65,83.21 PR136.2
  TOP w0.305: PR136.2 v1(51.34,83.15)
  BOTTOM w0.254: PR135.2 50.93,83.56 v1(51.34,83.15) 51.62,82.87 PU14.5
+VCCOPC_LP#: length 2.7
  BOTTOM w0.254: PU14.6 51.87,83.37 51.71,83.53 51.71,84.28 v1(51.49,84.5) 51.31,84.68 PR288.2
+VCCOPC_MODE: length 4.6
  BOTTOM w0.127: v1(50.65,86.48) 50.65,85.68 PR289.2
  BOTTOM w0.254: PU14.7 53.35,83.91 51.62,85.64 PR289.2
+VCCOPC_SRC: length 80.1
  TOP w0.508: R633.1 R634.1 99.88,114.19 98.56,112.87 86.62,112.87 83.86,110.12 77.77,110.12 76.51,108.86 v1(75.88,108.86) ; v1(56.19,82.06) 55.68,82.06 55.33,82.42 v1(55.28,82.42) 54.52,82.42 PR344.2
  IN2 w0.508: v1(56.19,82.06) 55.12,82.06 49.33,87.85 49.33,96.91 55.69,103.27 66.82,103.27 72.4,108.86 v1(75.88,108.86)
  BOTTOM w0.254: PU14.12 55.88,82.37 v1(56.19,82.06)
+VCCOPC_SW:
  vias: v1(53.57,85.24)
+VCCOPC_VBST:
  vias: v1(55.02,84.32)
+VCCPDSW_3P3: length 26
  TOP w0.381: 133.66,112.25 133.98,112.57 137.19,112.57 137.36,112.4 138.7,112.4 139.16,111.94
  TOP w0.508: v3(131.06,109.48) 131.06,109.48 v3(131.06,111.15) 131.06,111.4 131.7,112.03 132.34,112.03 132.56,112.25 133.66,112.25 ; R212.2 R210.1 148.14,116.73 v1(147.5,116.1) 147.39,115.99 146.64,115.99 C314.1 146.61,115.73 145.97,115.09 143.07,115.09 141.64,113.65 141.64,112.69 140.89,111.94 139.16,111.94
  BOTTOM w0.279: v3(131.06,109.48) 131.06,109.39 U35.AJ17
  BOTTOM w0.305: U35.AD17 v3(131.06,111.15) 130.74,111.48 U35.AD18
+VCCPGPPA: length 26.1
  TOP w0.127: v1(154.36,107) 154.65,107.29 R198.1
  TOP w0.381: R198.1 v1(153.85,107.97) 153.35,107.97 C292.1
  IN1 w0.381: v3(133.24,108.81) 133.24,109.02 133.56,109.34 134.14,109.34 134.9,108.58 137.36,108.58 137.79,109.01 139.99,109.01 141.03,107.97 143.56,107.97 144.58,109 145.98,109 146.19,108.78 152.15,108.78 152.96,107.97 v1(153.85,107.97)
  BOTTOM w0.254: v3(133.24,108.81) 132.94,108.51 132.94,108.47 U35.AK15
+VCCPGPPB: length 27.3
  TOP w0.381: R185.1 v1(153.85,109.24) C268.1
  IN1 w0.381: v1(153.85,109.24) 153.47,109.24 152.02,110.69 149.46,110.69 148.7,109.93 141.97,109.93 141.55,109.5 137.6,109.5 137.17,109.07 135.1,109.07 134.32,109.85 133.16,109.85 132.77,109.47 v3(131.68,109.47)
  BOTTOM w0.127: v1(153.85,109.24) v1(153.07,109.24)
  BOTTOM w0.305: v3(131.68,109.47) 132.26,109.47 U35.AG15
+VCCPGPPC: length 15.7
  TOP w0.381: R182.1 143.92,117.69 142.56,117.69 141.92,117.04 C230.1 141.67,116.49 141.28,116.1 141.28,115.34 141.15,115.21 139.93,115.21 139.54,114.81 v1(138.87,114.81) 134.66,114.81 133.26,113.42 132.18,113.42 131.71,112.95 v3(131.71,112.83)
  BOTTOM w0.305: U35.Y16 v3(131.71,112.83)
+VCCPGPPD: length 13.5
  TOP w0.381: v3(132.36,112.83) 133.36,112.83 134.28,113.75 138.7,113.75 139.25,114.29 139.7,114.29 140.13,114.73 v1(141.6,114.73) 141.9,114.73 142.88,115.71 C265.1 143.72,115.71 R187.1
  BOTTOM w0.305: v3(132.36,112.83) U35.Y15
+VCCPGPPE: length 31.1
  TOP w0.127: R179.1 154.65,112.89 v1(154.51,113.02)
  TOP w0.381: C256.1 153.73,112.03 v1(153.85,111.91) 153.98,112.03 R179.1
  IN3 w0.279: v1(153.85,111.91) 153.85,115.59 151.19,118.26 150.04,118.26 148.01,116.22 147,116.22 146.23,115.46 141.15,115.46 140.52,116.1 138.49,116.1 138.23,115.84 132.87,115.84 v3(132.38,115.35)
  BOTTOM w0.254: U35.T16 132.33,115.22 132.33,115.31 v3(132.38,115.35)
+VCCPGPPF: length 11.8
  TOP w0.381: v3(132.35,110.32) 132.44,110.41 137.35,110.41 137.5,110.27 138.7,110.27 139.28,110.85 141.47,110.85 v1(141.99,111.37) 142.18,111.56 R192.1
  BOTTOM w0.305: v3(132.35,110.32) 132.35,110.42 U35.AF16
+VCCPGPPG: length 18.8
  TOP w0.381: v3(132.36,111.15) 132.36,111.24 132.8,111.68 134.22,111.68 134.42,111.48 137.36,111.48 137.5,111.34 141.09,111.34 142.2,112.44 142.2,113.38 143.33,114.52 145.4,114.52 v1(145.78,114.14) 146.49,113.43 C270.1 147.11,113.31 147.12,113.3 R188.1
  BOTTOM w0.305: U35.AD15 v3(132.36,111.15)
+VCCPLL: length 26
  TOP w0.508: R112.2 143.44,127.69 143.14,127.39 C172.2 142.8,126.64 v1(142.52,126.35) 141.41,125.24 v1(141.41,124.35)
  IN2 w0.508: v1(141.41,124.35) 141.15,124.35 140.39,125.11 135.97,125.11 134.85,126.23 132.87,126.23 131.5,124.86 131.5,122.32 130.23,121.05 130.23,119.27 129.72,118.76 129.09,118.76 128.45,118.13 v3(128.45,117.88)
  BOTTOM w0.305: U35.K20 129.34,118.37 128.88,118.37 U35.K21 128.45,117.94 v3(128.45,117.88)
+VCCPRIM_1P0: length 5.6
  BOTTOM w0.254: U35.T1 140.49,115.56 141.13,115.56 141.92,116.35 141.92,117.11 142.93,118.13 R11131.1
+VCCPRIM_3P3: length 25.3
  TOP w0.508: v3(129.76,114.5) 129.76,114.1 129.13,113.47 129.13,112.04 128.49,111.41 128.49,110.91 129.1,110.3 v1(129.1,110.24) v3(129.1,109.48) ; C261.2 153.72,110.14 v1(153.72,110.09) 154.27,110.64 R186.1
  IN1 w0.508: 138.11,110.26 138.61,110.26 139.38,111.02 148.9,111.02 149.15,111.27 152.21,111.27 152.98,110.51 153.3,110.51 v1(153.72,110.09)
  BOTTOM w0.254: U35.AJ21 129.1,109.37 v3(129.1,109.48)
  BOTTOM w0.305: U35.V19 v3(129.76,114.5)
+VCCPRTC: length 48.1
  TOP w0.508: v1(153.96,88.54) 154.74,88.54 155.29,87.99 156.61,87.99 v1(157.18,88.56) 157.28,88.67 C322.1 C352.2 159.27,89.55 R252.1
  IN1 w0.508: v1(153.96,88.54) 152.3,90.19 150.93,90.19 149.31,88.57 141.98,88.57 138.55,92.01 138.55,93.05 132.84,98.76 v1(132.84,100.34) 132.27,100.34 131.77,99.84 130.79,99.84 129.11,101.52 128.38,101.52 127.37,102.53 127.37,103.25 127.86,103.74 127.86,105.92
  BOTTOM w0.178: U35.BB14 132.83,100.35 v1(132.84,100.34)
  BOTTOM w0.305: v3(129.46,107.7) 129.57,107.7 U35.AK19
+VCCPRTCPRIM_3P3: length 14
  TOP w0.381: v3(131.7,108.6) 131.7,108.73 132.85,109.87 135.44,109.87 135.97,109.34 140.88,109.34 141.15,109.61 C349.1 C348.2 144.16,109.61 R240.1
  BOTTOM w0.305: v3(131.7,108.6) 131.39,108.29 U35.AK17
+VCCPSPI: length 15.8
  TOP w0.356: R193.2 145.46,109.66 144.4,108.6 v1(144.4,108.46) 144.4,108.27 143.92,107.79 141.2,107.79 140.12,108.87 135.68,108.87 135.18,109.37 133.03,109.37 132.36,108.7 v3(132.36,108.61)
  BOTTOM w0.305: U35.AJ16 132.35,108.74 132.35,108.62 v3(132.36,108.61)
+VCCSA: length 51.2
  TOP w0.127: v1(144.63,183.31) 144.63,183.56 145.27,184.2 PR51.2
  IN1 w0.203: v1(149.48,142.39) 149.28,142.18 149.03,142.18 146.41,144.8 146.41,159.53 147.38,160.5 147.38,164.48 150.32,167.43 150.32,171.19 149.92,171.6 149.92,172.49 150.48,173.04 150.48,175.64 150.09,176.02 150.09,178.12 148.77,179.45 147.4,179.45 144.4,182.44 144.4,183.08 v1(144.63,183.31)
  BOTTOM w0.127: 127.18,108.71 U35.AK23 126.86,108.39 ; U35.AK25 126.27,108.71 ; U35.AK25 126.27,108.07 ; U35.AK25 126.58,108.39
  vias: v1(126.33,112.5) v1(126.33,111.87) v1(126.33,111.23) v1(126.33,109.63) v1(126.33,108.97) v1(126.96,108.66) v1(136.53,134.79) v1(147.91,142.67) v2(148.44,145.46) v2(148.44,144.62) v2(148.44,143.83) v2(149.15,143.23) v2(149.76,143.71) v2(150.58,143.43) v2(151.42,143.68) v3(124.87,120.03) v3(125.06,118.24) v3(125.7,117.86) v3(125.81,120.03) v3(125.81,108.6) v3(126.41,117.86) v3(127.06,117.62)
+VCCSTG: length 10.7
  TOP w0.508: R135.2 133.53,130.19 132.89,129.55 C174.2 132.52,129.13 131.92,128.53 C176.2 131.63,128.14 v1(131.28,127.79) 129.85,126.36 129.85,124.61 128.96,123.72
  BOTTOM w0.203: v1(128.2,124.4) 128.05,124.26 U35.A22
  BOTTOM w0.305: v3(129.47,119.41) 129.64,119.41 U35.G20
+VDDQ: length 154.8
  TOP w0.508: v1(115.49,59.66) 115.82,59.66 R10935.1
  TOP w0.762: v2(130.87,41.85) 130.87,41.8 131.13,41.54 R10887.1
  IN1 w0.762: v2(45.68,44.98) 45.68,42.54 46.28,41.93 46.28,36.6 47.68,35.2 47.68,31.9 48.82,30.75 48.82,29.23 53.9,24.15 62.39,24.15 64.42,26.18 70.63,26.18 73.72,29.26 73.72,34.31 77.58,38.18 92.26,38.18 93.22,39.14 123.37,39.14 124.9,40.66 129.85,40.66 130.87,41.68 v2(130.87,41.85)
  IN2 w0.762: 116.64,59.07 116.64,56.28 120.52,52.41 120.52,44.28 121.09,43.71 127.69,43.71 128.66,42.74 130.16,42.74 130.87,42.03 v2(130.87,41.85)
  IN3 w0.762: v2(45.68,44.98) 45.68,46.73 42.11,50.3 42.11,53.69 41.3,54.5 41.3,55.6
  BOTTOM w0.762: v1(40.65,56.76) v1(41.36,56.76)
+VDDQC: length 12.7
  TOP w0.127: v1(115.78,108.78) 115.82,108.74 R194.2
  IN3 w0.381: v3(127.63,107.22) 127.5,107.22 126.89,107.83 118.21,107.83 117.61,107.23 v3(117.61,107.17)
  BOTTOM w0.254: v3(117.61,107.17) 117.89,107.45 U35.AM40 ; U35.AL23 127.64,107.23 v3(127.63,107.22)
+VIN_VCCGT:
  vias: v1(131.78,159.58) v2(119.28,159.53) v2(119.69,160.17) v2(120.17,159.56) v2(120.58,160.22) v2(121.06,159.58) v2(121.37,160.27) v2(122.89,161.23) v2(122.92,160.45) v2(128.94,159.53) v2(129.22,160.22) v2(129.93,159.53) v2(130.18,160.24) v2(130.94,159.53) v2(131.15,160.24) v2(132.7,160.19)
AVCC33:
  vias: v1(26.09,65.04)
DVDD_IO: length 1.4
  BOTTOM w0.203: 206.3,46.5 205.78,45.98 U23.9
  vias: v1(206.18,50.44)
GND: length 2637.1
  TOP w0.127: C4616.2 31.54,24.66 C4612.2 ; v1(191.7,115.84) 192.08,116.22 193.73,116.22 194.5,115.45 C4207.1 ; C4206.1 191.69,113.99 v1(191.87,113.81) ; v1(16.57,70.38) 16.57,68.73 v1(16.82,68.47) 16.82,68.35 v1(18.47,66.69) 18.73,66.44 20.91,66.44 v1(21.04,66.31) ; v1(19.69,68.19) 18.42,69.46 v1(18.42,70.12) v1(18.42,71.9) 18.42,73.86 v1(18.09,74.19) 18.09,74.49 17.76,74.82 v1(17.33,74.82) v1(16.19,74.82) v1(13.8,74.82) 12.12,74.82 11.99,74.7 U38.3 ; v1(32.57,28.85) v1(32.57,28.21) v1(32.57,27.58) 33.08,27.07 34.22,27.07 34.6,26.69 v1(34.73,26.69) v1(34.73,26.05) 34.47,26.05 33.71,25.29 33.71,20.85 ; v1(32.57,28.85) 32.76,28.66 35.51,28.66 37.61,26.56 43.36,26.56 43.87,26.05 43.87,25.04 44.37,24.54 C4615.2 ; v1(32.57,28.85) 32.57,29.23 32.9,29.56 35.55,29.56 37.84,27.27 44.29,27.27 46.79,24.77 46.79,20.4 ; v1(32.57,28.85) 32.26,28.85 v1(31.53,28.11) 31.32,27.91 31.32,27.05 31.81,26.56 v1(31.81,26.05) ; C319.1 12.75,76.85 v1(14.03,76.85) v1(16.69,76.85) 17.58,76.85 18.73,75.71 18.73,75.54 v1(19.37,74.9) 19.16,74.69 19.16,73.51 v1(19.37,73.3) 19.16,73.09 19.16,71.05 v1(19.32,70.89) 19.16,70.72 19.16,69.97 19.89,69.23 v1(19.94,69.23) ; 31.43,20.59 31.43,22.89 31.31,23.01 v1(31.31,24.02) ; Y4200.4 194.66,111.06 195.26,111.65 195.26,113.56 194.95,113.86 v1(194.5,113.86) ; v1(194.07,110) 191.19,110 190.94,110.26 190.94,111.82 Y4200.2 ; R678.1 v1(153.98,91.33) ; R685.1 v1(153.98,90.44) ; v1(12.38,72.79) v1(13.9,72.79) v1(16.19,72.79) v1(17.33,72.79) 17.33,72.11 v1(17.53,71.9) v1(17.53,70.76) v1(17.53,69.36) 17.53,69.11 19.34,67.3 v1(19.74,67.3) ; v1(11.73,76.48) 11.6,76.35 9.84,76.35 v1(9.33,76.85) 7.93,78.25 v1(7.93,78.38)
  TOP w0.178: U9.3 33.95,118.2 v1(34.09,118.05) ; v1(28.89,121.69) 28.89,121.36 29.64,120.6 U9.19 ; C299.1 118.07,107.41 118.07,106.77 117.81,106.52 v3(117.61,106.52) ; U9.6 v1(34.09,119.4)
  TOP w0.191: PU20.11 39.3,99.08 v1(39.55,99.33) ; PU5.22 159.04,180.51 159.19,180.36
  TOP w0.203: v1(18.09,14.37) 17.58,14.37 17.51,14.44 U24.3 16.69,14.44 16.65,14.49 C502.1 ; v1(18.09,32.53) 17.66,32.53 17.58,32.6 U21.3 ; U28.12 30.05,109.35 v1(29.91,109.49) ; v1(19.74,33.17) 19.58,33 U21.9 ; v1(121.24,108.66) 121.21,108.66 121.11,108.55 C269.1 C262.1 ; v1(108.41,103.87) 107.97,103.43 C239.1 ; v3(120.8,122.28) 121.13,121.94 C181.1 C189.1 ; v1(47.66,56.89) 47.59,56.96 PU21.14 ; U21.8 19.36,32.2 v1(19.69,32.53) ; PU21.1 43.16,57.83 v1(43.11,57.88) ; C313.1 119.86,102.78 v3(120.51,102.78) ; U13.24 21.25,66.95 21.04,66.73 v1(21.04,66.31) ; C205.1 106.1,102.53 v3(105.81,102.83) ; C222.1 v1(133.97,147.33) ; C311.1 122.14,103.76 122.11,103.79 v3(122.11,103.86) ; v1(119.41,108.65) 119.69,108.36 C246.1 ; v3(125.49,102.78) 125.86,102.78 126.49,103.41 C308.1 ; U4513.3 15.55,115.84 v1(15.68,115.72) ; v1(120.33,108.63) 120.33,108.6 120.45,108.48 C235.1 ; v3(120.32,120.66) 120.17,120.51 C227.1 ; U24.9 v1(19.71,14.84) ; 159.19,180.36 159.19,179.95 v1(158.93,179.7) ; U24.8 v1(19.72,14.04) ; C228.1 v1(133.91,148.12) ; C215.1 v1(133.97,146.39)
  TOP w0.254: U16.5 131.22,83.84 131.94,83.12 U16.6 ; VRAM3004.R1 188.81,156.62 v3(188.73,156.53) ; C245.1 119.94,109.87 119.88,109.94 C252.1 119.56,109.46 v1(119.39,109.28) ; v1(134.8,82.01) 135.06,82.27 135.06,83.35 134.77,83.63 U16.7 ; 43.62,20.72 43.62,23.14 v1(44.37,23.9) ; v3(118.56,103.9) 118.71,103.74 C312.1 ; C298.1 126.05,107.36 v3(125.84,107.15) ; U17.5 81.22,83.67 81.06,83.51 81.06,82.09 81.49,81.66 v1(81.59,81.66) ; v1(124.9,108.65) 124.9,108.62 124.73,108.46 C297.1
  TOP w0.279: U22.14 20.76,25.3 21.01,25.55 v1(21.14,25.55) ; U18.17 17.23,45.39 16.82,44.98 v1(16.69,44.98)
  TOP w0.305: VRAM3002.K13 213.42,146.58 v3(213.42,146.58) ; v1(193.22,163.76) 192.58,163.76 VRAM3004.F5 ; v3(218.17,140.14) VRAM3002.R4 ; v3(199.33,160.21) 198.93,160.61 VRAM3004.K13 198.55,161 v3(198.55,161.01) ; v3(211.02,140.97) 211.02,140.93 VRAM3002.G5 ; v3(172.09,156.19) 171.69,156.59 VRAM3001.C11 ; VRAM3001.L5 176.49,163.01 v3(176.11,163.4) ; VRAM3004.C13 v3(198.53,165.81) ; VRAM3001.K13 170.46,161.82 v3(170.52,161.82) ; v1(171.25,98.06) 171.6,97.72 CN2.14 ; VRAM3001.P10 172.51,165.39 v3(172.88,165.76) ; v3(169.74,160.19) 169.74,160.24 170.09,160.59 VRAM3001.H13 ; VRAM3004.A12 v3(198.51,167.44) ; VRAM3004.N14 v3(200.11,158.6) ; v3(196.93,166.62) VRAM3004.C11 ; VRAM3007.H13 v3(214.18,117.64) ; VRAM3007.U3 206.19,125.64 v3(206.19,125.63) ; VRAM3004.B10 v3(196.15,167.4) ; v3(219,146.58) 219,146.55 VRAM3002.U12 ; v3(170.51,168.17) 170.51,168.17 VRAM3001.U12 ; v3(211,144.96) 211,144.95 VRAM3002.G10 ; VRAM3007.C11 218.18,120.03 v3(218.19,120.03) ; v3(218.98,124.04) VRAM3007.B5 ; VRAM3002.T10 218.99,144.17 v3(218.99,144.17) ; v3(180.27,166.27) 179.76,166.27 VRAM3001.R1 ; v3(207.07,123.97) 207.07,124.12 VRAM3007.T5 ; VRAM3001.E12 170.89,158.19 v3(171.29,157.79) ; VRAM3001.D10 172.88,157.78 v3(172.89,157.78) ; v3(209.85,128.19) 209.85,127.7 VRAM3007.N1 ; v3(210.2,139.36) VRAM3002.E3 ; v3(168.9,154.58) 168.9,154.6 VRAM3001.A14 ; v3(191.28,157.01) 191.33,157.01 VRAM3004.R4 ; v3(200.19,157) 200.11,157 VRAM3004.R14 ; v3(179.31,155.37) VRAM3001.A1 ; v3(215.79,140.92) 215.44,140.56 VRAM3002.M5 ; v3(171.29,156.19) 170.89,156.59 VRAM3001.C12 170.89,156.59 v3(170.49,156.99) ; v3(209.36,118.43) 209.38,118.43 VRAM3007.N12 ; v3(206.19,148.18) 206.19,148.16 VRAM3002.A14 ; VRAM3007.N3 210.16,126.41 v3(210.16,126.43) ; v3(207.8,146.56) VRAM3002.C13 ; VRAM3004.A14 199.95,168.03 v3(200.31,168.03) ; v3(200.34,164.62) 200.33,164.62 VRAM3004.E14 ; VRAM3004.C14 200.19,166.22 v3(200.29,166.32) ; VRAM3004.U1 188.89,154.58 v3(188.78,154.58) ; v3(192.13,158.59) 192.53,158.99 VRAM3004.M5 ; v3(215.8,138.56) 216.2,138.96 VRAM3002.N3 ; v3(171.29,154.58) 171.29,154.59 VRAM3001.A12 ; VRAM3007.K13 212.58,118.43 v3(212.58,118.49) ; CN2.8 v1(168.6,98.06) ; VRAM3001.N3 178.48,164.2 v3(178.48,164.16) ; v3(219.5,148.33) 219.5,147.87 VRAM3002.U14 ; VRAM3004.C3 190.93,166.22 v3(191.33,166.62) ; v3(190.56,156.23) 190.93,156.6 VRAM3004.R3 ; v3(180.06,160.99) 180.06,160.96 VRAM3001.H1 ; v3(176.89,158.59) 176.49,158.99 VRAM3001.F5 ; v3(176.89,155.39) 176.49,155.79 VRAM3001.B5 ; v3(215.18,143.94) 215.18,144.35 VRAM3002.M10 ; VRAM3007.R12 207.79,118.44 v3(207.79,118.43) ; v3(189.73,161.82) VRAM3004.H2 ; VRAM3007.C1 v3(217.78,128.18) ; v3(219.51,128.19) 219.51,127.76 VRAM3007.A1 ; v3(176.08,167.38) 176.47,166.99 VRAM3001.T5 ; v3(218.99,140.97) 218.99,140.96 VRAM3002.T5 ; VRAM3007.F5 215.38,124.02 v3(215.25,123.89) ; v3(218.18,118.43) VRAM3007.C13 ; v3(209.39,148.13) 209.42,148.13 VRAM3002.E14 ; VRAM3001.G5 176.19,159.79 v3(175.78,159.38) ; v3(192.98,159.43) 192.91,159.43 VRAM3004.L5 ; VRAM3002.L5 214.98,140.94 v3(214.98,140.94) ; v3(218.2,144.96) 218.19,144.96 VRAM3002.R11 ; VRAM3007.E14 215.79,116.84 v3(215.76,116.84) ; v3(219.56,136.82) 219.56,137.2 VRAM3002.U1 ; v3(215.91,128.21) 215.91,127.91 VRAM3007.E1 ; VRAM3002.H1 212.58,136.98 v3(212.61,136.98) ; VRAM3001.G10 172.5,159.79 v3(172.88,159.41) 172.88,159.38 VRAM3001.F10 ; v3(178.25,168.4) 178.09,168.24 VRAM3001.U3 ; VRAM3007.M5 210.19,124.83 v3(210.19,124.83) ; v3(211.8,146.56) VRAM3002.H13 ; U37.3 v1(9.82,89.54) ; VRAM3004.T10 v3(196.91,156.19) VRAM3004.R11 ; VRAM3004.M10 v3(196.91,159.39) 196.53,159.77 VRAM3004.L10 ; v3(208.6,138.56) 208.2,138.96 VRAM3002.C3 ; v3(199.35,161.01) 199.35,161 VRAM3004.K14 ; VRAM3001.M10 172.49,163.79 172.55,163.85 v3(173.07,163.85) ; v3(172.88,167.38) 172.49,166.99 VRAM3001.T10 ; VRAM3001.H14 168.89,160.2 v3(168.89,160.19) ; VRAM3001.R11 171.69,166.19 v3(172.09,166.59) ; VRAM3007.A14 v3(218.99,116.84) ; VRAM3004.B5 v3(193.16,167.02) ; VRAM3007.U12 206.19,118.44 v3(206.19,118.42) ; v3(177.69,166.59) 177.69,166.59 VRAM3001.R3 ; v3(214.31,148.23) 214.27,148.23 VRAM3002.K14 ; VRAM3004.H1 189.25,162.22 v3(188.91,161.87) ; v3(210.99,120.03) 210.99,120.04 VRAM3007.L10 ; v3(208.6,145.76) VRAM3002.C11 ; v3(217.84,136.78) 217.8,136.82 VRAM3002.R1 ; v3(130.4,104.52) 130.4,103.95 R681.1 ; v3(192.89,155.4) 192.53,155.76 VRAM3004.T5 ; VRAM3007.R1 208.15,127.67 v3(208.15,128.18) ; v3(219,139.36) 219,139.35 VRAM3002.U3 ; v3(217.37,144.17) 217.37,144.18 VRAM3002.P10 ; v3(218.2,139.36) 217.8,138.96 VRAM3002.R3 ; v3(176.89,166.59) VRAM3001.R4 ; v3(192.91,162.64) VRAM3004.G5 ; v3(171.29,166.59) 170.92,166.23 170.89,166.19 VRAM3001.R12 ; v3(214.22,144.12) 214.6,144.49 VRAM3002.L10 ; VRAM3001.U1 179.87,167.97 v3(180.25,167.97) ; VRAM3007.U1 206.58,127.96 v3(206.82,128.19) ; v3(214.18,123.97) 214.18,124.03 VRAM3007.G5 ; v3(168.7,164.41) 168.88,164.59 VRAM3001.N14 ; VRAM3001.R14 169.26,166.17 v3(168.74,166.17) ; v3(211.02,144.16) 210.99,144.16 VRAM3002.F10 ; VRAM3001.K14 168.89,161.79 v3(168.7,161.79) ; VRAM3002.N14 216.2,148.14 v3(216.02,148.31) ; VRAM3001.H2 v3(179.29,160.19) ; v3(178.49,156.99) 178.09,156.59 VRAM3001.C3 ; v3(197.74,154.63) VRAM3004.U12 ; v3(206.99,120.03) 206.99,120.04 VRAM3007.T10 ; v3(190.53,154.61) VRAM3004.U3 ; CN2.10 v1(169.6,98.06) ; v3(177.69,156.99) 177.29,156.59 VRAM3001.C4 ; v3(217.39,118.44) VRAM3007.C12 ; v3(207.77,148.18) 207.77,148.18 VRAM3002.C14 ; v3(206.98,136.98) 206.98,136.98 VRAM3002.A1 ; v3(213.44,137.74) 213.44,137.8 VRAM3002.K2 ; VRAM3001.E3 178.09,158.19 v3(177.69,158.59) ; VRAM3004.A3 190.93,167.81 v3(190.55,168.19) ; VRAM3007.F10 215.38,120.45 v3(215.79,120.86) ; v3(208.59,136.98) 208.58,136.98 VRAM3002.C1 ; v3(210.17,140.16) 210.2,140.16 VRAM3002.F5 ; VRAM3004.R12 v3(197.74,156.23) ; v3(208.6,139.36) 208.2,139.76 VRAM3002.C4 ; VRAM3002.N12 216.59,145.77 v3(216.61,145.77) ; v3(180.16,161.84) 180.06,161.84 179.71,162.19 VRAM3001.K1 ; VRAM3007.P10 208.59,120.04 v3(208.59,120.03) ; VRAM3002.H2 212.2,138.17 v3(211.8,138.56) ; VRAM3002.H14 211.78,148.17 v3(211.78,148.23) ; VRAM3001.C14 168.9,156.2 v3(168.9,156.17) ; U40.1 v1(14.04,89.55) ; v3(190.56,158.59) VRAM3004.N3 ; VRAM3002.R12 217.82,146.16 v3(218.2,146.54) ; VRAM3002.A3 206.6,138.97 v3(206.2,139.36) ; CN2.12 v1(170.6,98.04) ; v3(172.89,156.2) 172.89,156.19 VRAM3001.B10 ; VRAM3002.E1 210.18,136.98 v3(210.2,136.98) ; VRAM3001.C1 180.06,156.96 v3(180.06,156.99) ; VRAM3002.K1 213.44,137 v3(213.44,136.98) ; VRAM3007.C4 218.17,124.85 v3(218.17,124.81) ; R635.1 130.35,102.54 v3(130.61,102.8) ; VRAM3001.N12 170.89,164.64 v3(170.53,164.99) ; VRAM3004.N12 198.13,158.21 v3(198.53,157.81) ; v3(211.82,127.22) 211.82,127.2 VRAM3007.K2 ; VRAM3007.R3 207.79,125.64 v3(207.79,125.63) ; VRAM3001.N1 v3(180.3,164.59) ; v3(188.78,167.94) 189.2,167.94 VRAM3004.A1 ; v3(168.72,167.87) 169.21,167.87 VRAM3001.U14 ; VRAM3007.B10 v3(218.99,120.84) ; VRAM3004.C1 v3(188.81,166.22) ; v3(197.73,165.07) 197.73,165.01 VRAM3004.E12 ; v3(170.49,156.19) 170.09,156.59 VRAM3001.C13 ; v3(199.3,162.59) VRAM3004.H13 ; v3(210.19,120.03) 210.19,120.04 VRAM3007.M10 ; VRAM3007.K1 v3(212.18,128.16) ; VRAM3007.A3 v3(219.86,126.51) ; U37.1 v1(11.12,89.54) ; VRAM3002.R14 217.8,148.29 v3(217.81,148.31) ; VRAM3007.H1 v3(214.18,127.24) 214.18,127.23 VRAM3007.H2 ; VRAM3007.D10 217.38,120.84 v3(217.41,120.84) ; v3(200.1,162.59) VRAM3004.H14 ; VRAM3007.A12 v3(218.99,118.44) ; v3(196.91,157.79) VRAM3004.P10 ; v3(217.36,116.84) 217.39,116.84 VRAM3007.C14 ; VRAM3002.B10 207.4,144.55 v3(207.79,144.16) ; v3(209.4,144.16) 209.39,144.16 VRAM3002.D10 ; VRAM3007.E12 215.79,119.23 v3(215.79,119.25) ; VRAM3004.F10 196.15,163.44 v3(196.15,163.44) ; v3(188.76,164.41) 189.13,164.41 VRAM3004.E1 ; VRAM3007.H14 v3(214.18,116.84) ; v1(182.17,36.47) 182.03,36.61 U8.3 ; v3(206.17,116.82) 206.17,116.82 VRAM3007.U14 ; v3(207.79,124.82) 207.79,124.84 VRAM3007.R4 ; VRAM3007.R14 v3(207.77,116.82) ; VRAM3004.C12 v3(198.53,166.62) ; v3(214.99,120.03) VRAM3007.G10 ; v3(177.69,154.59) VRAM3001.A3 ; v3(180.06,158.59) 180.06,158.56 179.69,158.19 VRAM3001.E1 ; VRAM3002.N1 216.2,136.78 v3(216.16,136.75) ; v3(173.03,163.21) 172.71,163.21 VRAM3001.L10 ; v3(191.36,164.99) 191.31,164.99 VRAM3004.E3 ; VRAM3004.K1 189.33,160.59 v3(189.73,160.19) 189.73,160.21 VRAM3004.K2 ; VRAM3004.N1 189.3,158.19 v3(188.71,158.19) ; v3(168.89,157.79) VRAM3001.E14 ; v3(208.6,146.56) VRAM3002.C12 ; U40.3 v1(12.74,89.55) ; v3(210.98,123.99) 210.98,124.03 VRAM3007.L5 ; v3(211.81,116.86) VRAM3007.K14 ; v3(196.95,163.44) VRAM3004.G10 ; v3(210.2,146.56) VRAM3002.E12 ; VRAM3002.A12 v3(207,146.56) ; VRAM3007.N14 v3(209.37,116.82) ; v3(200.26,155.4) 200.11,155.4 VRAM3004.U14 ; VRAM3007.R11 208.18,119.61 v3(207.79,119.21) ; v3(216.59,125.63) VRAM3007.E3 ; v3(207,140.16) VRAM3002.B5 ; v3(179.29,161.79) VRAM3001.K2 ; VRAM3004.D10 v3(196.15,165.8) ; v3(218.19,125.63) VRAM3007.C3 ; v3(192.13,166.62) VRAM3004.C4 ; v3(176.9,164.2) VRAM3001.M5
  TOP w0.381: v1(29.37,106.27) 29.13,106.03 C4817.2 ; PR3.1 154.89,184.68 v1(155.43,184.68) ; v1(133.99,170.91) 134.01,170.91 134.32,170.6 PC7.1 PR342.1 ; PR10.1 157.88,171.56 v2(157.64,171.8) ; C4676.1 R11075.1 211.31,152.48 v1(211.31,152.8) ; v1(134.7,179.06) 134.24,178.6 PC35.2 ; C1266.2 147.61,47.64 147.38,47.87 v1(147.02,47.87) ; C230.2 142.03,115.71 142.81,116.49 C265.2 v1(142.93,117.11) ; R158.1 100.25,119.27 99.93,119.6 v1(99.93,119.62) ; v1(47.66,56.89) 47.66,57.2 47.72,57.26 47.72,57.27 48.16,57.72 48.18,57.72 48.4,57.94 PR250.1 PC217.2 ; R11210.2 31.68,113.71 v1(32.14,113.25) ; R564.1 142.04,121.76 v1(141.46,122.35) ; v1(143.97,183.69) 143.97,183.87 144.28,184.17 PC46.1 144.16,184.49 143.41,185.25 PC139.2 143.26,185.22 PC41.2 ; PR117.1 217.72,172.71 v1(216.79,172.71) ; v1(152.89,185.87) 152.84,185.87 152.51,186.2 PC6.1 ; C4041.2 v1(185.6,113.19) ; PR265.2 47.46,54.54 v1(47.1,54.91) ; PC14.2 140.85,167.65 140.06,167.65 v1(140.01,167.7) 139.68,167.37 139.68,167.13 139.38,166.82 139.16,166.82 PR180.2 ; PC196.2 PC203.2 43.06,52.37 42.83,52.14 42.83,51.81 v1(42.86,51.79) ; v1(151.09,165.55) 149.97,166.67 PC8.2 150.34,168.5 150.79,168.05 PD1.2 ; U4512.7 172.27,83.73 172.42,83.59 v1(172.42,83.33) ; R178.2 R174.1 141.04,112.88 140.65,112.49 139.59,112.49 v3(139.35,112.73) ; C4748.1 28.63,67.71 29.01,68.09 v1(29.01,68.35) ; v1(158.78,176.47) 158.78,175.81 159.09,175.51 PC130.1 ; v1(155.86,172.61) 155.61,172.87 PC132.1 ; R764.1 v1(147.63,109.37) ; v1(166.3,161.06) 166.11,161.06 165.67,160.62 C4534.2 ; U36.3 11.41,81.05 11.72,80.74 v1(11.72,80.41) ; v1(106.36,129.43) 106.61,129.18 R156.1 R534.1 ; v1(158.93,179.7) 158.91,179.67 PC123.1 ; PC125.1 160.48,176.11 PR15.1 160.42,176.25 161.12,176.25 v1(161.45,176.58) ; v1(153.6,185.82) 153.47,185.95 PC3.1 ; v1(137.72,167.48) 138.05,167.48 138.35,167.78 PC10.1 138.35,168.11 139.05,168.8 PC15.2 ; PC23.2 146.17,174.95 PC135.2 146.18,174.95 146.41,174.95 146.94,175.48 147.5,175.48 v1(147.78,175.2) ; PC9.2 153.32,168.48 153.76,168.03 PD2.2 v1(154.19,165.6) ; U38.3 v1(9.4,74.7) ; R778.2 v1(145.6,108.22) ; C4206.1 191.69,115.83 v1(191.7,115.84) ; R162.1 103.3,120.4 v3(103.72,120.81) ; R646.1 132.35,102.37 v3(132.7,102.73) ; v1(145.95,184.09) 146.44,184.58 PC33.2 ; PC25.1 150.4,177.95 v1(150.7,177.64) ; R98.2 127.53,136.33 v1(127.28,136.07) ; PC81.1 49.44,53.93 48.66,53.15 PC70.1 ; v1(194.5,113.86) C4207.1 ; C4529.2 165.93,159.15 v1(166.3,159.15) ; PR13.1 150.76,179.62 v1(150.37,179.62) ; R364.2 16.32,28.86 v1(15.68,28.21) ; PC11.2 136.69,169.17 v1(137.01,169.49) 137.09,169.56 137.09,170.42 PC21.1 ; PR11.1 150.73,181.33 v1(150.37,181.68) ; C261.1 C256.2 151.95,112.03 v1(151.82,111.91) ; v1(188.06,121.52) 188.14,121.61 C4027.2 ; C460.2 20.26,32.78 19.87,33.17 v1(19.74,33.17) ; R400.2 v1(213.42,42.56) ; R199.1 v1(149.66,104.79) ; v1(135.46,180.22) 135.33,180.09 PR206.2 ; R692.2 225.49,107.07 v1(225.1,107.46) ; C268.2 C292.2 v1(151.82,108.1) ; v1(144.71,178.61) 145.1,178.22 PC28.2 ; R256.2 v1(151.69,104.79)
  TOP w0.508: R10927.2 131.37,57.04 131.69,57.35 v1(132.11,57.35) ; C4542.2 164.3,161.99 v1(164.26,161.94) ; C4672.1 v1(211.12,132.62) C4678.2 ; v1(115.5,58.95) 115.21,58.95 114.59,59.57 R10930.2 ; v1(122.98,102.78) 122.91,102.71 C328.2 ; PQ11.1 43.14,33.45 v1(43.36,33.67) ; C4765.1 v1(28.5,110.13) ; PC180.2 39.93,92.58 v1(40.24,92.27) ; v1(19.88,7.89) 20.13,8.15 C517.1 ; v1(131.76,171.85) 131.25,172.36 PC6228.2 ; PU4.5 v1(53.96,115.97) ; v3(128.49,107.8) 128.44,107.85 C288.2 ; R4548.1 187.08,172.4 187.11,172.4 v1(187.48,172.77) 187.89,172.36 R4542.2 ; v1(164.24,161.31) 164.64,161.31 R4552.1 ; C754.1 183.65,57.05 184.41,57.81 v1(184.41,57.93) ; C1248.2 88.7,52.51 v1(88.7,52.68) ; C361.1 40.75,80.11 v1(40.7,80.16) ; C747.2 181.16,53.13 180.87,52.85 v1(180.48,52.85) ; C323.2 127.56,102.38 v3(127.97,102.78) ; R11262.2 v1(36.76,63.77) ; C4697.1 v1(217.99,152.8) ; C1324.2 148.9,58.95 v1(149.79,58.06) ; v1(23.68,28.72) 23.56,28.84 C475.1 ; v1(47.68,70.38) 48.07,70.77 C4782.1 ; C3001.1 109.46,34.15 v1(108.79,34.82) ; PQ15.1 56.95,70.15 v1(57.44,70.63) ; PC109.1 v1(51.11,70.12) ; C4698.2 v1(224.08,127.02) ; v1(208.34,112.29) 208.34,112.79 C4691.1 ; C352.1 158.3,90.44 v1(157.79,90.95) 157.28,90.44 C322.2 ; PC103.1 v1(48.56,35.84) ; v1(75.11,107.36) 74.89,107.59 PQ6.1 ; v1(79.18,49.04) 78.53,49.04 R301.1 ; R532.2 97.94,128.68 97.59,129.03 v1(97.59,129.31) ; C4754.1 20.4,62.15 v1(20.25,62) ; R4531.1 193.34,172.99 v1(193.6,172.99) ; PQ40.1 150.53,174.49 v1(150.93,174.9) ; C1247.2 143.91,54.47 143.44,53.99 v1(143.44,53.74) ; C3000.1 112.71,28.68 v1(112.8,28.59) ; v1(35.74,80.2) 35.52,80.2 35.11,79.79 35.11,79.28 C365.2 ; C386.2 v1(20.76,42.31) ; PU4.4 v1(53.96,107.89) ; v1(159.7,178.89) 160.3,178.29 PC122.2 ; Q15.1 v1(25.96,105.94) ; R11106.1 v1(210.5,112.29) ; v1(183.44,36.6) 183.58,36.46 R130.1 ; v1(37.65,52.22) 37.78,52.09 PQ6057.1 ; v1(44.51,68.98) C363.1 ; v1(112.09,45.41) 111.74,45.41 111.18,44.85 111.18,44.22 110.8,43.83 C1258.1 ; C250.2 144.32,113.9 v1(144.28,113.94) ; v1(34.65,66.44) 35.02,66.81 C4598.1 ; C4708.2 223.35,131.97 223.74,132.36 v1(223.74,132.71) 223.74,133.08 223.45,133.37 C4670.2 ; C4554.2 v1(185.6,172.87) ; C168.1 176.96,35.7 v1(177.5,36.24) ; R11076.1 v1(223.96,145.56) ; C4614.2 v1(38.28,24.66) ; v1(34.73,26.05) 34.73,25.56 C4617.2 ; R587.2 143.58,108.6 143.19,108.99 v1(142.83,108.99) ; C4038.1 174.24,126.62 v1(173.82,126.62) ; C330.2 228.66,105.58 v1(228.81,105.73) ; C334.1 v1(16.19,72.79) ; v1(141.32,110.28) 141.93,110.28 C349.2 C348.1 ; R11264.1 v1(41.97,79.9) ; C4513.1 v1(184.84,169.83) C4517.1 ; v1(81.21,13.61) C548.2 ; C4605.1 43.36,75.2 v1(44,75.84) ; v1(156.22,59.13) 156.36,58.98 C1316.2 156.65,58.02 R10943.2 ; v1(191.87,113.81) Y4200.2 ; C4767.1 v1(19.49,113.56) ; C4019.2 v1(170.87,114.83) ; v1(216.85,112.29) 217.35,112.8 R11089.1 ; R11083.1 v1(223.96,143.53) ; PC193.2 206.69,102.75 v1(206.69,102.76) ; C4040.2 176.24,139.87 v1(176.72,139.39) 176.72,139.33 C4037.1 ; C1330.2 101.49,50.36 v1(101.74,50.12) ; v1(71.3,10.18) 70.7,10.78 D23.1 ; v1(164.17,186.28) 163.91,186.02 PC2.2 163.11,185.51 162.56,184.95 PC116.1 ; v1(204.02,66.57) 203.09,67.5 PAD3.1 ; v1(25.96,117.11) 26.22,117.37 C4775.2 ; v1(116.36,34.89) 116.01,34.54 C4819.1 ; C4519.1 v1(168.2,172.61) ; C1264.2 111.91,60.82 111.46,60.37 111.03,60.37 111.03,60.36 v1(110.95,60.36) ; v1(115.69,64.9) 115.69,64.22 116.13,63.77 C1323.2 ; v1(136.12,52.75) 135.53,52.16 C1246.2 ; R376.1 23.42,26.94 v1(23.68,27.2) ; v3(112.09,107.1) 111.67,107.1 111.43,107.34 C291.2 ; C1337.2 v1(90.75,67.47) ; C4116.2 v1(166.17,139.47) ; C755.2 197.41,188.23 v1(197.29,188.11) ; v1(223.96,142.77) 223.59,142.77 R11069.1 ; v1(81.21,12.34) C546.2 ; R4209.1 v1(186.24,113.81) ; PR147.2 43.77,30.57 v1(44.71,30.57) ; v1(15.53,32.47) 15.58,32.52 C462.1 ; v1(126.72,100.48) 126.09,101.11 C327.2 ; C326.2 119.59,100.74 v1(119.33,100.48) ; C4537.2 v1(198.18,172.45) ; v1(188.02,105.07) 187.89,105.2 PQ17.1 ; C318.2 117.58,102.33 v3(118.03,102.78) ; v1(20,54.25) 20.49,53.75 R11276.2 ; v1(72.19,15.64) 72.95,14.88 D28.1 ; C1321.2 114.83,66.69 115.21,66.31 v1(115.69,66.31) ; C4540.2 201.1,172.62 v1(201.1,172.87) ; C4107.1 v1(204.53,166.9) ; R11200.2 v1(18.34,113.56) ; v1(189.03,172.74) C4533.2 ; v1(224.72,140.74) 223.59,140.74 C4680.2 ; C4608.2 v1(16.19,42.31) ; R4314.1 v1(196.91,115.84) ; C4530.2 v1(204.53,167.91) ; R161.2 95.43,118.64 95.05,119.02 v1(95.05,120.03) ; R4012.2 229.99,114.4 v1(230.61,115.03) ; v1(119.94,172.1) 119.7,171.86 C578.1 ; C1250.2 126.73,44.25 v1(127.15,44.68) ; C4607.2 v1(21.65,42.31) ; v1(137.85,80.92) 137.85,81.38 PAD6.1 ; C4751.1 v1(21.52,62.88) ; v1(74.61,19.1) BT1.2 ; C577.1 118.29,172.18 118.09,172.38 118.09,172.43 v1(118.04,172.49) ; 39.93,31.52 v1(40.85,31.52) ; C4702.2 v1(215.97,132.62) C4700.2 ; C4032.1 175.47,126.72 v1(175.47,126.71) 175.06,126.3 C4211.1 ; v1(79.18,48.28) 78.92,48.03 C382.2 ; v1(68.38,103.07) 69.09,103.78 PQ8.1 ; C4552.2 202.84,160.4 v1(202.32,160.4) ; C511.2 v1(20,18.2) ; Q4509.1 225.98,119.54 v1(226.02,119.58) ; v1(164.24,164.48) 164.51,164.48 R4555.1 ; v1(48.7,32.66) 48.57,32.53 PQ3.1 ; D24.2 v1(61.26,15.51) ; R11277.2 v1(15.55,54.38) ; PU4.6 v1(52.69,115.97) ; v1(31.81,26.05) 31.81,25.93 32.19,25.55 C4616.2 ; PC126.2 157.01,172.43 v2(157.64,171.8) ; v1(32.19,73.29) 31.93,73.04 C4596.2 ; v1(25.33,74.11) R11188.1 ; C1249.2 C1275.2 C1251.2 145.88,42.18 145.34,41.65 v1(145.34,41.29) ; v1(94,54.11) 94.71,54.81 C1312.2 ; v1(39.1,65.81) 39.05,65.86 C760.2 ; C27.1 C16.1 116.33,167.65 v1(116.01,167.33) ; C339.1 v1(197.29,189.12) ; v1(16.57,70.38) R222.2 C337.1 ; R4309.1 v1(195.89,115.84) ; D25.2 v1(64.69,15.51) ; C4514.2 v1(184.84,156.6) C4518.1 ; HOLE19.1 14.4,125.5 17.33,125.5 ; C4521.1 204.15,158.9 v1(204.55,158.9) ; C4786.2 18.97,55.53 v1(18.98,55.52) ; EC42.2 100.39,67.47 v1(100.41,67.44) ; v1(47.81,38.88) 48.25,39.33 PC6100.1 ; C4785.2 v1(20.5,56.28) ; v1(204.56,132.57) 204.43,132.45 C4119.1 ; C4706.2 v1(223.92,134.13) ; v1(190.33,115.84) 190.33,115.24 R4310.1 ; R11068.1 223.56,127.93 v1(224.08,127.93) ; v1(146.61,39.64) 146.61,40.27 EC40.2 ; PR158.2 51.51,69.39 v1(51.14,69.39) ; C450.1 v1(20,40.28) ; v3(114.85,107.12) 114.45,107.52 C276.1 ; R4547.1 v1(204.53,164.74) ; v1(37.9,92.86) PC214.2 ; v1(35.74,79.52) 35.87,79.39 C354.2 ; v1(166.99,108.96) 166.99,109.8 Q4001.1 ; v1(117.53,164.36) 117.01,164.36 C9.1 ; C4597.1 v1(31.93,67.08) 31.3,67.08 v1(30.66,67.71) ; C458.2 19.75,35.33 v1(19.74,35.33) ; v1(67.87,100.6) 68,100.73 PC101.1 ; R11073.1 213.81,133.24 v1(213.81,132.61) ; v1(109.37,66.44) C1318.2 ; R11209.2 v1(26.22,119.4) ; C381.2 v1(76.65,45.36) ; v1(44.71,31.26) 44.76,31.31 PR150.2 ; v1(179.38,86.25) 177.3,84.17 PAD5.1 ; PC61.1 47.54,44.45 v1(47.43,44.34) ; R145.1 136.72,120.1 v3(136.78,120.03) ; C4677.2 v1(218,132.62) C4681.2 ; C4609.2 v1(19.87,42.31) ; C4555.2 v1(184.84,165.76) C4551.2 ; v1(44,72.22) 43.54,72.22 C4606.1 ; PQ13.1 v1(40.42,112.29) ; C4536.2 v1(184.84,160.67) C4531.2 ; v1(46.79,18.56) 46.79,20.4 ; C797.2 R784.2 180.88,38.5 v1(180.24,39.14) ; PR54.2 46.73,45.07 v1(46.45,45.36) ; v1(19.23,54.38) 19.23,54 R11273.2 ; v1(147.5,117.49) 147.5,117.11 147.13,116.74 C314.2 ; C4673.2 223.46,130.99 v1(224.08,131.62) ; C4667.2 v1(207.06,132.62) C4696.2 ; v1(35.62,53.23) 34.85,52.47 PQ6058.1 ; R377.2 v1(23.68,27.96) ; C4612.2 v1(31.31,24.02) ; v1(135.89,61.68) 135.44,61.68 135.02,62.1 C1308.2 ; C1322.2 v1(156.36,64.31) 156,64.66 C1338.2 ; v1(180.17,172.54) 179.62,171.99 R4543.2 ; C1259.2 124.9,39.76 v1(124.9,39.52) ; C4684.1 223.84,115.72 v1(224.11,115.72) ; C551.2 v1(81.21,14.88) ; v1(177.35,172.61) 177.35,172.42 177.78,171.99 C4524.1 ; C764.2 v1(220.65,72.15) ; R4532.1 v1(164.27,165.25) ; v1(184.84,163.6) R4554.1 ; C556.2 v1(71.56,15.64) ; PR82.1 66.46,75.24 v1(67.42,76.19) ; C1263.2 94,50.89 v1(93.22,50.12) ; R4533.1 v1(172.78,172.61) ; PQ5.1 69.75,92.45 v1(69.14,91.84) ; R11100.1 v1(213.92,152.8) ; v1(32.99,73.3) 32.99,72.71 C244.1 ; C4539.2 v1(170.49,172.61) ; C518.1 17.45,8.15 v1(17.7,7.89) ; C505.2 v1(17.45,18.2) ; R4311.1 187.25,116.15 v1(187.89,116.78) ; C1313.2 116.3,67.33 v1(115.66,67.96) ; v1(197.41,192.17) C753.2 ; C4549.2 v1(182.05,172.74) ; v3(117.58,119.98) 117.13,119.53 C282.1 ; C748.1 v1(151.95,89.55) ; C1270.2 146.41,45.24 v1(145.6,45.24) ; R11102.1 v1(224.08,122.19) ; C4603.2 v1(44.51,71.27) ; PQ9.1 v1(41.84,116.22) ; C380.2 v1(78.42,45.99) ; PC65.2 v1(49.51,51.58) ; PR119.2 v1(37.42,45.74) ; v1(145.34,65.04) 145.69,64.7 C1328.2 ; v2(22.69,36.85) U20.2 21.04,36.85 v2(20.73,36.55) ; R10877.2 127.95,46.37 127.52,45.95 v1(127.15,45.95) ; R4556.1 164.34,157.37 v1(164.22,157.5) ; D26.2 v1(52.63,15.51) ; PC74.1 v1(49.49,50.18) ; C804.1 v1(121.46,173.5) ; PC210.2 v1(39.17,101.87) ; R11258.2 v1(39.17,63.77) ; C4682.2 v1(224.08,118.13) ; v1(21.85,18.11) 21.85,20.6 CN4.13 ; v1(37.37,23.59) CN4.3 ; PC88.2 64.31,21.24 63.81,21.74 v1(63.68,21.74) ; C778.2 187.38,35.7 C482.2 188.02,35.61 v1(188.55,35.07) ; C1255.2 125.82,39.68 v1(125.66,39.52) ; C4546.2 v1(184.84,167.8) C4541.2 ; v1(156.17,60.4) 155.77,60 C1326.2 ; PQ14.1 v1(45.14,108.1) ; C469.1 v1(23.7,31.27) ; R4553.1 v1(164.22,158.39) ; PC71.2 v1(36.05,45.74) ; v1(50.17,51.99) 49.18,52.98 PC70.1 ; v1(44.05,72.97) 44.79,72.97 Y1.4 ; R563.1 v1(145.6,129.46) ; v1(29.77,21.2) 29.87,21.3 CN4.6 ; R213.2 v1(17.33,74.82) ; C4773.2 v1(26.22,118.51) ; R11092.1 223.68,123.21 v1(224.06,122.83) ; v1(19.51,21.51) 19.8,21.22 C497.1 ; R10895.2 v1(127.82,39.52) ; v1(68,107.84) 68.26,107.59 PR140.2 ; C337.1 15.01,71.13 14.51,70.63 v1(11.61,70.63) C336.1 v1(10.85,71.38) 9.21,71.38 v1(8.69,71.9) v1(7.68,72.92) 7.17,73.43 CN7.6 ; C337.1 v1(15.42,70.38) ; C4604.2 v1(44.51,70) ; C4703.1 v1(209.09,132.62) C4693.1 ; R6308.2 C4618.1 35.62,26.15 35.07,26.69 v1(34.73,26.69) ; C1272.2 138.77,52.89 v1(138.43,53.22) ; v1(138.43,53.99) 138.14,54.29 C1334.2 ; C4690.1 v1(220.03,132.62) C4679.1 ; C451.1 v1(18.98,40.28) ; R219.2 v1(17.33,72.79) ; v1(123.5,41.55) 123.5,41.96 124.01,42.47 C1262.2 ; v1(224.72,141.37) 224.59,141.5 C4671.2 ; C333.1 v1(12.38,72.79) ; C1257.2 148.66,47.55 147.94,46.84 v1(147.94,46.75) ; C368.1 v1(47.94,65.17) ; C759.1 C756.1 206.3,188.36 206.3,188.68 v1(206.61,189) ; C345.1 206.1,192.25 v1(205.62,191.76) 205.14,192.25 C344.1 ; C765.2 v1(220.91,67.84) ; R4313.1 v1(189.29,115.84) ; C346.1 v1(197.29,190.14) ; v1(220.15,112.91) C4699.2 R11090.1 ; C750.2 v1(151.95,93.37) ; PC115.1 v1(164.22,187.47) ; C4668.1 v1(219,152.8) ; C4527.1 v1(184.84,158.63) C4522.1 ; v1(100.41,64.92) 100.4,64.91 C1332.2 ; C320.1 v1(16.19,74.82) ; R4211.1 v1(188.27,115.84) ; v1(17.74,28.82) 17.74,29.13 18.22,29.61 C483.2 ; C4774.2 v1(35.5,121.69) ; v1(42.35,67.33) C4599.1 ; C424.2 v1(25.71,36.72) ; C4210.1 176.27,125.89 v1(176.66,125.5) ; PC223.2 v2(50.98,92.68) ; C537.2 206.3,40.79 v1(206.43,40.91) ; C290.2 110.56,107.4 v3(110.26,107.11) ; R11084.1 v1(216.97,152.8) ; v3(191.45,141.62) 190.69,140.87 R4118.1 ; v1(170.53,124.12) 170.53,123.87 171.16,123.24 C4204.2 ; C4784.1 v1(17.07,42.31) ; 21.85,5.8 v1(21.85,7.87) ; PC104.1 v1(51.38,117.49) ; C4526.1 v1(204.55,159.66) ; C4709.2 v1(209.35,112.29) ; PR6297.2 55.68,41.98 56.09,42.39 v1(56.09,42.46) ; v1(113.31,61.61) 113.59,61.61 114.19,62.21 C1331.2 ; C1320.2 147.76,60.18 147.39,59.81 v1(146.97,59.81) ; C4545.2 v1(204.53,168.93) ; C1317.1 110.05,57.18 109.62,56.75 v1(109.38,56.75) ; C383.2 v1(14.53,53.11) ; C4707.2 v1(224.08,126) ; C731.2 v1(197.29,191.15) ; PAD9.1 40.46,41.15 v1(40.32,41.29) ; R11114.1 v1(151.82,98.32) ; v1(145.98,39.64) 145.98,39.12 146.22,38.88 R10882.2 ; C4694.2 v1(224.08,117.11) ; v1(207.09,155.47) 207.09,156.04 C4721.2 207.45,156.39 207.45,157 C4719.2 ; PQ7.1 71.3,102.38 v1(71.05,102.13) ; D27.2 54.56,16.5 54.56,15.36 v1(54.38,15.18) ; C270.2 146.7,112.53 v1(147.07,112.16) ; PC45.1 v1(141.92,187.68) ; R4530.1 v1(204.55,162.71) ; C4600.1 v1(40.32,63.65) ; C757.2 39.55,80.03 40.44,80.92 v1(40.7,80.92) ; v1(36.89,80.21) C355.2 ; C714.1 v1(14.66,82.44) ; C4685.2 223.33,136.23 223.65,135.91 v1(224.01,135.91) ; PR145.2 v1(53.45,107.33) ; C802.2 226.62,103.02 227.39,102.25 v1(227.39,101.39) ; R10937.2 156.65,54.05 v1(156.6,53.99) ; C718.2 v1(14.66,79.39) ; R176.2 v1(88.78,109.99) ; R4549.1 v1(204.53,165.75) ; Q26.2 v1(17.58,60.09) ; PC159.2 v1(133.66,144.16) ; v1(109.4,67.79) 109.45,67.84 EC41.2 ; HOLE24.1 HOLE24.6 ; v1(41.59,24.02) 41.83,24.27 C4613.2 ; C1245.2 v1(145.98,41.29) ; R10873.1 131.56,38.38 132.26,39.09 v1(132.26,39.14) ; C4692.1 v1(223.96,147.72) ; C716.2 v1(14.66,81.43) ; R11091.1 v1(215.07,112.29) ; R4338.2 181.79,114.13 v1(181.79,113.81) ; v1(227.39,109.93) 226.83,109.37 C752.2 ; v1(81.21,11.07) C545.2 ; C724.2 v1(14.66,80.41) ; C4615.2 v1(44.37,23.9) ; C4752.1 v1(22.54,62.88) ; v1(115.49,60.93) 116.08,60.93 R10938.2 116.38,62.42 C1327.2 ; v1(194.07,110) Y4200.4 ; R11065.2 223.68,138.45 224.36,139.14 v1(224.36,139.62) ; Y1.2 v1(47.81,74.91) ; PC102.1 v1(48.67,107.59) ; v1(29.98,25.06) 29.57,24.66 C4611.2 ; v1(224.08,119.15) C4675.1 ; PC6219.1 v1(47.02,38.02) ; C4550.2 v1(200.34,172.87) ; C4544.2 v1(169.35,172.61) ; PQ4.1 v1(40.14,38.88) ; C319.1 v1(11.73,76.48) ; R720.2 v1(14.66,58.44) ; Q17.1 v1(22.92,108.48) ; D6.2 v1(13.65,53.11) ; PC87.2 v1(63.68,20.09) ; EC43.2 v1(90.75,65.69) ; C555.2 v1(58.35,15.51)
  TOP w0.762: PC190.2 182.5,96.75 v2(182.5,98.04)
  IN1 w0.089: v1(32.19,73.29) 32.24,73.34 32.24,74.17 v1(32.57,74.51) 32.76,74.51 33.05,74.22 33.05,73.36 v1(32.99,73.3)
  IN1 w0.127: v1(32.57,28.85) 32.57,30.59 v1(30.77,32.38) 30.33,32.82 v1(30.33,35.83) 30.33,37.48 29.12,38.69 v1(29.12,40.66) v1(29.12,45.61) v1(29.12,51.33) v1(29.12,57.3) 29.12,61.79 v1(30.3,62.97) 33.08,65.75 v1(33.08,66.13) 33.08,66.57 33.98,67.48 33.98,68.83 33.23,69.59 v1(33.23,69.87) v1(33.23,70.5) 33.23,72.04 32.99,72.28 v1(32.99,73.3) 33.47,72.82 33.72,72.82 34.85,71.68 34.85,66.64 v1(34.65,66.44) 34.65,66.14 v1(32.42,63.9) 29.93,61.41 v1(29.93,57.3) v1(29.93,51.33) v1(29.93,45.61) v1(29.93,40.66) 29.93,38.91 31.2,37.64 v1(31.2,35.83) 31.2,33.23 v1(32.04,32.39) 33.62,30.81 33.62,28.93 33.37,28.67 32.75,28.67 v1(32.57,28.85) ; v1(32.57,28.85) v1(32.57,28.21) v1(32.57,27.58) 32.57,27.42 32.31,27.17 31.68,27.17 31.43,27.42 31.43,28.01 v1(31.53,28.11) 31.53,28.19 30.66,29.06 30.66,31.28 v1(29.98,31.97) 29.41,32.54 v1(29.41,35.83) 29.41,37.37 28.3,38.48 v1(28.3,40.66) v1(28.3,45.61) v1(28.3,51.33) v1(28.3,57.3) 28.3,62.14 v1(29.93,63.77) 31.93,65.77 v1(31.93,67.08) 31.93,67.86 32.46,68.38 32.46,71.79 32.19,72.06 v1(32.19,73.29)
  IN1 w0.203: v1(144.71,150.87) 144.71,150.95 144.89,151.12 144.89,160.85 145.85,161.82 145.85,164.28 144.63,165.5 144.63,167.41 146.41,169.18 146.41,171.65 147.31,172.55 147.31,173.97 147.78,174.44 v1(147.78,175.2) ; v2(129.62,170.17) 127.92,168.47 126.12,168.47 122.81,165.17 120.27,165.17 117.36,162.26 117.36,161.38 115.75,159.77 115.75,159.15 115.25,158.64 115.25,155.21 109.25,149.22 109.25,148.74 v1(109.12,148.61) ; v1(143.97,183.69) 143.95,183.66 143.95,182.32 147.15,179.12 148.52,179.12 149.71,177.92 149.71,175.81 150.07,175.45 150.07,173.4 149.54,172.87 149.54,171.52 149.97,171.09 149.97,167.58 147,164.61 147,160.67 146.11,159.79 146.11,144.6 148.88,141.83 149.33,141.83 v1(149.51,141.65)
  IN3 w0.508: HOLE6.1 HOLE6.2
  BOTTOM w0.089: v3(101.86,106.07) U35.AP70
  BOTTOM w0.102: U35.D22 128.24,121.72 128.58,122.07 128.96,122.07 ; 128.96,122.07 128.96,121.96 129.47,121.46 v3(129.47,121.42) ; 128.96,122.07 128.96,122.2 129.03,122.27 129.03,122.54 128.84,122.74 U35.B22
  BOTTOM w0.127: v3(133.11,120.59) 133.33,120.59 U35.F13 ; C4201.2 171.5,108.61 ; R4337.2 R4340.2 ; Q56.1 v1(218.1,74.05)
  BOTTOM w0.14: v1(191.73,136.4) 191.93,136.19 U3002.E22
  BOTTOM w0.152: v3(180.55,140.82) 180.55,140.82 U3002.W28 ; U35.BB60 106.94,101.4 106.94,100.52 v1(106.92,100.5) ; v1(196.7,141.04) 196.58,141.16 195.43,141.16 195.4,141.19 U3002.B28
  BOTTOM w0.157: v1(124.45,100.25) 124.44,100.25 124.32,100.37 124.32,101.4 U35.BB30
  BOTTOM w0.178: U35.AT68 102.46,104.8 102.46,104.8 102.46,104.42 102.51,104.37 102.51,104.11 102.47,104.07 U35.AV68 ; v1(126.72,100.48) 126.66,100.53 U35.BB26 ; v1(99.36,110.14) 99.58,110.14 99.83,109.9 100.16,109.9 U35.AG71 ; v1(121.71,99.8) 121.6,99.92 121.6,100.22 121.69,100.31 121.69,101.41 U35.BB34 ; U35.BB55 109.56,100.43 v1(109.6,100.39) ; U35.BB38 119.33,100.48 v1(119.33,100.48) ; U35.BB43 116.73,100.48 v1(116.7,100.46) ; v1(141.15,120.92) 141.12,120.92 141.07,120.87 U35.F1 140.34,121.02 139.99,121.02 U35.F2 U35.F4 138.86,120.74 138.51,120.38 138.51,119.69 138.63,119.56 ; v1(99.41,107.08) 99.57,107.24 100.23,107.24 U35.AM71 ; U35.AT71 100.46,104.94 99.46,104.94 99.46,104.94 v1(99.44,104.94)
  BOTTOM w0.191: v1(56.8,54.3) 56.95,54.45 PU10.11 ; PU11.11 61.88,20.82 v1(61.73,20.67)
  BOTTOM w0.203: v1(91.01,48.83) 91.42,48.83 92.22,49.64 JDIM1.39 ; U35.BA2 140.51,101.72 140.68,101.55 U35.BA1 ; JDIM2.51 95.22,62.39 v1(95.35,62.26) ; U35.AM68 102.46,106.86 102.5,106.82 102.5,106.57 102.46,106.53 U35.AP68 102.46,106.03 102.46,106.02 102.46,105.66 102.5,105.61 102.5,105.33 102.46,105.28 102.46,105.03 102.46,105.03 U35.AT68 ; U3002.D33 193.62,145.48 193.62,146.91 v3(193.69,146.98) ; U35.AW6 137.58,103.41 136.54,103.41 U35.AW8 ; U3002.AL32 U3002.AL33 v3(170.98,146.89) ; U3002.AH32 U3002.AH33 173.31,145.51 173.31,146.68 v3(173.48,146.85) ; U3002.AL30 170.49,143.27 169.76,143.27 U3002.AN30 ; JDIM1.35 91.22,50.32 v1(91.01,50.1) ; 103.47,103.43 103.47,102.91 U35.AY66 U35.BA66 ; 103.47,103.43 103.73,103.43 103.76,103.4 104.16,103.4 104.2,103.36 U35.AW64 ; 103.47,103.43 U35.AW66 103.02,103.89 v3(102.96,103.89) 102.76,103.69 U35.AV68 ; U3002.G32 U3002.G33 191.09,145.45 191.09,146.97 v3(190.98,147.08) ; U35.AV1 140.85,103.53 141.54,103.53 v1(142.04,104.03) ; JDIM1.68 99.47,44.63 v1(99.09,45.01) ; JDIM1.51 95.22,50.19 v1(95.35,50.06) ; v3(175.98,146.81) 175.98,145.34 U3002.AE33 U3002.AE32 ; 130.2,121.39 130.6,120.99 U35.E18 130.84,120.9 130.36,120.42 130.36,119.52 U35.H18 ; 130.2,121.39 U35.D18 ; 130.2,121.39 129.49,121.39 v3(129.47,121.42) ; U35.K70 102.05,118.14 U35.K68 ; v1(112.1,24.76) 111.65,25.21 U1006.3 ; v1(109.12,148.61) 108.87,148.61 107.33,147.07 107.33,143.09 106.84,142.59 ; U35.AW16 131.25,103.36 131.22,103.39 130.93,103.39 130.9,103.36 U35.AW18 130.09,103.36 130.06,103.39 129.58,103.39 129.55,103.36 U35.AW21 128.83,103.36 128.8,103.39 128.51,103.39 128.48,103.36 U35.AW23 127.51,103.36 127.47,103.39 127.18,103.39 127.15,103.36 U35.AW26 126.38,103.36 126.35,103.39 125.89,103.39 125.86,103.36 U35.AW28 125.1,103.36 125.07,103.39 124.62,103.39 124.59,103.36 U35.AW30 123.82,103.36 123.79,103.39 123.5,103.39 123.47,103.36 U35.AW32 ; JDIM1.65 98.72,50.45 98.9,50.27 v1(98.9,50.12) ; U3002.C28 U3002.B28 ; U3002.B10 U3002.C10 v1(193.9,125.76) ; JDIM2.1 82.72,62 83.15,61.58 v1(83.67,61.58) ; U35.D45 114.98,121.76 114.6,121.76 114.57,121.73 114.23,121.73 114.2,121.76 U35.D47 U35.D48 ; U35.AW14 133.32,103.36 133.35,103.39 133.64,103.39 133.67,103.36 U35.AW12 134.31,103.36 134.75,103.8 v3(134.95,103.8) ; U3002.N32 U3002.N33 186,145.37 186,145.48 185.99,145.49 185.99,145.71 185.99,145.71 185.99,146.74 v3(186.21,146.96) ; U4509.3 v1(13.47,120.03) ; U35.D44 U35.B44
  BOTTOM w0.229: JDIM2.93 105.72,64.51 105.54,64.69 105.22,64.69 v1(104.32,65.59) ; JDIM1.93 105.72,50.47 105.42,50.17 105.42,49.72 105.75,49.4 106.03,49.4 v1(106.05,49.41) ; JDIM2.9 84.72,64.81 v1(83.85,65.69) ; v1(127.31,159.4) 127.49,159.23 PU7.21 ; U35.AW49 113.58,103.36 113.62,103.4 114.06,103.4 114.1,103.36 U35.AW47
  BOTTOM w0.254: v1(86.21,52.8) 86.22,52.79 JDIM1.15 ; U35.AM45 114.96,107.12 v3(114.85,107.12) ; v1(90.86,41.42) 91.47,42.03 JDIM1.36 ; JDIM1.188 131.47,44.17 131.22,44.42 131.22,44.89 131.62,45.28 v1(131.73,45.28) ; U35.D53 110.47,121.96 v3(110.47,122.16) 110.47,122.5 U35.B53 ; v1(98.77,57.51) 98.57,57.51 98.22,57.17 98.22,56.66 98.47,56.41 JDIM2.64 ; JDIM1.244 145.47,42.16 145.34,42.03 v1(145.34,41.29) ; JDIM1.107 109.22,53.08 109.53,53.39 v1(109.83,53.39) ; JDIM2.6 83.97,56.8 v1(84.13,56.95) ; JDIM1.57 96.72,48.57 97.21,48.08 v1(97.43,48.08) ; v1(127.15,48.85) 126.71,48.85 126.22,49.33 JDIM1.167 ; v3(103.76,112.55) 103.76,112.67 U35.AA65 ; U35.B39 118.14,122.39 v3(118.33,122.2) 118.33,121.91 U35.D39 ; JDIM2.48 94.47,56.42 94.55,56.5 94.55,56.99 94.11,57.43 v1(94,57.43) ; v1(99.09,46.28) 98.89,46.28 98.33,45.71 98.33,44.34 98.47,44.2 JDIM1.64 98.47,41.84 ; JDIM1.171 127.22,50.2 v1(127.15,50.12) ; U35.L17 131.75,117.8 v3(131.75,117.86) ; v3(128.49,107.8) 128.35,107.95 128.35,108.14 U35.AK22 ; v3(128.49,107.8) 128.84,107.45 U35.AM21 ; v3(128.49,107.8) 128.79,108.1 U35.AK21 ; U35.BA28 v3(125.49,102.78) U35.AW28 ; v3(129.11,117.83) 129.11,117.76 U35.L20 ; JDIM2.2 82.97,56.47 v1(82.53,56.92) ; U35.BA14 132.7,102.27 v3(132.7,102.73) 132.7,103.23 U35.AW14 ; JDIM1.214 137.97,44.87 138.23,45.13 v1(138.56,45.13) ; v1(141.46,101.48) 141.39,101.55 U35.BA1 ; v1(141.37,57.92) 141.68,57.92 141.97,57.62 JDIM2.230 ; U35.U10 135.81,114.34 v3(135.81,114.28) 135.81,113.93 U35.W9 ; JDIM2.14 85.97,54.24 v1(86.21,54) ; U35.BB64 104.69,101.32 104.69,100.49 v1(104.64,100.44) ; 105.79,102.83 v3(105.81,102.83) ; 105.79,102.83 105.78,102.84 U35.AW62 ; 105.79,102.83 105.78,102.82 U35.BA62 ; U35.D47 113.86,121.3 113.93,121.24 v1(113.93,120.62) v1(113.93,119.96) 113.9,119.93 113.71,119.93 U35.G48 113.35,119.69 v1(113.06,119.98) ; JDIM1.18 86.97,42.06 v1(86.79,41.88) ; 103.97,41.84 JDIM1.86 v1(103.97,44.48) ; JDIM2.181 v1(129.72,62.32) ; JDIM1.103 108.22,50.46 107.98,50.22 107.95,50.22 107.57,49.84 107.57,49.37 107.85,49.1 v1(108.16,49.1) ; JDIM2.77 101.72,61.04 102.42,60.34 v1(102.93,60.34) ; JDIM1.252 147.47,45.82 147.84,46.19 147.84,46.65 v1(147.94,46.75) ; U35.AW57 v1(108.41,103.87) 109.18,103.36 U35.AW55 ; U35.AW57 107.92,103.36 107.75,103.52 107.22,103.52 U35.AW60 ; U35.AW57 v1(108.26,102.84) U35.BA57 ; JDIM1.181 v1(129.72,50.12) ; v1(91.97,45.23) 92.26,45.23 92.47,45.02 JDIM1.40 92.47,42.15 v1(91.62,41.29) ; JDIM1.248 146.47,44.72 145.95,45.24 v1(145.6,45.24) ; C4723.2 151.07,101.46 150.63,101.9 150.63,102.04 R616.1 150.29,102.17 149.66,101.54 v1(149.66,101.47) ; JDIM1.30 89.97,44.53 v1(89.99,44.55) ; v1(99.93,119.62) 100.39,119.62 U35.H71 ; JDIM1.175 128.22,52.72 v1(128.61,53.11) ; U35.AR43 v3(116.7,105.18) ; v3(116.7,105.18) U35.AR42 U35.AP42 ; v3(116.7,105.18) U35.AT42 ; v1(133.47,41.8) JDIM1.196 ; v3(121.25,106.49) 121.38,106.49 U35.AN33 v3(122.11,106.46) ; U35.AP10 135.41,106.13 135.71,105.83 v3(135.83,105.83) 136.16,105.5 U35.AR8 ; v1(137.89,49.46) 138.09,49.46 138.72,50.09 JDIM1.217 ; v3(131.75,117.86) 131.75,117.99 U35.K16 131.79,118.53 131.7,118.53 131.55,118.68 131.14,118.68 ; v3(131.75,117.86) 131.92,117.69 131.92,117.55 U35.L16 ; JDIM1.94 105.97,44.26 v1(106.25,44.53) ; JDIM1.205 135.72,52.35 v1(136.12,52.75) ; JDIM1.26 v1(88.97,41.89) ; v3(133.11,120.59) 133.07,120.59 U35.E15 ; 131.13,65.66 131.72,65.07 JDIM2.189 ; v3(108.6,121.38) 108.26,121.72 U35.D58 U35.B58 ; v1(138.74,41.8) 138.97,42.04 JDIM1.218 ; v1(168.71,126.19) U3002.AN10 ; CN5.9 v1(127.86,176.17) ; U35.BA41 v3(118.03,102.78) U35.AW41 ; v1(143.17,57.54) 143.59,57.54 143.97,57.15 JDIM2.238 ; 131.14,118.68 131.14,118.74 U35.H18 ; 131.14,118.68 U35.K18 130.74,118.15 v3(130.41,117.83) 130.41,117.76 U35.L18 ; JDIM1.206 v1(135.97,41.8) ; JDIM1.201 134.72,53.02 135.11,53.41 v1(136.15,53.41) ; U35.G63 104.74,120.2 104.74,120.48 U35.E65 ; v1(125.39,46.73) 125.56,46.73 126.32,45.97 126.32,44.34 126.47,44.18 JDIM1.168 ; U3002.AK7 171.34,124.08 v1(171.34,124.12) ; v1(88.51,48.19) 88.99,48.19 90.22,49.42 JDIM1.31 ; v1(143.17,45.34) 143.59,45.34 143.97,44.95 JDIM1.238 v1(143.97,41.8) ; JDIM1.2 82.97,44.74 83.42,45.18 v1(83.54,45.18) ; U35.AT56 v1(108.41,104.53) ; v1(141.35,65.23) 141.22,65.1 JDIM2.227 ; v1(99.13,103.13) 99.13,103.14 99.49,103.5 U35.AV71 U35.AV70 ; v1(136.15,54.05) 135.97,54.22 JDIM2.206 ; 88.22,65.04 JDIM2.23 88.22,62.51 88.09,62.38 88.09,60.85 87.55,60.31 v1(86.95,60.31) ; 97.47,41.84 JDIM1.60 97.47,44.71 96.96,45.23 v1(96.7,45.23) ; v1(145.51,57.57) 145.58,57.57 146.47,56.68 JDIM2.248 ; v1(101.22,111.62) 101.25,111.59 101.26,111.59 101.49,111.36 U35.AE69 U35.AE68 102.19,111.22 102.74,111.22 U35.AE67 102.81,111.19 103.41,111.19 U35.AE66 103.46,111.19 104.06,111.19 U35.AE65 104.11,111.19 104.71,111.19 U35.AE64 ; v1(104.32,64.93) 104.65,64.6 104.65,64.6 104.72,64.53 JDIM2.89 ; U35.T2 139.53,115.56 v3(139.33,115.36) 139.12,115.56 U35.T4 138.61,115.56 v3(138.4,115.35) ; v1(126.93,175.28) 126.63,175.28 CN5.12 ; JDIM1.61 97.72,50.43 98.02,50.13 98.02,49.6 97.78,49.35 v1(97.43,49.35) ; v1(196.65,136.18) 196.54,136.29 195.23,136.29 U3002.B22 U3002.C22 ; U35.AW10 135.6,103.36 135.75,103.51 136.34,103.51 U35.AW8 ; U35.AW10 135.25,103.5 v3(134.95,103.8) 135.36,104.2 U35.AU10 ; U35.AW10 U35.BA10 ; v1(132.9,64.9) 132.72,64.73 JDIM2.193 ; v1(138.43,53.99) 138.72,53.99 138.97,54.25 JDIM2.218 ; JDIM1.213 137.72,52.52 v1(138.43,53.22) ; U3002.AH10 173.83,125.79 v1(173.83,125.77) ; JDIM2.176 128.47,57.2 127.53,58.15 v1(127.15,58.15) ; U35.AD62 105.01,111.62 v3(105,111.64) ; v1(107.65,57.43) 107.65,57.43 107.77,57.43 108.16,57.05 108.16,56.54 107.97,56.36 JDIM2.102 ; v1(96.7,41.8) 96.47,42.03 JDIM1.56 ; v1(101.83,115.29) 101.83,115.17 U35.U69 U35.U70 ; U35.B66 103.1,122.57 v3(103.1,122.24) 103.22,122.12 103.22,121.78 U35.D66 ; 97.72,65.04 JDIM2.61 97.72,62.42 96.99,61.68 v1(96.8,61.68) ; JDIM2.47 94.22,64.84 v1(94.06,65) ; 100.47,41.84 JDIM1.72 100.47,44.46 v1(100.46,44.48) ; JDIM2.68 99.47,54.34 99.21,54.08 v1(98.81,54.08) ; JDIM2.22 87.97,57.14 87.05,58.06 v1(86.95,58.06) ; v1(142.97,41.8) JDIM1.234 ; v1(143.31,49.35) 143.59,49.35 144.22,49.98 JDIM1.239 ; U35.F22 128,120.34 127.66,120 ; JDIM2.214 137.97,57.07 138.23,57.33 v1(138.56,57.33) ; v1(95.47,56.92) JDIM2.52 ; v1(133.27,61.52) 133.71,61.52 133.91,61.72 133.91,62.44 133.72,62.63 JDIM2.197 ; JDIM2.185 130.72,64.63 130.4,64.95 v1(129.85,64.95) ; JDIM1.6 v1(83.97,41.89) ; U35.AR50 112.34,105.29 111.85,105.29 U35.AR52 ; v1(185.65,118.07) 185.86,118.28 185.86,119.42 U3002.N2 ; CN5.15 v1(125.73,174.06) ; 116.21,107.47 116.47,107.21 116.72,107.21 U35.AN42 ; 116.21,107.47 U35.AM43 ; 116.21,107.47 U35.AL45 ; v1(173.82,126.62) 173.82,126.63 U3002.AG11 ; U35.L2 139.53,118.21 v3(139.35,118.04) 139.17,118.21 U35.L4 ; v1(107.63,65.71) 107.11,65.2 107.11,64.65 107.22,64.54 JDIM2.99 ; v1(85.47,44.76) 85.97,44.25 JDIM1.14 ; 127.66,120 127.5,120.16 127.36,120.16 U35.F23 127,120.16 126.8,120.16 v1(126.68,120.03) ; 127.66,120 127.97,119.69 U35.G22 U35.K22 ; 127.66,120 v3(127.68,120) ; v1(82.86,49.8) 83.06,49.8 83.72,50.47 JDIM1.5 ; 109.18,41.85 108.97,42.05 JDIM1.106 v1(108.97,44.48) ; U35.K68 U35.K67 v3(103.09,118.05) ; v1(138.39,65.42) 138.72,65.09 JDIM2.217 ; v1(171.33,125.76) 171.35,125.76 171.32,125.78 U3002.AK10 ; 105.08,114.32 104.74,114.66 U35.U64 ; 105.08,114.32 v3(105.08,114.37) ; 105.08,114.32 105.39,114.63 U35.U63 ; JDIM1.68 99.47,41.84 ; v1(143.19,61.6) 143.55,61.6 144.22,62.27 JDIM2.239 ; PU15.19 67.08,75.85 v1(67.42,76.19) ; JDIM2.196 133.47,54.38 133.09,53.99 v1(132.92,53.99) ; U35.AV68 102.13,103.69 v3(101.99,103.54) 101.94,103.5 U35.AV69 ; JDIM1.44 93.47,42.13 v1(92.51,41.17) ; v1(141.35,61.55) 140.87,61.55 140.22,62.19 JDIM2.223 ; JDIM1.222 139.97,44.18 140.14,44.35 140.14,44.87 v1(139.6,45.41) ; U35.AW53 v3(110.74,102.83) U35.BA53 ; JDIM2.56 96.47,56.82 95.68,57.61 v1(95.46,57.61) ; JDIM2.57 96.72,64.99 v1(96.79,65.05) ; CN5.24 v1(122.49,170.94) ; v1(84.16,58.35) 84.48,58.35 85.27,57.55 85.27,56.66 84.97,56.36 JDIM2.10 ; v1(134.09,57.43) 134.97,56.55 JDIM2.202 ; JDIM1.23 88.22,52.44 88.47,52.68 v1(88.7,52.68) ; U35.B14 133.17,122.58 v3(133.17,122.27) 133.14,122.24 133.14,121.85 U35.D14 ; v1(100.23,48.85) 99.95,48.85 99.72,49.07 JDIM1.69 ; v3(104.77,105.19) 104.9,105.19 U35.AT63 ; v1(84.31,49.19) 84.72,49.61 JDIM1.9 ; v1(91.6,61.61) 91.85,61.61 92.22,61.99 JDIM2.39 92.22,65.04 ; JDIM2.69 99.72,61.9 100.13,61.49 v1(100.41,61.49) ; U35.AN23 126.99,106.61 v3(126.72,106.61) 127.18,106.15 U35.AP23 ; v1(97.47,56.7) JDIM2.60 ; U35.D18 v3(130.53,122.22) U35.B18 ; v1(95.47,44.6) JDIM1.52 ; U35.AK18 U35.AJ18 130.41,109.38 130.41,109.57 U35.AG18 ; v1(104.37,58.04) 104.66,58.04 104.97,57.72 JDIM2.90 ; v1(101.97,44.5) JDIM1.78 101.97,41.84 ; JDIM2.171 127.22,62.37 v1(127.15,62.29) ; JDIM2.234 142.97,54.21 v1(143.44,53.74) ; JDIM1.19 87.22,49.84 86.74,49.36 v1(86.5,49.36) ; JDIM2.168 126.47,56.38 126.04,56.82 126.04,57.69 125.44,58.29 v1(125.39,58.29) ; U35.A67 102.6,123.84 102.33,124.11 102.33,124.31 v1(102.27,124.37) ; JDIM2.36 91.47,56.61 v1(91.59,56.73) ; U35.AP68 v3(101.86,106.07) ; JDIM2.51 95.22,65.04 ; v1(101.47,100.28) 101.95,100.28 102.6,100.93 U35.BB67 ; v1(98.33,65.05) 98.72,64.65 JDIM2.65 ; v3(114.85,105.18) U35.AR45 ; JDIM2.15 86.22,64.9 v1(87,65.68) ; v1(190.66,126.61) 191.03,126.24 U3002.G10 ; JDIM1.235 143.22,52.71 v1(143.44,52.93) ; v1(173.05,122.39) 173.05,122.37 U3002.AH5 ; U35.E71 99.85,121.3 v1(99.32,121.83) ; v1(83.88,64.92) 83.72,64.76 JDIM2.5 ; JDIM2.167 126.22,62.2 126.6,61.83 126.6,61.41 126.99,61.02 v1(127.15,61.02) ; v1(139.91,49.45) 140.22,49.76 JDIM1.223 ; v3(112,120.02) 111.67,119.69 U35.G52 ; U35.G58 v3(107.52,119.94) U35.G60 ; 135.41,65.33 134.72,64.64 JDIM2.201 ; v1(106.97,45.14) 107.35,45.14 107.97,44.51 JDIM1.102 ; U35.AW49 v3(113.26,102.62) 113.26,102.18 U35.BA49 ; JDIM1.176 128.47,45 127.53,45.95 v1(127.15,45.95) ; v3(124.91,107.11) 125.25,107.45 U35.AM27 ; U35.AW51 v3(112.06,103.88) ; v1(101.74,50.12) 101.72,50.13 JDIM1.77 ; U35.AW18 130.41,103.01 v3(130.61,102.8) 130.41,102.6 U35.BA18 U35.BB18 ; v1(132.11,57.35) 131.58,57.35 131.35,57.12 131.35,56.47 131.47,56.34 JDIM2.188 ; U35.D44 116.01,121.38 116.67,121.38 v3(116.73,121.44) ; JDIM2.184 130.47,54.44 130.91,54 v1(132.26,54) 132.47,54.22 JDIM2.192 ; CN5.28 120.93,169.67 v1(121.21,169.67) ; v1(172.14,122.4) 171.28,122.4 U3002.AL5 ; U35.AR55 109.92,105.5 v3(110.26,105.16) ; v1(141.37,45.72) 141.68,45.72 141.97,45.42 JDIM1.230 v1(141.97,41.8) ; v3(107.55,105.19) 107.64,105.19 U35.AT58 ; v1(104.37,52.78) 104.72,52.42 JDIM1.89 ; U35.AW23 v3(127.97,102.78) U35.BA23 ; U35.D34 120.8,121.9 v3(120.8,122.28) 120.8,122.56 U35.B34 ; JDIM1.1 82.72,52.56 v1(82.53,52.76) ; JDIM2.18 86.97,56.74 86.92,56.79 v1(86.95,56.79) ; U35.B30 v3(123.1,122.23) U35.D30 ; U35.AR5 138.32,105.5 U35.AT4 138.93,104.96 139.12,105.14 v3(139.35,105.14) 139.65,105.14 U35.AT2 ; v3(136.51,107.91) 136.51,108.06 136.78,108.34 U35.AK8 ; v1(93.22,48.85) 93.48,48.85 94.22,49.59 JDIM1.47 ; JDIM1.27 89.22,49.94 88.74,49.46 v1(88.51,49.46) ; v1(136.2,45.31) 136.38,45.31 136.97,44.71 JDIM1.210 ; U35.K71 99.29,118.14 v1(99.17,118.02) ; 93.22,65.04 JDIM2.43 93.22,62.23 93.78,61.67 v1(94.06,61.67) ; v1(138.48,61.66) 138.09,61.66 137.72,62.03 JDIM2.213 ; v1(88.7,61.65) 89,61.65 89.33,61.98 89.33,62.43 89.22,62.54 JDIM2.27 89.22,65.04 ; JDIM2.175 128.22,65.03 128.86,65.66 ; U3002.G7 191.03,123.64 190.63,124.03 v1(190.63,124.06) ; U35.AP38 U35.AN38 U35.AN40 ; v1(132.92,52.7) 132.72,52.5 JDIM1.193 ; JDIM2.30 89.97,56.73 v1(89.99,56.75) ; U35.K66 v3(103.74,118.05) U35.K65 U35.K64 ; v1(136.29,65.31) 135.72,64.75 JDIM2.205 ; v3(114.84,119.94) U35.G45 ; v1(132.72,49.42) 132.72,49.42 133.28,49.42 133.72,49.87 JDIM1.197 ; v1(90.75,65.69) 91.23,65.21 91.23,64.77 91.22,64.76 JDIM2.35 ; JDIM1.247 146.22,52.48 145.99,52.72 v1(145.4,52.72) ; v1(127.15,56.88) 127.47,56.56 JDIM2.172 ; v1(132.26,53.26) 131.72,52.72 JDIM1.189 ; JDIM1.22 v1(87.97,41.8) ; JDIM2.210 136.97,57.21 136.68,57.51 v1(136.2,57.51) ; v1(147.02,49.14) 147.02,49.14 145.88,49.14 145.22,49.8 JDIM1.243 ; JDIM2.81 102.72,64.72 v1(102.93,64.92) ; v1(136.2,49.12) 136.41,49.12 136.72,49.44 JDIM1.209 ; JDIM2.1 82.72,65.04 ; v1(127.95,180.61) 127.95,180.33 CN5.3 ; 122.15,119.94 v3(122.15,119.89) U35.J32 ; 122.15,119.94 U35.F33 ; 122.15,119.94 U35.F32 ; v1(135.9,60.29) 136.72,61.12 JDIM2.209 ; 103.72,65.04 JDIM2.85 103.72,62.09 104.2,61.61 v1(104.32,61.61) ; U35.AG20 129.44,109.83 v3(129.76,109.5) 129.76,109.38 U35.AJ20 ; v1(103.1,49.28) 102.76,49.28 102.59,49.44 102.59,50.26 102.72,50.39 JDIM1.81 ; JDIM1.231 142.22,52.8 v1(141.28,53.74) 140.97,54.05 JDIM2.226 ; CN5.18 v1(124.64,173.02) ; U35.U66 103.44,114.75 v3(103.11,114.42) 102.79,114.75 U35.U67 ; JDIM2.231 142.22,65.21 ; JDIM2.247 146.22,64.68 145.86,65.04 v1(145.34,65.04) 145.22,64.92 JDIM2.243 ; U35.F68 101.93,120.72 v3(101.45,121.19) 101.63,121.37 U35.D69 ; v1(104.32,49.48) 104.13,49.48 103.72,49.89 JDIM1.85 ; JDIM2.40 92.47,57.32 91.76,58.03 v1(91.59,58.03) ; v1(103,54.11) 102.19,54.11 101.97,54.32 JDIM2.78 ; v1(145.39,54) 145.47,54.08 JDIM2.244 ; v1(109.37,64.9) 109.22,64.75 JDIM2.107 ; v1(106.36,58.12) 106.37,58.12 106.97,57.52 JDIM2.98 ; v1(87,64.92) 87.22,64.69 JDIM2.19 ; JDIM2.72 100.47,56.66 v1(100.46,56.68) ; 102.97,41.84 JDIM1.82 v1(102.97,45.39) ; JDIM2.44 93.47,54.38 93.75,54.11 v1(94,54.11) ; U35.BA36 v3(120.51,102.78) U35.AW36 ; JDIM2.106 108.97,56.35 v1(109.38,56.75) ; v1(88.61,57.41) 88.85,57.41 89.13,57.13 89.13,56.5 88.97,56.34 JDIM2.26 ; PU22.19 217.11,173.03 v1(216.79,172.71) ; U35.AH6 138.09,109.48 U35.AF4 139.17,110.26 v3(139.35,110.08) 139.53,110.26 U35.AF2 139.84,110.26 U35.AF1 140.51,110.28 v1(141.32,110.28) ; v3(110.26,119.94) U35.G55 ; v3(122.11,103.86) U35.AW34 ; JDIM1.73 100.72,49.76 100.44,49.48 v1(100.23,49.48) ; v1(134.09,45.23) 134.97,44.35 JDIM1.202 ; JDIM1.48 94.47,44.81 94.05,45.23 v1(93.97,45.23) ; JDIM2.252 147.47,57.29 147.84,57.66 v1(148.64,57.66) ; JDIM2.235 143.22,65.06 ; JDIM1.180 129.47,44.15 129.23,44.39 129.23,44.95 129.65,45.36 v1(129.77,45.36) 129.98,45.36 130.33,45 130.33,44.34 130.47,44.2 JDIM1.184 ; JDIM2.86 103.97,56.36 103.81,56.52 103.81,57.05 104.14,57.38 v1(104.37,57.38) ; v1(129.77,57.56) 129.65,57.56 129.23,57.15 129.23,56.59 129.47,56.35 JDIM2.180 ; U35.AA2 139.53,112.91 v3(139.35,112.73) 139.17,112.91 U35.AA4 138.77,112.91 U35.W6 ; 90.22,65.04 JDIM2.31 90.22,61.57 89,60.35 v1(88.7,60.35) ; v1(172.14,124.13) U3002.AJ7 172.63,123.64 U3002.AH7 ; U35.B71 99.65,123.25 v1(99.47,123.43) ; U35.K63 105.38,118.47 105.38,118.62 v3(105.66,118.9) 105.8,118.76 U35.K61 ; U35.BA32 v1(122.98,102.78) U35.AW32 ; CN5.21 v1(123.57,171.98) ; JDIM1.192 132.47,42.27 v1(132.01,41.8) ; JDIM1.99 107.22,52.49 106.53,53.18 v1(106.36,53.18) ; U35.AU38 v3(118.56,103.9) U35.AW38 ; JDIM1.43 v1(93.22,50.12) ; JDIM2.94 105.97,56.35 v1(106.36,56.73) ; JDIM2.103 108.22,64.88 ; v3(102.46,112.54) U35.AA68 ; JDIM2.73 100.72,64.6 v1(100.41,64.92) ; U35.AW43 116.77,103.42 115.61,103.42 U35.AW45 v1(115.55,102.76) U35.BA45 ; JDIM2.251 147.22,65.27 ; U35.N68 102.26,116.48 102.46,116.2 v1(103.08,116.2) ; v1(129.98,52.75) 130.4,52.75 130.72,52.43 JDIM1.185 ; v1(139.6,57.36) 140.01,57.36 140.14,57.23 140.14,56.55 139.97,56.38 JDIM2.222 ; v1(84.64,41.89) 84.97,42.23 JDIM1.10 ; v1(102.97,56.7) JDIM2.82 ; v1(148.67,53.36) 147.9,53.36 147.22,52.68 JDIM1.251 ; U35.F40 117.67,119.98 v3(117.58,119.98) ; v1(127.15,44.68) 127.47,44.36 JDIM1.172 ; JDIM1.226 v1(140.97,41.8) ; v3(103.75,116.21) 103.75,116.32 U35.N65 ; v3(137.47,102.68) 137.47,102.34 U35.BA6 137.67,102.14 137.67,101.42 U35.BB6 ; v1(104.97,44.48) JDIM1.90 104.97,41.84 ; JDIM1.98 v1(106.97,44.48) ; U35.B48 U35.D48 ; JDIM1.227 v1(141.22,53.03)
  BOTTOM w0.279: v1(227.39,109.93) 226.97,109.51 Q37.1 ; v1(224.08,107.46) 224.08,107.56 223.75,107.89 223.75,108.07 223.89,108.21 Q37.4 ; v1(196.65,138.83) 196.63,138.81 195.24,138.81 U3002.B25 U3002.C25 ; v1(97.47,132.86) 97.23,133.1 U33.3 ; U43.3 203.62,183.27 v1(204.02,183.66) ; Q3.1 108.66,152.38 108.82,152.55 109.07,152.55 109.33,152.29 v1(109.33,151.61) ; Q3.4 107.36,154.46 v1(107.63,154.73) ; U3002.B31 v1(196.68,143.69) ; v1(142.42,135.05) 142.42,134.89 142.06,134.53 U47.3 ; Q56.4 219.4,71.15 219.64,71.39 v1(220.53,71.39) ; v1(144.16,135.05) 144.16,135 144.5,134.65 U6.3
  BOTTOM w0.305: v1(193.22,163.76) 192.58,163.76 VRAM3004.F5 ; v1(185.54,121.54) 185.58,121.54 U3002.N5 ; v3(210.17,140.16) 210.2,140.16 VRAM3002.F5 ; v3(112.09,107.1) U35.AL52 ; v3(212.61,136.98) 212.58,136.98 VRAM3002.H1 ; U3002.G5 190.52,122.39 v1(190.52,122.39) ; U3002.A2 195.98,119.54 v1(196.37,119.93) ; v3(200.19,157) 200.11,157 VRAM3004.R14 VRAM3000.C13 ; v3(197.73,165.07) 197.73,165.01 VRAM3004.E12 ; VRAM3001.E1 180.06,158.56 v3(180.06,158.59) ; VRAM3002.A3 206.6,138.97 v3(206.2,139.36) ; U35.AG21 128.5,109.61 v3(128.24,109.61) ; U35.AP35 v3(120.4,105.83) ; VRAM3007.E14 215.79,116.84 v3(215.76,116.84) ; v1(185.24,126.56) 185.11,126.56 U3002.R12 ; U3002.K2 v1(188.08,119.94) ; U4001.3 v1(209.35,107.85) ; v3(206.99,120.03) 206.99,120.04 VRAM3007.T10 ; U3002.E7 192.38,123.34 v3(192.31,123.34) 192.23,123.34 U3002.F7 ; v3(206.19,125.63) 206.19,125.64 VRAM3007.U3 ; VRAM3002.K1 213.44,137 v3(213.44,136.98) ; U3002.T2 183.22,119.28 183.22,118.34 v1(183.09,118.21) ; v1(189.67,179.83) 189.99,179.5 CN10.51 ; VRAM3001.C12 170.89,156.59 v3(171.29,156.19) ; VRAM3001.C12 170.49,156.99 v3(170.49,156.99) ; VRAM3001.C12 v3(170.49,156.19) ; v3(192.13,158.59) 192.53,158.99 VRAM3004.M5 ; v3(188.71,158.19) 189.3,158.19 VRAM3004.N1 ; v3(214.99,120.03) VRAM3007.G10 ; v1(121.24,108.66) 121.24,108.65 U35.AL35 ; VRAM3004.C1 v3(188.81,166.22) ; U35.F37 119.92,120.34 120.23,120.66 v3(120.32,120.66) 120.47,120.66 U35.F35 ; U35.F37 120.32,119.88 U35.J35 ; U35.F37 119.68,120.53 119.14,120.53 U35.F38 118.56,119.94 118.49,119.94 ; v3(176.89,155.39) 176.49,155.79 VRAM3001.B5 ; v3(207.07,123.97) 207.07,124.12 VRAM3007.T5 ; U3002.AH2 173.48,118.7 v1(173.03,118.26) ; U35.C25 125.9,122.41 v4(125.74,122.26) ; VRAM3001.R11 171.69,166.19 v3(172.09,166.59) ; U3002.G2 191,119.54 191.39,119.92 v1(191.41,119.92) 191,120.34 U3002.G3 ; VRAM3003.C13 208.18,118.04 v3(207.79,118.43) 207.79,118.44 VRAM3007.R12 ; CN10.18 197.64,187.75 v1(197.29,188.11) ; VRAM3002.R11 218.19,144.96 v3(218.2,144.96) ; v1(215.17,107.08) 215.43,107.34 U4002.3 ; VRAM3007.N12 209.38,118.43 v3(209.36,118.43) ; v3(217.37,144.17) 217.37,144.18 VRAM3002.P10 ; U35.AL48 v3(113.92,107.13) U35.AM46 ; VRAM3007.F10 215.38,120.45 v3(215.79,120.86) ; v3(214.31,148.23) 214.27,148.23 VRAM3002.K14 ; U3002.AC20 v1(177.19,134.48) U3002.AB19 v1(177.19,133.4) U3002.AC18 176.73,132.75 v1(177.06,132.42) 176.73,132.09 U3002.AC17 v1(177.2,131.47) U3002.AB16 ; v4(125.74,122.26) 125.58,122.09 U35.D26 ; v4(125.74,122.26) 125.76,122.26 U35.D25 ; v3(175.78,159.38) 176.19,159.79 VRAM3001.G5 ; v1(171.33,135.77) 171.33,135.74 U3002.AL21 U3002.AL20 170.93,134.52 v1(170.53,134.12) 170.53,134.09 U3002.AM19 169.73,134.09 v1(169.73,134.12) 169.33,133.72 U3002.AN19 ; U35.Y19 v3(129.76,112.83) U35.Y20 ; v1(156.9,104.67) 157.25,104.32 CN23.71 ; v1(156.9,104.67) 156.75,104.52 CN23.73 ; v1(156.9,104.67) 156.52,104.67 156.25,104.4 CN23.75 ; U35.AH63 105.39,109.39 v3(105.06,109.85) 105.35,110.25 U35.AF63 ; VRAM3007.D10 217.38,120.84 v3(217.41,120.84) ; VRAM3002.C1 208.58,136.98 v3(208.59,136.98) ; VRAM3007.K2 211.82,127.2 v3(211.82,127.22) ; U3002.N28 v3(185.58,140.84) ; U19.10 220.52,52.99 220.78,52.72 v1(220.78,52.6) ; VRAM3007.R3 207.79,125.64 v3(207.79,125.63) ; VRAM3002.U1 219.56,137.2 v3(219.56,136.82) ; VRAM3007.N3 210.16,126.41 v3(210.16,126.43) ; U35.AR48 v3(112.99,105.18) ; VRAM3002.C3 208.2,138.96 v3(208.6,138.56) ; v3(190.55,168.19) 190.93,167.81 VRAM3004.A3 ; v1(123.07,108.62) 123.07,108.54 123.07,108.54 U35.AL32 ; VRAM3001.R1 179.76,166.27 v3(180.27,166.27) ; VRAM3002.R1 217.8,136.82 v3(217.84,136.78) ; U35.AM8 136.32,107.65 136.51,107.83 v3(136.51,107.91) ; v3(199.3,162.59) VRAM3004.H13 ; VRAM3004.D10 v3(196.15,165.8) ; v1(189.67,181.63) 189.67,181.38 190.04,181 CN10.45 ; U35.AL55 v3(110.26,107.11) ; v3(207.79,119.21) 208.18,119.61 VRAM3007.R11 ; v3(210.2,136.98) 210.18,136.98 VRAM3002.E1 ; CN23.21 169.75,104.39 v1(169.22,104.92) ; U35.AM55 v3(109.35,107.13) ; VRAM3004.L10 196.53,159.77 v3(196.91,159.39) VRAM3004.M10 ; v3(116.67,119.97) 116.21,119.72 U35.G43 ; v3(116.67,119.97) 117.09,120.34 U35.F42 ; v3(116.67,119.97) U35.J42 ; v3(218.17,124.81) 218.17,124.85 VRAM3007.C4 ; U35.AG17 131.39,109.96 v3(131.72,110.29) 131.72,110.21 U35.AG16 ; v3(215.18,143.94) 215.18,144.35 VRAM3002.M10 ; v1(218.24,52.6) 218.24,53.61 219.02,54.39 U19.13 ; U35.AM61 v3(106.62,107.13) 106.95,107.45 U35.AM60 ; VRAM3007.H2 214.18,127.23 v3(214.18,127.24) VRAM3007.H1 ; VRAM3007.R1 208.18,128.14 v3(208.15,128.18) ; v1(191.42,143.35) 191.41,143.35 191,142.94 U3002.G30 ; v3(198.55,161.01) 198.55,161 VRAM3004.K13 v3(199.33,160.22) ; CN10.69 191.98,175 v1(192.21,175.23) ; U3002.T5 183.19,122.23 v1(183.19,123.1) 183.19,123.36 U3002.T7 ; VRAM3004.R12 v3(197.74,156.23) 197.71,156.23 VRAM3004.R11 ; VRAM3004.L5 192.91,159.43 v3(192.98,159.43) ; v3(209.39,148.13) 209.42,148.13 VRAM3002.E14 ; v1(162.22,102.17) 162.25,102.19 CN23.51 ; v3(172.89,157.78) 172.5,157.39 VRAM3001.D10 ; U35.V17 131.76,114.5 ; 131.76,114.5 U35.V16 ; 131.76,114.5 v3(131.74,114.5) ; U35.A70 100.51,123.85 v1(100.06,123.85) ; VRAM3001.H1 180.06,160.96 v3(180.06,160.99) ; U35.AP38 v3(119.48,106.48) U35.AN37 120.19,106.48 v3(120.4,106.48) U35.AN35 v3(121.25,106.49) ; U35.F8 136.78,120.69 U35.E6 137.24,121.02 137.59,121.36 137.59,121.37 U35.D6 137.94,122.07 138.08,122.21 v3(138.08,122.22) 138.27,122.41 U35.C5 ; U35.F8 136.63,120.03 v3(136.78,120.03) 136.9,120.03 U35.G6 137.44,119.89 137.95,119.89 U35.G5 138.28,119.56 v3(138.66,119.56) ; U35.F8 136.06,120.34 U35.G10 ; VRAM3002.A12 v3(207,146.56) ; v1(168.93,139.12) 168.93,139.09 U3002.AN25 ; 118.49,119.94 U35.J38 ; 118.49,119.94 U35.F40 ; v3(206.98,136.98) 206.98,136.98 VRAM3002.A1 ; VRAM3004.E1 189.13,164.41 v3(188.76,164.41) ; U44.9 163.79,68.37 v1(163.7,68.47) ; v1(215.45,57.8) 215.71,57.54 U19.16 ; v1(193.12,139.11) 193.12,139.08 U3002.E25 ; VRAM3004.C14 200.19,166.22 v3(200.29,166.32) ; VRAM3001.L10 172.71,163.21 v3(173.03,163.21) ; v3(200.1,162.59) VRAM3004.H14 ; v3(211.02,144.16) 210.99,144.16 VRAM3002.F10 ; v3(120.39,104.53) 120.77,104.85 U35.AT35 ; v1(193.6,191.79) 193.39,192 CN10.1 ; v3(215.79,140.92) 215.44,140.56 VRAM3002.M5 ; CN2020.13 212.14,16.65 v1(212.27,16.78) ; v3(177.69,156.99) 177.29,156.59 VRAM3001.C4 ; v1(141.46,122.35) 141.05,122.75 U35.C1 ; v3(171.29,154.58) 171.29,154.59 VRAM3001.A12 ; VRAM3001.E12 170.89,158.19 v3(171.29,157.79) ; U35.P20 129.27,115.97 v3(129.1,116.2) 129.1,116.31 128.81,116.6 U35.N21 ; VRAM3007.G5 214.18,124.03 v3(214.18,123.97) ; v3(180.3,164.59) VRAM3001.N1 ; v3(172.88,167.38) 172.49,166.99 VRAM3001.T10 ; U3002.AN34 169.33,146.6 v1(169.09,146.83) ; v1(138.55,124.28) U35.A5 ; VRAM3001.N14 168.88,164.59 v3(168.7,164.41) ; U3002.P15 v1(185.22,129.43) U3002.R14 v1(184.3,128.51) U3002.T13 ; U3002.B4 195.25,121.32 v1(195.75,121.32) ; v3(134.96,118.81) 134.54,118.39 U35.J11 ; v3(139.34,107.8) 138.87,108.27 U35.AJ4 ; v3(139.34,107.8) 139.53,107.61 U35.AL2 ; v3(139.34,107.8) 139.14,107.61 U35.AL4 ; v3(177.69,158.59) 178.09,158.19 VRAM3001.E3 ; U3002.AH11 173.43,127.01 v1(173.82,126.62) ; v3(215.8,138.56) 216.2,138.96 VRAM3002.N3 ; v3(206.19,118.42) 206.19,118.44 VRAM3007.U12 ; U35.AL58 v3(108.45,107.12) ; U3002.K5 v1(188.06,121.52) ; U35.AP20 v3(130.4,105.82) ; v3(130.4,105.82) U35.AP18 U35.AN20 ; v3(130.4,105.82) U35.AR20 v3(130.4,105.17) 129.93,104.85 ; U35.AT20 129.93,104.85 ; 129.93,104.85 v3(130.4,104.52) U35.AU20 ; VRAM3007.R14 v3(207.77,116.82) ; U3002.B34 195.14,146.14 v1(195.54,145.74) 195.93,145.35 U3002.A33 ; U3002.K28 188.5,141.24 188.91,141.65 v1(188.91,141.63) ; v3(217.81,148.31) 217.8,148.29 VRAM3002.R14 ; U3002.N21 U3002.P22 U3002.N23 v1(187.16,137.51) U3002.M22 ; U35.AK69 101.26,108.47 v3(101.65,108.47) 101.65,108.46 102.03,108.46 U35.AK68 ; v1(181.39,144.93) 181.39,144.93 181.39,144.92 181,144.54 U3002.W32 ; v3(192.23,121.51) 192.3,121.51 U3002.E5 ; v3(104.77,105.19) 105.24,105.5 U35.AR63 ; v3(132.2,107.71) 132.2,108.05 U35.AK16 ; v3(190.53,154.61) VRAM3004.U3 ; U3002.AH30 173.43,142.9 173.43,142.85 v1(173.07,142.49) ; v3(168.7,161.79) 168.89,161.79 VRAM3001.K14 ; v1(125.83,120.68) 125.69,120.68 U35.F27 125.07,120.62 124.72,120.62 U35.F28 124.44,120.31 123.98,119.85 U35.J28 ; U35.R13 133.26,116.01 v3(133.26,116.34) 133.26,116.53 U35.N13 ; U35.AD8 136.9,111.59 v3(136.9,112.02) ; U35.T21 U35.P21 128.49,116.06 v3(128.49,116.18) ; v3(216.02,148.31) 216.2,148.14 VRAM3002.N14 ; v3(190.63,138.31) 190.65,138.31 U3002.G25 ; v3(170.54,160.19) 170.49,160.19 VRAM3001.H13 ; v3(207.77,148.18) 207.77,148.18 VRAM3002.C14 ; v3(178.87,142.51) 178.87,142.55 U3002.AB30 ; U35.E21 129.44,121.42 v3(129.47,121.42) ; U35.P17 131.69,115.46 v3(131.69,115.35) 131.69,115.23 U35.T17 ; U48.3 194.55,52.96 194.89,53.3 v1(194.89,53.62) ; v3(196.91,156.19) VRAM3004.T10 ; 124.9,108.62 v1(124.9,108.65) ; 124.9,108.62 124.89,108.62 U35.AL28 ; 124.9,108.62 U35.AK27 ; VRAM3007.H14 v3(214.18,116.84) ; U3002.G19 191.29,133.95 v1(191.73,133.95) ; CN2020.10 v1(209.99,18.15) ; VRAM3007.B10 v3(218.99,120.84) ; v3(211.8,138.56) 212.2,138.17 VRAM3002.H2 ; U3002.K30 188.08,142.54 v1(188.04,142.54) ; U3002.AL24 U3002.AL23 170.93,137.01 v1(170.53,136.61) 170.53,136.59 U3002.AM22 169.73,136.59 v1(169.73,136.62) 169.33,136.22 U3002.AN22 168.93,136.59 v1(168.93,136.62) ; v3(180.16,161.84) 180.06,161.84 179.71,162.19 VRAM3001.K1 ; VRAM3004.K2 189.73,160.21 v3(189.73,160.19) 189.33,160.59 VRAM3004.K1 ; v1(193.4,179.34) 192.06,178 CN10.57 ; VRAM3001.F10 172.88,159.38 v3(172.88,159.41) 172.5,159.79 VRAM3001.G10 ; VRAM3007.N14 v3(209.37,116.82) ; v3(218.98,124.04) VRAM3007.B5 ; VRAM3002.B10 207.4,144.55 v3(207.79,144.16) ; U35.AH67 v3(102.46,109.8) ; U44.23 168.69,73.33 169.23,73.87 C768.2 ; U35.AL64 U35.AL65 104.09,107.34 v3(103.84,107.1) 103.44,107.5 U35.AL66 ; VRAM3004.R3 190.93,156.6 v3(190.56,156.23) ; VRAM3002.K2 213.44,137.8 v3(213.44,137.74) ; v3(212.58,118.49) 212.58,118.43 VRAM3007.K13 ; U3002.F28 191.91,141.22 v3(192.31,141.62) ; U3002.K7 188.49,123.64 188.91,123.22 v1(188.91,123.22) ; v3(215.79,119.25) 215.79,119.23 VRAM3007.E12 ; VRAM3002.R4 v3(218.17,140.14) ; 134.59,107.97 134.59,108.15 U35.AK11 ; 134.59,107.97 v3(134.54,107.97) ; 134.59,107.97 134.53,107.91 133.91,107.91 133.58,107.58 U35.AM13 ; v3(218.2,139.36) 218.2,139.36 VRAM3002.R3 ; U3002.T18 v1(183.16,133.51) U3002.U19 ; VRAM3002.K13 213.42,146.58 v3(213.42,146.58) ; v3(129.76,109.5) 130.09,109.83 U35.AG19 ; U3002.R23 U3002.T22 183.73,136.93 184.71,135.94 U3002.R21 185.2,135.47 v1(185.21,135.47) 185.21,135.46 U3002.P20 v1(186.2,134.47) ; v3(179.29,161.79) VRAM3001.K2 ; VRAM3001.M10 172.55,163.85 v3(173.07,163.85) ; v3(176.11,163.4) 176.49,163.01 VRAM3001.L5 ; VRAM3001.R14 169.26,166.17 v3(168.74,166.17) ; v3(200.31,168.03) 199.95,168.03 VRAM3004.A14 ; v3(189.73,161.82) VRAM3004.H2 ; VRAM3004.T5 192.53,155.76 v3(192.89,155.4) ; v3(216.16,136.75) 216.2,136.78 VRAM3002.N1 ; v3(208.59,120.03) 208.59,120.04 VRAM3007.P10 ; VRAM3007.H13 v3(214.18,117.64) ; VRAM3004.N14 v3(200.11,158.6) ; U19.15 v1(215.45,57.04) ; VRAM3004.B10 v3(196.15,167.4) ; v3(175.56,143.34) 175.58,143.34 U3002.AE30 ; v3(177.69,154.59) VRAM3001.A3 ; v3(211.81,116.86) VRAM3007.K14 ; U35.AF10 135.27,110.61 v3(135.27,110.94) ; U35.Y17 v3(131.06,112.83) U35.AB18 ; VRAM3001.U1 179.87,167.97 v3(180.25,167.97) ; VRAM3004.U14 200.11,155.4 v3(200.26,155.4) ; v1(168.93,131.59) U3002.AN16 v1(169.73,131.59) U3002.AM16 170.93,130.39 U3002.AL15 170.74,130.16 170.74,129.72 U3002.AL14 ; U3002.B1 195.64,118.74 v1(195.69,118.69) ; v1(190.63,135.77) 191.03,136.16 U3002.G22 ; VRAM3002.C4 208.2,139.76 v3(208.6,139.36) ; U35.AP28 v3(123.98,105.83) U35.AR28 ; VRAM3001.C11 171.69,156.59 v3(172.09,156.19) ; v3(193.91,134.11) 194.33,133.69 U3002.C19 ; v3(134.03,105.76) 134.24,105.76 U35.AR11 ; v3(215.25,123.89) 215.38,124.02 VRAM3007.F5 ; VRAM3001.H14 168.89,160.2 v3(168.89,160.19) ; U35.K16 132.67,118.91 U35.H15 133.32,118.39 U35.J13 v3(134.04,118.78) 134.11,118.78 U35.J11 ; v3(211.02,140.97) 211.02,140.93 VRAM3002.G5 ; VRAM3007.K1 v3(212.18,128.16) ; v1(189.08,147.26) 188.78,146.96 188.78,145.64 U3002.K33 U3002.K32 ; v3(209.4,144.16) 209.39,144.16 VRAM3002.D10 ; v3(214.22,144.12) 214.6,144.49 VRAM3002.L10 ; U3002.AN30 v1(168.82,143.35) ; U3002.AH29 173.86,141.71 v1(173.86,141.67) U3002.AH28 ; v1(175.59,140.84) 175.59,140.85 U3002.AE28 ; U35.AR35 120.4,105.18 v3(120.39,105.18) ; VRAM3001.R12 170.89,166.19 170.92,166.23 v3(171.29,166.59) ; v1(170.53,127.44) U3002.AL12 170.53,128.24 v1(170.53,128.29) U3002.AM13 U3002.AN13 ; U3002.AH19 173,133.26 v1(172.99,133.26) ; U3002.C7 U3002.B7 195.25,123.57 196.25,123.57 196.47,123.34 v1(196.78,123.34) ; v1(189.57,173.22) 189.87,173.22 190.15,173.5 CN10.75 ; v3(178.25,168.4) 178.09,168.24 VRAM3001.U3 ; v3(136.49,113.12) 136.49,112.91 136.78,112.62 U35.AB8 ; VRAM3002.R12 217.82,146.16 v3(218.2,146.54) 218.2,146.55 VRAM3006.C13 ; U35.E56 109.21,121.3 v3(109.38,121.3) ; v3(168.72,167.87) 169.21,167.87 VRAM3001.U14 ; v3(211.78,148.23) 211.78,148.17 VRAM3002.H14 ; v3(216.61,145.77) 216.59,145.77 VRAM3002.N12 ; v3(191.33,166.62) 190.93,166.22 VRAM3004.C3 ; v3(218.99,144.17) 218.99,144.17 VRAM3002.T10 ; v3(207.8,146.56) 208.2,146.17 VRAM3002.C12 v3(208.6,146.56) ; U3002.AC22 v1(177.22,136.45) U3002.AB21 ; U35.Y21 v3(128.46,112.83) ; U3002.C13 193.91,128.27 v1(193.91,128.26) ; CN2020.9 v1(212.15,18.65) ; v1(171.33,133.27) 171.33,133.24 U3002.AL18 ; VRAM3004.H1 189.25,162.22 v3(188.91,161.87) ; U3002.AH24 173.03,137.44 v1(173,137.44) ; U35.B10 U35.D10 135.45,121.76 U35.D11 134.63,121.76 134.26,121.4 v3(134.04,121.4) 134.44,120.99 U35.E11 ; v3(218.19,125.63) VRAM3007.C3 ; VRAM3002.T5 218.99,140.96 v3(218.99,140.97) ; U35.P19 129.92,115.97 v3(129.76,116.18) U35.N19 ; CN10.63 v1(189.84,176.5) ; v3(206.19,148.18) 206.19,148.16 VRAM3002.A14 ; v3(209.85,128.19) 209.85,127.7 VRAM3007.N1 ; v3(133.86,108.79) 133.86,109.01 U35.AH13 133.51,109.36 132.99,109.36 U35.AJ15 ; v1(171.49,69.11) 170.75,68.37 U44.32 ; v3(198.53,166.62) VRAM3004.C12 ; PC206.1 201.19,55.59 v1(201.55,55.95) ; VRAM3004.E3 191.31,164.99 v3(191.36,164.99) ; U35.AR46 v3(114.85,105.18) ; VRAM3007.M5 210.19,124.83 v3(210.19,124.83) ; v3(211.8,146.56) VRAM3002.H13 ; VRAM3007.A12 v3(218.99,118.44) ; v3(207.79,124.82) 207.79,124.84 VRAM3007.R4 ; CN10.33 v1(192.33,184) ; U35.AU32 v3(122.11,103.86) ; v3(188.73,156.53) 188.81,156.62 VRAM3004.R1 ; U35.AB21 128.4,112.02 v3(128.24,112.02) 128.24,111.8 128.47,111.57 U35.AD21 ; U3002.D2 193.66,119.36 v1(193.66,118.84) ; U3002.N7 185.58,124.04 v1(185.58,124.04) ; v3(176.89,166.59) VRAM3001.R4 ; U3002.Y19 U3002.AA20 ; VRAM3004.R4 191.33,157.01 v3(191.28,157.01) ; v1(222.31,61.61) 222.31,60.85 221.02,59.57 U19.5 ; v3(130.4,107.78) 130.74,108.12 U35.AK18 ; VRAM3002.U3 219,139.35 v3(219,139.36) ; VRAM3007.L10 210.99,120.04 v3(210.99,120.03) ; U3002.G13 191.45,128.27 v3(191.47,128.27) ; U3002.D31 v1(193.92,144.14) ; VRAM3001.C1 180.06,156.96 v3(180.06,156.99) ; v3(196.91,157.79) VRAM3004.P10 ; v3(211,144.96) 211,144.95 VRAM3002.G10 ; U3002.G28 191.06,141.24 v3(191.45,141.62) ; U14.3 164.41,89.57 v1(164.44,89.59) ; U35.V18 131.03,114.38 v3(131.03,114.51) 131.03,114.63 U35.T18 ; CN23.39 165.25,102.42 v1(165.54,102.13) ; U3002.T28 183.91,141.67 v3(183.99,141.67) ; v3(192.33,125.8) U3002.E10 ; v3(179.29,160.19) VRAM3001.H2 ; v3(138.4,115.35) 138.4,115.45 138.11,115.73 U35.R6 138.4,116.05 138.4,116.49 U35.N6 ; U35.AF15 133.03,111.07 v3(133.03,111.14) ; v3(190.61,130.76) 191.03,131.17 U3002.G16 ; VRAM3004.A1 189.2,167.94 v3(188.78,167.94) ; U49.3 v1(194.98,33.82) ; v3(111.12,105.18) U35.AR52 ; v3(112,120.67) 112.32,120.99 U35.E50 ; v3(196.95,163.44) VRAM3004.G10 ; U35.AP32 v1(122.11,105.81) ; CN10.39 v1(189.67,182.5) ; v1(179.15,136.46) 179.15,136.52 U3002.AA22 ; v3(196.93,166.62) VRAM3004.C11 ; v3(217.39,118.44) VRAM3007.C12 ; U3002.AH22 173.4,136.19 v1(173,136.59) ; U3002.AH13 173.81,128.31 v1(173.81,128.28) ; U35.E46 114.01,120.62 v1(113.93,120.62) ; VRAM3007.C11 218.18,120.03 v3(218.19,120.03) ; v3(178.49,156.99) 178.09,156.59 VRAM3001.C3 ; v3(219.51,128.19) 219.51,127.76 VRAM3007.A1 ; CN23.45 163.75,102.42 v1(163.5,102.17) ; U35.AR53 v3(110.26,105.16) ; U35.AN58 v3(107.55,106.49) ; v3(194.72,130.81) 194.34,131.19 U3002.C16 ; v3(177.69,166.59) 177.69,166.59 VRAM3001.R3 ; CN2021.A1 7.92,117.15 v1(8.21,116.86) ; VRAM3007.C14 217.39,116.84 v3(217.36,116.84) ; U35.AR16 v3(132.21,105.18) ; VRAM3005.C13 170.09,166.19 v3(170.49,166.59) ; v1(155.98,31.26) 156.11,31.39 156.89,31.39 157.14,31.13 U50.3 ; VRAM3001.N3 178.48,164.2 v3(178.48,164.16) ; U35.B62 v3(105.75,122.23) U35.D62 ; U44.16 164.42,71.87 164.14,72.16 v1(164.14,72.44) ; v3(179.31,155.37) VRAM3001.A1 ; VRAM3007.U14 206.17,116.82 v3(206.17,116.82) ; CN95.4 v1(110.75,17.24) ; U35.AR58 v3(107.55,105.19) ; v3(172.88,165.76) 172.51,165.39 VRAM3001.P10 ; U35.AD20 v3(129.76,111.15) U35.AD19 ; v3(104.77,106.49) U35.AN63 ; VRAM3007.L5 210.98,124.03 v3(210.98,123.99) ; VRAM3002.U14 219.5,147.87 v3(219.5,148.33) ; VRAM3001.B10 172.49,155.8 v3(172.89,156.2) ; VRAM3007.E1 215.91,127.91 v3(215.91,128.21) ; v3(188.78,154.58) 188.89,154.58 VRAM3004.U1 ; VRAM3007.C1 v3(217.78,128.18) ; v3(170.53,164.99) 170.89,164.64 VRAM3001.N12 ; v3(196.15,163.44) 196.15,163.44 VRAM3004.F10 ; CN23.57 160.75,102.47 v1(161.09,102.13) ; U35.G66 103.72,120.32 v3(103.72,120.81) 103.96,121.05 U35.E65 ; U35.J11 U35.L11 134.92,117.62 U35.N10 ; U3002.AN4 169.74,121.6 v1(169.74,121.61) ; v3(176.9,164.2) VRAM3001.M5 ; VRAM3001.T5 176.47,166.99 v3(176.08,167.38) ; U3002.AP33 168.53,145.92 v1(168.5,145.94) ; v3(133.12,105.18) U35.AR15 ; VRAM3007.A14 v3(218.99,116.84) ; v3(197.74,154.63) VRAM3004.U12 ; CN2021.A12 v1(8.26,122.65) ; v3(104.77,105.84) U35.AP63 ; v3(192.91,162.64) VRAM3004.G5 ; v1(170.52,139.11) 170.52,139.13 U3002.AL26 ; U35.AK63 104.74,109.07 U35.AH64 v3(104.41,109.8) ; U3002.Y23 179.66,138.01 v1(179.66,138.52) ; U35.D53 110.88,121.56 110.88,121.15 U35.E53 ; VRAM3001.K13 170.46,161.82 v3(170.52,161.82) ; v3(208.6,145.76) VRAM3002.C11 ; U35.AM25 v3(125.84,107.15) ; v3(199.35,161.01) 199.35,161 VRAM3004.K14 ; U3002.AL28 v1(170.52,141.6) ; CN23.3 174.25,102.39 v1(174.48,102.17) 174.75,102.44 CN23.1 ; v1(171.33,132.43) 171.31,132.43 U3002.AL17 ; v1(183.9,144.14) 183.88,144.14 U3002.T32 ; v3(219.86,126.51) VRAM3007.A3 ; v3(219,146.58) 219,146.55 VRAM3002.U12 ; v3(168.9,154.58) 168.9,154.6 VRAM3001.A14 ; U35.AF17 v3(131.71,111.15) U35.AD16 U35.AB16 132.3,112.15 132.42,112.15 U35.AB15 133.09,112.01 133.09,111.91 U35.AD13 133.79,111.21 v3(133.79,111.02) ; CN10.7 192.86,190.5 193.22,190.14 v1(193.6,190.14) ; U3002.AM25 169.73,139.09 v1(169.73,139.12) ; v1(209.99,20.15) CN2020.6 ; U35.W13 133.53,113.85 133.2,114.18 v3(133.2,114.21) 133.2,114.41 U35.T15 ; VRAM3001.F5 176.49,158.99 v3(176.89,158.59) ; v3(190.56,158.59) VRAM3004.N3 ; U19.12 219.52,54 219,53.49 v1(219,52.6) ; CN23.15 171.25,102.38 v1(171.51,102.13) 172.4,102.13 172.75,102.48 CN23.9 ; v3(170.51,168.17) VRAM3001.U12 ; U35.AU15 132.99,104.53 v3(133.09,104.53) ; v3(207,140.16) VRAM3002.B5 ; v1(186.41,142.56) 186.03,142.94 U3002.N30 ; VRAM3007.E3 v3(216.59,125.63) ; VRAM3004.B5 v3(193.16,167.02) ; CN23.27 168.25,102.47 167.95,102.17 v1(166.75,102.17) CN23.33 ; v3(192.13,166.62) VRAM3004.C4 ; v3(198.53,157.81) 198.13,158.21 VRAM3004.N12 ; U35.AT28 v3(123.98,105.18) ; v3(137.11,117.35) 137.11,117.41 U35.L8 136.78,117.93 U35.J8 ; v3(206.82,128.19) 206.58,127.96 VRAM3007.U1 ; VRAM3004.A12 v3(198.51,167.44) ; U35.AN28 v3(123.98,106.48) U35.AN30 v3(123.05,106.48) U35.AN32 v3(122.11,106.46) ; v1(119.41,108.65) U35.AL38 ; VRAM3007.M10 210.19,120.04 v3(210.19,120.03) ; v3(200.34,164.62) 200.33,164.62 VRAM3004.E14 ; v3(168.9,156.17) 168.9,156.2 VRAM3001.C14 ; U35.AR23 v3(126.72,105.18) U35.AT23 ; U3002.AH16 v1(173.03,131.59) ; v3(210.2,146.56) VRAM3002.E12 ; v3(210.2,139.36) VRAM3002.E3 ; VRAM3002.L5 214.98,140.94 v3(214.98,140.94) ; U3002.AB32 v3(178.88,144.14) ; v3(168.89,157.79) VRAM3001.E14 ; U35.AP58 v3(107.55,105.84) ; U35.J25 v3(125.81,118.54)
  BOTTOM w0.381: C4804.2 200.23,24.58 v1(200.36,24.71) ; PC79.1 156.49,60.72 v1(156.17,60.4) ; C356.2 81.61,81.67 v1(81.59,81.66) ; C712.2 143.59,109.75 v1(142.83,108.99) ; D2.2 87.25,85.87 v1(87.51,85.62) ; v1(106.96,131.92) 106.96,131.38 R553.1 ; U3002.T20 183.71,134.94 v1(183.2,135.44) 182.73,135.92 U3002.U21 ; v1(142.3,132.18) 142.5,131.97 C808.1 ; C357.2 87.38,84.73 v1(87.51,84.6) ; v1(134.7,179.06) 134.35,178.71 C803.1 ; C4737.2 171.51,84.24 v1(172.42,83.33) 172.9,83.82 D4013.2 ; v1(224.08,122.19) 224.86,121.42 C187.1 ; C4793.2 176.21,24.35 v1(176.61,24.76) 176.89,24.76 177.35,24.3 C4792.2 ; v1(226.02,119.58) 226.85,118.74 Q19.1 ; R393.2 209.62,45.75 v1(209.75,45.62) ; v1(120.07,126.38) 120.44,126.76 C664.2 C678.2 ; C728.1 80.93,121.18 81.72,120.39 v1(81.72,120.39) ; R621.1 95.53,103.79 95.76,103.55 v1(95.76,102.92) ; U3002.W15 v1(180.19,130.48) U3002.Y16 ; v1(224.08,127.93) 224.74,127.93 C170.1 ; v1(83.6,87.27) 83.12,86.8 D3.2 ; PC43.2 137.64,186.18 v1(137.87,186.41) ; U3002.U12 U3002.V12 U3002.W13 v1(180.15,128.52) U3002.Y14 v1(179.24,129.42) U3002.AA15 ; C374.2 83.34,85.49 84.03,86.18 v1(84.03,86.79) ; R750.2 v1(212.65,38.75) ; C667.2 C675.2 118.79,126.9 v1(119.31,126.38) ; v1(125.53,169.95) R450.2 ; C325.2 125.38,93.78 125.38,95.12 124.99,95.51 v1(124.81,95.51) ; C4807.2 196.78,24.58 v1(196.86,24.66) ; v1(181.17,129.35) 181.58,128.94 U3002.V14 U3002.U14 ; U3002.N14 186.63,128.94 v1(186.2,128.51) 186.2,128.41 185.73,127.94 U3002.P13 ; C4736.2 168.84,83.08 v1(168.71,82.95) ; U3002.Y19 v1(180.23,133.44) U3002.W18 ; C720.1 14.3,87.66 v1(14.63,87.33) ; v1(214.53,107.08) 214.53,106.85 214.7,106.69 C4024.1 ; v1(82.2,120.9) 80.78,122.32 C723.1 ; v1(67.75,21.36) 67.52,21.58 PC84.2 ; U3002.AN1 169.33,118.1 v1(169.55,117.88) ; U3002.AB23 178.3,138.52 v1(178.3,138.54) ; U3002.AB7 v1(178.48,122.74) U3002.AB5 ; U3002.AB2 178.89,119.95 v1(178.9,119.95) ; C672.2 v1(148.65,120.97) 148.21,120.97 147.76,121.43 R569.2 ; C821.1 v1(202.11,179.22) ; v1(125.71,161.18) 126.23,161.7 PR225.2 ; C4789.2 194.52,24.28 194.98,24.73 v1(195.31,24.73) 195.66,24.38 C4788.2 ; U3002.V19 181.73,134.04 181.41,134.35 v1(181.34,134.45) ; C4733.2 170.44,81.82 170.7,81.55 v1(170.87,81.55) ; v1(49.37,83.95) 49.73,83.95 49.97,83.71 PR135.1 ; v1(94.71,100.54) 95.05,100.88 R760.2 ; C1169.2 156.42,93.2 v1(155.87,93.2) ; C4734.2 168.38,81.82 v1(167.75,82.44) ; v1(168.92,124.11) 168.92,124.1 U3002.AN7 ; v1(187.04,126.44) 187.01,126.44 186.76,126.7 186.76,126.91 U3002.N12 U3002.M13 ; v1(170.87,82.19) 171.13,82.19 C4735.2 ; PR268.2 196.82,55.59 v1(196.5,55.26) ; PC98.2 59.72,20.34 v1(59.62,20.24) ; U3002.T15 v1(184.18,130.4) U3002.R16 v1(184.2,131.46) U3002.T17 ; PR112.2 204.8,54.5 205.12,54.82 205.15,54.82 205.44,55.11 205.44,55.88 v1(205.42,55.9) ; v1(85.4,82.7) 85.15,82.44 C353.2 ; v1(107.63,156.69) 107.24,156.31 R65.1 ; v1(149.51,141.65) 149.55,141.69 PC171.2 ; U3002.V23 U3002.U23 182.73,137.99 v1(182.2,138.52) ; v1(85.3,83.36) 85.07,83.59 C360.2 ; v1(123.63,127.68) 123.4,127.91 C679.2 ; C4809.2 189.92,24.23 v1(189.36,24.78) 188.78,24.2 C4810.2 ; C1168.2 v1(158.32,93.1) ; v1(167.75,83.08) 168.9,84.22 D4012.2 ; U3002.V21 181.73,135.98 180.77,136.94 U3002.W22 180.36,137.31 v1(180.27,137.31) ; U3002.AE2 v1(176.39,119.95) ; C509.2 197.41,44.27 v1(197.2,44.47) 197.41,44.67 C501.2 ; U3002.M18 188.06,132.61 v1(188.06,132.43) 188.06,132.33 187.73,132 U3002.M17 ; U3002.AB28 v1(178.05,140.81) ; 181.24,131.47 180.77,131.94 U3002.W17 ; 181.24,131.47 v1(181.24,131.47) ; 181.24,131.47 181.73,130.98 U3002.V16 U3002.U16 ; R648.2 132.4,88.1 v1(132.45,88.04) ; PC129.2 134.35,170.56 v1(133.99,170.91) ; v1(199.7,32.15) R399.2 ; C801.2 184.31,47.2 v1(184.31,46.76) ; C4790.2 193.35,24.38 193.05,24.68 v1(192.77,24.68) 192.51,24.68 192.21,24.38 C4791.2 ; U3002.W20 v1(180.2,135.47) U3002.Y21 ; v1(224.08,127.02) C169.1 ; C4803.2 183.06,24.56 v1(182.84,24.78) 182.25,24.78 181.92,24.45 C4796.2 ; C772.2 v1(186.87,46.63) ; v1(185.24,132.61) 185.24,132.43 U3002.P17 U3002.N16 ; v1(130.97,128.72) 131.45,128.72 131.76,128.42 C677.1 ; C321.1 C719.1 78.76,120.3 79.99,119.07 v1(79.99,118.64) ; v1(170.74,118.76) 170.74,119.31 U3002.AL2 ; v1(49.22,85.86) 49.43,85.64 PR289.1 ; C4801.2 185.35,24.43 185.07,24.71 v1(184.77,24.71) 184.46,24.71 184.21,24.45 C4802.2 ; v1(196.53,42.69) 196.28,42.45 C541.1 ; C4811.2 187.64,24.48 v1(187.33,24.78) 186.58,24.03 C4800.2 ; C806.2 v1(149.66,99.21) ; v1(197.16,42.69) 197.41,42.45 C510.2 ; PR224.2 136.5,164.77 136.33,164.94 v1(136.25,164.94) ; v1(47.07,82.44) R707.1 R706.1 ; U3002.R19 v1(185.2,133.47) U3002.P18 U3002.N19 ; C4794.2 175.06,24.66 v1(175.01,24.71) 174.76,24.71 174.08,24.03 C4795.2 ; v1(177.87,125.95) 177.87,126.8 U3002.AB12 U3002.AC13 ; v1(149.66,120.97) 149.54,120.85 C695.1 ; C4805.2 199.07,24.3 198.81,24.56 v1(198.51,24.56) 198.48,24.56 197.95,24.02 C4806.2 ; U3002.AC15 v1(177.15,130.36) ; v1(180.13,125.95) 180.13,126.54 U3002.Y12 U3002.AA13 U3002.AB14 ; v1(123.63,127.05) 123.6,127.02 C673.2 ; U3002.AE7 175.98,122.7 v1(176.1,122.57) 176.1,122.07 U3002.AE5 ; R759.2 144.45,103.4 v1(144.71,103.4) ; PC175.2 59.72,21.33 v1(59.62,21.43) ; C4799.2 178.49,24.15 v1(179.08,24.73) 179.63,24.18 C4798.2 ; v1(180.68,24.73) 180.78,24.63 C4797.2 ; v1(188.21,129.59) 188.08,129.59 U3002.M15 ; R957.1 v1(165.41,92.35) ; PR4.2 166.63,181.93 v2(167.82,180.74) ; U3002.M20 188.65,134.94 v1(188.8,135.09) ; v1(183.32,46.63) 183.34,46.6 D4015.1 ; v1(168.42,117.95) 168.53,118.06 U3002.AP2 ; C4808.2 v1(191.06,24.68)
  BOTTOM w0.406: U3002.AA18 178.89,132.94 v1(179.24,132.58) 178.73,132.07 U3002.AA17
  BOTTOM w0.483: v1(204.55,162.71) 204.53,162.71 203.9,162.08 R4550.1
  BOTTOM w0.508: PQ18.1 205.25,52.43 v1(205.25,52.1) ; R4332.1 161.97,124.31 163.15,123.13 163.96,123.13 v1(164.34,123.51) ; v1(109.04,22.96) 108.98,23.02 R2872.2 ; R612.1 v1(145.6,105.94) ; C1261.2 v1(102.16,41.04) ; C364.1 v1(36.89,89.18) ; v1(204.55,158.26) 204.91,158.26 205.03,158.13 Q4500.1 ; v1(204.53,169.56) 204.15,169.95 C4548.2 ; R4532.1 v1(164.27,165.25) ; CN95.9 v1(112.51,13.45) ; C136.1 144.72,135.9 v1(144.34,136.28) ; v1(208.21,46.63) 208.21,46.76 C492.2 ; C4687.2 211.41,113.69 211.11,114 v1(211.11,114.32) ; v1(170.11,110.79) 170.01,110.89 Q59.1 ; 226.37,104.92 227.26,105.81 v1(227.39,105.81) ; R555.2 v1(142.04,129.22) ; v1(197.36,113.81) 197.36,113.98 R4114.2 ; C435.2 v1(224.08,43.45) ; v1(122.15,17.42) 122,17.26 CN17.5 ; 31.33,92.55 U42.25 ; C428.2 v1(225.99,56.03) ; R4529.1 v1(204.55,155.47) ; Q40.1 v1(219.13,65.42) ; v1(224.08,127.93) 223.56,127.93 R11068.1 ; v1(57.44,70.63) 57.21,70.4 PC286.1 ; C1165.2 176.21,92.48 v1(177.09,91.59) ; v1(202.77,50.31) 202.77,49.84 C488.2 ; PC187.2 206.05,51.96 v1(205.92,52.09) ; R214.2 165.8,88.28 v1(165.13,88.28) ; v1(171.82,107.45) 171.5,107.78 171.5,108.61 ; v1(194.11,33.8) 193.6,33.29 Q30.1 ; v1(201.86,49.93) 202.12,50.19 C456.2 ; 13.65,84.47 14.2,84.47 14.46,84.22 v1(14.66,84.22) ; Y4.2 111.54,129.78 v1(111.54,129.36) ; SW2.6 v1(221.12,31.13) ; v2(167.06,47.64) 167.04,47.62 PU16.2 ; R4116.2 195.89,114.24 196.32,113.81 v1(196.35,113.81) ; v1(164.52,85.5) 163.52,85.5 C332.1 ; PC233.2 163.91,44.72 v1(164.27,45.08) ; C4726.2 v1(174.81,48.29) ; 164.65,140.35 v1(164.65,139.21) ; C1163.2 177.86,91.46 v1(177.73,91.59) ; v1(64.37,120.7) 64.37,120.95 63.67,121.65 CN8.3 ; v1(189.15,105.07) 189.15,104.54 R4326.1 ; v1(106.36,129.43) 106.61,129.18 R156.1 ; CN20.30 v1(148.95,14.8) ; C713.1 v1(11.76,87.66) ; C4528.2 v1(164.27,168.68) ; R4556.1 164.34,157.37 v1(164.22,157.5) ; v1(170.16,21.1) 170.49,20.77 170.49,19.17 CN2019.30 ; v1(174.68,100.81) 175.85,101.98 CN23.76 ; R447.2 122.34,169.94 121.96,169.94 v1(121.72,170.17) ; C812.1 v1(197.53,30.48) ; C780.2 v1(190.56,31.64) ; v1(113.85,168.17) 113.47,168.17 112.07,166.77 112.07,165.94 CN5.42 ; v1(151.85,107.08) R598.1 R766.1 ; v1(159.44,34.06) 159.31,33.93 C813.1 ; R196.2 v1(145.6,100.22) C732.2 ; PR49.2 v1(141.92,187.68) ; C777.2 v1(179.89,48.69) ; v1(154.87,100.86) 155.15,101.14 CN23.77 ; CN20.28 v1(151.42,15.75) ; PR85.1 173.16,87.78 173.03,87.9 v1(173.03,88.16) ; PC232.2 160.46,51.2 160.2,51.45 v1(160.23,51.45) ; v1(177.18,105.38) 177.23,105.43 Q4200.1 ; D4002.2 172.43,23.89 v1(171.53,23.89) ; C4686.2 212.94,113.69 213.19,113.94 v1(213.19,114.32) ; v1(192.56,38.22) 192.3,38.22 C490.1 ; PC113.1 v1(193.99,108.35) ; v1(178.49,89.55) 178.61,89.67 C1164.2 ; v1(164.24,164.48) 164.44,164.48 R4534.1 ; Q4201.1 v1(172.53,105.11) ; v1(155.76,35.83) 156.14,35.45 156.77,35.45 ; v1(194.35,45.88) 194.35,45.51 C494.2 ; C4030.1 v1(207.08,107.2) ; CN2019.29 202.45,17.25 v1(202.42,17.22) ; v1(230.94,102.13) 229.78,102.13 C740.2 229.7,100.98 v1(230.94,100.98) ; C4036.2 v1(161.98,144.67) ; C489.2 207.96,48.15 v1(208.34,48.53) ; C824.1 C823.1 143.69,136.93 144.07,137.31 v1(144.46,137.31) ; v1(172.93,20.19) 172.95,20.21 172.98,20.21 CN2019.28 ; R4005.1 v1(219.53,108.99) ; R375.2 200.86,36.34 200.86,36.33 v1(201.1,36.09) ; v1(169.09,36.19) 169.24,36.33 R783.2 ; C527.2 v1(201.86,35.58) ; C484.2 199.32,46.88 v1(199.19,46.76) ; R389.2 v1(190.57,28.34) ; R11093.1 209.75,154.19 v1(209.75,154.69) ; v1(162.32,50.9) 162.11,50.69 161.85,50.43 PC241.1 ; C525.2 v1(214.31,34.18) ; C508.2 v1(179.38,46.63) ; C1271.2 v1(83.37,41.04) ; C491.2 R380.1 v1(190.58,34.56) ; v1(178.09,172.62) 178.59,173.12 179.13,173.12 ; C4689.2 222.47,124.7 v1(222.05,125.11) ; v1(208.97,19.3) 208.97,19.7 C4711.2 v1(208.34,19.3) ; C785.1 v1(215.45,37.48) ; v1(170.03,24.86) 169.47,25.42 C798.1 ; PC177.2 54.72,54.88 v1(54.57,55.04) ; v1(174.81,46.76) 174.94,46.76 175.32,46.37 R785.2 ; C774.2 v1(162.35,71.52) ; v1(223.96,143.53) 224.34,143.91 Q4510.1 ; C3002.1 v1(116.31,19.58) ; v1(62.64,53) 62.16,53.49 PC112.2 62.07,53.51 PC111.2 PC107.2 ; Q27.1 v1(193.48,49.19) ; J1.2 79.33,19.25 v1(81.07,20.99) ; CN2020.27 v1(215.05,24.3) ; C811.1 190.8,53.48 190.43,53.11 v1(190.43,52.78) ; R4547.1 v1(204.53,164.74) ; R4206.1 165.32,133.27 v1(165.32,133.7) ; PR309.2 203.79,176.52 v1(203.56,176.75) ; v1(194.29,106.06) 194.67,106.06 195.13,105.61 195.13,104.79 ; v1(170.69,66.81) 170.5,66.61 C766.2 ; R606.1 v1(147.63,109.37) ; C1162.2 v1(179,102.76) ; v1(114.36,19.7) 113.77,19.7 113.51,19.45 EC53.1 ; v1(156.65,90.49) 156.34,90.19 R786.2 ; C436.2 v1(225.23,43.45) ; v1(187.89,116.78) 187.25,116.15 R4311.1 ; PC174.2 57.01,50.65 v1(57.38,51.02) ; R605.1 v1(145.6,107.08) ; v1(161.47,135.02) 161.46,135.01 161.46,134.4 C4202.2 ; C431.2 v1(219.89,61.61) ; CN17.10 117.54,14.24 v1(118.42,14.24) ; C4707.2 v1(224.08,126) ; v1(114.74,170.2) 114.74,171.1 CN5.44 ; v1(224.36,139.62) 224.36,138.26 CN6.5 ; C658.1 114.49,128.45 v1(114.2,128.16) ; R4212.1 190.89,114.01 v1(190.89,113.89) ; PC229.2 56.65,78.86 v1(56.88,79.09) ; C481.2 v1(205.42,50.31) ; v1(224.08,131.62) 224.2,131.5 CN6.6 ; PC32.2 134.16,174.89 134.52,175.25 v1(134.52,175.38) ; C775.2 165.79,64.66 166.06,64.4 v1(166.06,63.9) ; C628.2 v1(95.31,135.53) ; PC247.1 203.87,177.54 v1(203.59,177.82) ; v1(220.55,105.4) 220.55,105.93 C4025.1 ; v1(169.35,43.45) 169.61,43.45 C770.2 ; v1(125.74,159.28) 125.8,159.34 PC147.1 ; PC6231.1 79.3,97.77 79.27,97.74 PC6230.1 77.91,97.74 v1(77.72,97.56) ; CN95.10 v1(108.57,13.45) ; Q6059.1 v1(161.73,88.79) ; R595.1 v1(145.6,108.22) ; PR302.1 v1(170.74,49.42) ; CN6.1 223.69,135.59 v1(224.01,135.91) ; v1(110.48,159.53) 110.04,159.53 109.91,159.4 U1.5 ; v1(117.11,18.81) C783.2 ; R354.1 v1(210.75,46.37) ; EC46.2 v1(114.1,39.9) ; PC195.2 198.68,65.31 v1(198.68,65.42) ; C1166.2 173.91,93.74 v1(173.41,93.24) 173.91,92.74 C1167.2 ; v1(112.07,128.04) 111.93,128.17 C665.1 ; PC6225.1 v1(75.08,48.05) ; R4553.1 v1(164.22,158.39) ; v1(195.74,45.89) 196.09,46.25 C500.2 ; v1(178.11,51.96) 178.11,51.58 178.75,50.95 U41.4 ; C514.2 185.13,49.09 v1(184.71,49.09) 184.71,50.31 186.24,51.84 PAD13.1 ; C4674.2 v1(207.1,154.54) ; C4698.2 v1(224.08,127.02) ; v1(156.36,64.31) 156.32,64.27 156.32,62.95 PC77.1 156.58,62.21 156.17,61.79 v1(156.17,60.4) ; C4714.2 215.45,29.11 v1(215.45,29.36) ; v1(228.19,120.98) 228.5,121.28 SW1.6 ; v1(155.3,73.63) 155.65,73.97 PC80.2 ; R4313.1 v1(189.29,115.84) ; C807.1 163.13,68.87 163.37,69.11 v1(163.74,69.11) ; R394.2 v1(195.76,36.85) ; PC159.2 v1(133.66,144.16) ; v1(190.33,115.84) 190.33,115.24 R4310.1 ; v1(176.55,105.11) 175.9,105.76 175.9,106 C4200.2 ; v1(170.87,44.6) 170.87,44.35 C799.2 ; PC244.2 163.29,50.03 163.44,50.18 v1(163.44,50.21) ; R782.2 v1(189.93,30.5) ; C538.2 v1(206.18,9.93) ; C4675.1 v1(224.08,119.15) ; PC221.2 194.57,59.24 PR118.2 193.47,59.2 v1(191.62,59.2) ; EC48.2 v1(104.2,40.02) ; C362.1 139.87,92.6 v1(140.39,92.6) ; C788.1 v1(121.95,18.81) ; v1(112.32,154.78) 112.32,155.42 Q4.1 ; v1(175.7,171.86) 175.19,171.86 C4525.1 ; R729.1 166.81,64.02 v1(166.69,63.9) ; v1(151.82,108.1) 151.69,108.22 R592.1 ; C485.2 v1(198.89,48.03) ; C786.2 129.71,17.84 v2(129.72,17.85) ; C4750.1 22.41,68.6 v1(22.66,68.35) ; C4519.1 v1(168.2,172.61) ; EC50.2 v1(88.19,41.04) ; CN18.6 82.59,8.54 v1(83.09,9.04) ; PC252.1 204.22,178.53 203.94,178.81 v1(203.64,178.81) ; v1(165.41,63.89) 165.41,63.33 PC75.1 ; v1(203.82,173.98) 203.82,173.87 PC300.1 ; PC240.1 166.8,44.97 v1(166.68,44.85) ; C4753.2 21.78,72.67 v1(22.41,73.3) ; v1(215.45,33.04) 216.12,32.36 SW2.5 ; CN18.5 82.59,15.38 v1(82.1,14.88) ; v1(157.28,87.65) 156.9,88.03 Q6060.1 ; v1(126.55,14.5) 127.5,13.55 CN17.9 ; C818.1 100.01,133.12 v1(100.01,133.5) ; R4009.1 v1(164.67,143.54) ; C4749.1 21.78,70.41 v1(21.75,70.38) ; C453.2 v1(221.93,43.45) ; R558.1 v1(103.94,127.4) ; C4544.2 v1(169.35,172.61) ; C4692.1 v1(223.96,147.72) ; R4202.1 181.17,105.74 180.9,105.48 v1(180.9,105.3) ; R736.2 174.3,46.25 v1(173.79,46.76) 173.41,46.37 R735.2 ; Q4202.1 164.55,137.08 v1(165.03,137.56) ; C819.1 100.65,133.5 v1(100.64,133.5) ; C805.2 v1(149.79,16.66) ; C742.1 v1(130.87,94.38) ; C796.2 v1(172.27,46.63) ; C4713.1 v1(212.41,25.67) ; R11076.1 v1(223.96,145.56) ; C477.2 v1(209.73,46.37) ; SW2.4 v1(220.47,27.65) ; PC178.1 202.98,55.46 v1(202.98,54.86) ; C763.2 v1(200.33,186.22) ; C530.2 v1(202.88,35.58) ; R4011.2 v1(166.55,123.96) ; C771.2 179.95,25.55 180.19,25.79 v1(180.19,26.18) ; D34.2 v1(153.31,18.78) ; PC200.2 206.1,56.3 v1(206.1,55.9) ; C787.1 v1(119.14,18.81) ; PR102.2 206.76,58.67 v1(207.17,59.07) ; v1(161.98,129.08) 161.97,129.07 R4334.1 ; JDIM2.262 149.9,69.76 v1(150.93,68.73) ; Y4.4 114.31,132.65 v1(113.85,133.12) ; C4539.2 v1(170.49,172.61) ; v1(150.42,130.53) 150.42,130.96 149.41,131.97 C164.1 ; C4516.1 v1(164.27,169.82) ; v2(125.79,127.91) C663.2 C674.2 125.03,126.2 v1(125.48,125.75) ; C1256.2 v1(112.45,40.91) ; R4209.1 v1(186.24,113.81) ; R642.2 v1(132.52,94.38) ; C454.2 v1(225.94,57.93) ; v1(114.36,17.42) 114.02,17.42 EC52.1 ; v1(144.71,103.4) R624.2 ; C1273.2 v1(114.1,40.91) ; v1(219.89,62.25) 219.48,62.25 C412.2 ; PC176.2 54.49,53.87 v1(54.34,53.72) ; EC49.2 v1(102.16,40.02) ; C493.1 v1(204.53,48.28) ; C4547.2 v1(173.76,170.49) ; R463.2 v1(168.08,30.75) ; EC51.1 v1(12.38,116.73) ; CN2020.28 v1(213.85,9.93) ; C739.1 v1(129.72,94.38) ; R4343.2 v1(186.24,111.75) ; C800.2 v1(189.15,26.56) ; v1(169.91,74.31) C768.2 ; v1(207.3,62) 206.8,62 PR276.1 ; C4545.2 v1(204.53,168.93) ; v1(106.75,20.73) 106.61,20.87 C3008.1 ; R369.2 v1(193.6,45.87) ; R614.1 v1(145.6,104.79) ; C425.1 v1(215.45,53.92) ; C1254.2 v1(104.2,41.04) ; v1(145.47,102.25) 145.6,102.38 R127.1 ; C437.2 v1(222.94,43.45) ; EC47.2 v1(112.45,39.9) ; PC227.1 v1(196.53,52.34) ; C793.1 v1(146.23,119.4) ; v1(224.08,122.19) R11102.1 ; R739.2 184.33,46.73 v1(184.31,46.76) ; R968.1 v1(169.22,104.92) ; C515.1 v1(214.56,35.45) ; R256.2 v1(151.69,104.79) ; v1(142.02,179.34) 142.02,179.06 142.71,178.38 PJ1.9 ; R4549.1 v1(204.53,165.75) ; v1(140.24,97.06) C351.1 ; v1(221.42,36.6) 220.47,35.65 SW2.3 ; R4340.2 v1(181.16,111.78) ; v1(99.24,133.5) C815.1 ; C767.2 170.84,65.42 171.66,66.24 v1(172.27,66.24) ; v1(176.08,170.45) 176.08,170.93 C4111.1 ; C822.2 v1(190.56,32.53) ; C781.2 v1(133.03,18.3) ; C4526.1 v1(204.55,159.66) ; C776.2 v1(164.78,63.9) ; C4530.2 v1(204.53,167.91) ; C4203.2 v1(161.47,141.75) ; CN20.29 v1(180.9,10.69) ; C814.1 v1(103.05,133.5) ; R350.1 v1(203.64,48.28) ; C790.2 v1(132.14,18.3) ; R337.1 v1(225.99,57.04) ; C3007.1 v1(108.59,21.35) ; C4107.1 v1(204.53,166.9) ; v1(188.27,115.84) R4211.1 ; PC100.1 v1(56.19,79.77)
  BOTTOM w0.635: U25.2 v2(212.3,32.02)
  BOTTOM w0.762: PC275.2 224.44,166.95 v1(225.15,167.66) ; v2(221.42,186.07) 220.82,186.07 PC13.1 ; v2(65.77,37.97) 66.21,37.52 PC6226.1 ; PC6098.2 57.77,39.54 v1(57.92,39.69)
  vias: v1(9.2,84.47) v1(9.33,85.11) v1(9.71,120.47) v1(9.94,70.33) v1(9.96,85.11) v1(11.49,119.58) v1(11.51,114.73) v1(11.74,82.06) v1(12.12,119.58) v1(12.15,114.68) v1(13.75,113.53) v1(13.77,50.08) v1(13.77,48) v1(14.05,84.75) v1(14.41,92.53) v1(14.71,92.27) v1(14.66,84.98) v1(15.42,57.8) v1(16.57,40.3) v1(17.02,52.34) v1(17.2,40.3) v1(17.48,44.27) v1(17.46,23.01) v1(17.58,21.86) v1(17.84,40.3) v1(18.09,33.17) v1(18.09,15.01) v1(18.83,28.82) v1(19.03,52.34) v1(19.49,44.32) v1(19.49,23.01) v1(20.1,10.59) v1(21.77,15.77) v1(22.66,69.23) v1(22.66,67.46) v1(22.79,122.07) v1(22.92,120.29) v1(22.92,118.13) v1(22.92,32.79) v1(23.04,116.48) v1(23.68,69.23) v1(23.68,68.35) v1(23.68,67.46) v1(24.06,53.74) v1(24.06,53.11) v1(24.06,52.47) v1(24.36,122.6) v1(24.69,69.23) v1(24.69,68.35) v1(24.69,67.46) v1(24.82,27.32) v1(24.82,26.69) v1(24.95,32.66) v1(25.46,27.32) v1(25.46,26.69) v1(26.09,46.25) v1(26.29,122.02) v1(26.29,120.85) v1(26.32,50.31) v1(26.32,48.28) v1(26.5,52.34) v1(26.47,44.22) v1(26.68,57.68) v1(26.8,46.22) v1(26.98,50.31) v1(26.96,48.28) v1(27.62,36.09) v1(28.5,119.27) v1(28.5,118.64) v1(28.5,28.62) v1(28.53,27.32) v1(28.81,70.3) v1(29.01,117.62) v1(29.01,72.28) v1(29.14,123.46) v1(29.06,65.25) v1(29.44,70.17) v1(29.7,65.25) v1(29.72,27.93) v1(30.03,68.73) v1(30.16,115.97) v1(30.17,71.39) v1(30.66,69.62) v1(32.57,59.71) v1(32.92,75.37) v1(33.71,94.38) v1(33.71,93.75) v1(33.71,93.11) v1(34.47,115.59) v1(34.55,117.49) v1(34.85,98.7) v1(34.85,98.06) v1(35.36,97.17) v1(35.36,85.87) v1(35.36,84.98) v1(35.36,82.82) v1(35.62,77.41) v1(35.62,57.55) v1(35.62,55.52) v1(35.87,87.65) v1(36.12,74.44) v1(36.12,72.66) v1(36.12,70.89) v1(36.18,67.91) v1(36.25,123.46) v1(36.25,121.38) v1(36.25,117.62) v1(36.66,119.53) v1(37.01,97.4) v1(37.5,82.09) v1(37.9,74.44) v1(37.9,72.66) v1(37.9,70.89) v1(38.41,97.43) v1(38.39,58.03) v1(38.54,61.74) v1(38.54,61.11) v1(38.87,59.13) v1(38.87,58.44) v1(38.87,57.63) v1(39.05,124.73) v1(39.05,78.02) v1(39.15,108.02) v1(39.17,117.88) v1(39.3,120.92) v1(39.3,120.29) v1(39.3,97.43) v1(39.68,74.44) v1(39.68,72.66) v1(39.68,70.89) v1(39.81,117.88) v1(40.19,97.43) v1(40.7,121.69) v1(40.67,46.35) v1(40.82,76.27) v1(40.95,60.52) v1(41.2,119.65) v1(41.38,61.01) v1(42.22,46.37) v1(42.86,119.65) v1(42.86,117.62) v1(42.86,46.37) v1(43.16,122.24) v1(43.87,78.15) v1(44.25,56.03) v1(44.76,78.15) v1(44.76,56.53) v1(45.27,56.03) v1(47.28,120.01) v1(48.06,14.62) v1(48.7,14.62) v1(48.82,12.59) v1(50.86,12.59) v1(53.17,81.55) v1(55.91,27.1) v1(56.01,27.15) v1(56.32,60.32) v1(57.28,29.1) v1(57.79,71.55) v1(58.38,52.7) v1(58.53,51.56) v1(59.01,52.72) v1(59.31,72.92) v1(59.72,47.77) v1(62.87,95.17) v1(63.07,16.63) v1(63.38,77.19) v1(63.63,22.58) v1(63.68,20.85) v1(64.7,106.45) v1(64.7,105.18) v1(67.85,57.93) v1(69.4,56.84) v1(71.86,75.66) v1(74.71,122.91) v1(77.78,74.06) v1(78.75,72.79) v1(78.8,71.9) v1(79.66,32.3) v1(79.94,67.43) v1(79.97,68.4) v1(80.07,76.22) v1(80.45,78.89) v1(80.73,74.42) v1(81.72,74.95) v1(82.17,129.61) v1(83.5,81.17) v1(83.5,80.54) v1(84.24,46.44) v1(85.25,61.87) v1(85.25,59.2) v1(85.53,126.38) v1(85.65,10.69) v1(85.65,9.67) v1(86.04,126.89) v1(86.42,111.65) v1(86.42,111.02) v1(86.47,45.39) v1(86.65,15.67) v1(86.8,10.69) v1(86.8,9.67) v1(86.8,2.18) v1(86.95,61.61) v1(87.05,111.65) v1(87.05,111.02) v1(87.15,31.41) v1(87.25,126.33) v1(87.5,2.18) v1(87.74,126.82) v1(87.69,111.65) v1(88.47,45.23) v1(89.46,34.31) v1(89.72,126.38) v1(90,47.11) v1(90.1,126.89) v1(90.07,59.29) v1(90.15,11.55) v1(90.46,106.78) v1(90.91,106.32) v1(91.06,106.95) v1(91.55,106.32) v1(91.7,106.95) v1(91.7,60.24) v1(92,34.31) v1(92.13,127.02) v1(92.13,126.38) v1(92.17,21.98) v1(92.18,11.55) v1(92.33,106.95) v1(92.33,106.24) v1(92.77,127.02) v1(92.77,126.38) v1(93.15,120.67) v1(93.15,120.03) v1(93.4,111.6) v1(93.44,108.39) v1(93.4,37.99) v1(93.62,104.9) v1(93.78,120.67) v1(93.78,120.03) v1(94.04,60.38) v1(94.16,111.6) v1(94.2,21.98) v1(94.21,11.55) v1(94.28,110.14) v1(94.42,120.67) v1(94.42,120.03) v1(94.42,41.17) v1(94.54,34.31) v1(94.8,111.6) v1(95.05,120.67) v1(95.43,126.69) v1(95.43,111.6) v1(95.36,108.39) v1(95.35,59.72) v1(95.35,47.52) v1(95.52,104.9) v1(95.69,120.67) v1(95.69,120.03) v1(95.81,127.27) v1(96.19,110.14) v1(96.22,107.07) v1(96.23,21.98) v1(96.25,11.55) v1(96.58,40.02) v1(96.8,60.41) v1(97.08,34.31) v1(97.21,116.1) v1(97.43,104.93) v1(97.49,107.07) v1(97.47,57.97) v1(97.59,111.32) v1(97.69,102.32) v1(97.85,116.1) v1(97.83,103.13) v1(97.85,41.17) v1(98.09,108.62) v1(98.23,129.97) v1(98.28,33.14) v1(98.27,21.98) v1(98.28,11.55) v1(98.48,116.1) v1(98.61,126.56) v1(98.74,98.83) v1(98.74,40.02) v1(98.9,48.85) v1(99.37,97.94) v1(99.37,96.67) v1(99.37,94.76) v1(99.62,126.56) v1(99.62,34.31) v1(99.66,101.22) v1(99.88,117.11) v1(100.13,129.31) v1(100.15,100.03) v1(100.3,21.98) v1(100.31,11.55) v1(100.41,66.57) v1(100.51,117.11) v1(100.46,59.22) v1(100.46,47.02) v1(100.64,97.54) v1(100.64,96.27) v1(100.64,95) v1(100.77,129.31) v1(101.15,117.11) v1(101.78,117.11) v1(102.16,34.31) v1(102.34,11.55) v1(102.72,97.1) v1(102.72,95.83) v1(102.72,94.56) v1(102.93,61.61) v1(102.97,57.99) v1(102.97,46.71) v1(103.56,126.11) v1(104.18,149.32) v1(104.64,97.48) v1(104.65,95.55) v1(104.65,92.38) v1(104.7,34.31) v1(105.21,151.12) v1(106.72,61.63) v1(107.32,93.55) v1(107.57,97.7) v1(107.57,96.43) v1(107.57,95.16) v1(107.63,64.98) v1(107.65,61.61) v1(107.93,46.55) v1(108.39,40.02) v1(108.77,133.37) v1(108.97,45.12) v1(109.22,48.64) v1(109.25,20.26) v1(109.4,133.37) v1(109.41,97.02) v1(109.41,95.12) v1(109.41,92.99) v1(109.41,91.72) v1(109.38,60.34) v1(110.01,35.71) v1(110.23,45.29) v1(110.55,132.1) v1(110.63,96.64) v1(110.63,95.37) v1(110.63,93.47) v1(110.93,133.5) v1(110.88,97.86) v1(111.21,134.08) v1(111.33,110.74) v1(111.38,20.26) v1(111.56,163.88) v1(111.56,133.5) v1(111.69,132.25) v1(111.92,134.08) v1(111.86,49.05) v1(111.86,47.73) v1(112.02,164.33) v1(112.2,133.5) v1(112.2,35.71) v1(112.35,139.16) v1(112.55,134.08) v1(112.63,110.74) v1(112.71,111.78) v1(112.68,96.89) v1(112.68,94.95) v1(112.68,93.05) v1(112.83,133.5) v1(113.67,111.73) v1(113.72,48.21) v1(113.97,46.2) v1(114.74,158.9) v1(114.74,158.26) v1(114.74,157.63) v1(114.71,156.99) v1(114.99,117.24) v1(115.37,46.07) v1(115.63,117.24) v1(115.73,97.23) v1(115.73,95.96) v1(115.73,94.69) v1(115.68,53.41) v1(115.91,126.87) v1(115.88,114.07) v1(116.01,49.42) v1(116.06,157.14) v1(116.06,157.09) v1(116.21,125.6) v1(116.52,128.62) v1(116.52,117.24) v1(116.52,114.07) v1(116.64,130.53) v1(116.57,113.43) v1(116.61,45.42) v1(116.95,157.45) v1(116.95,131.13) v1(116.92,110.56) v1(116.92,97.61) v1(116.92,95.71) v1(116.92,94.44) v1(116.92,92.53) v1(116.97,156.74) v1(117.23,130.19) v1(117.23,129.56) v1(117.15,27.17) v1(117.64,159.1) v1(117.83,57.43) v1(117.86,59.97) v1(117.88,45.42) v1(118.09,46.93) v1(118.17,164.36) v1(118.67,39.9) v1(118.8,164.36) v1(118.93,134.39) v1(118.93,60.65) v1(119.23,68.22) v1(119.23,67.08) v1(119.15,63.27) v1(119.31,125.06) v1(119.37,97.47) v1(119.37,95.56) v1(119.37,93.65) v1(119.36,46.93) v1(119.4,20.75) v1(119.94,30.07) v1(119.94,26.87) v1(119.97,132.99) v1(120.2,134.26) v1(120.27,28.52) v1(120.58,167.02) v1(121.09,34.89) v1(121.15,97.51) v1(121.15,95.6) v1(121.15,94.33) v1(121.15,93.06) v1(121.41,46.53) v1(121.41,45.26) v1(121.49,60.22) v1(121.49,58.73) v1(121.49,57.46) v1(121.52,48.91) v1(121.69,20.7) v1(121.85,133.75) v1(122.24,41.07) v1(122.48,167.02) v1(122.71,61.59) v1(122.71,49.41) v1(122.9,97.17) v1(122.9,95.9) v1(122.9,93.99) v1(122.99,30.07) v1(123.48,120.21) v1(123.51,118.24) v1(123.62,67.95) v1(123.63,34.89) v1(123.65,60.34) v1(123.68,57.69) v1(123.68,45.54) v1(123.75,26.87) v1(124.15,118.19) v1(124.06,116.99) v1(124.06,116.35) v1(124.06,115.34) v1(124.14,113.81) v1(124.14,113.18) v1(124.14,111.53) v1(124.11,110.89) v1(124.34,49.3) v1(124.54,35.28) v1(124.8,156.94) v1(124.81,97.44) v1(124.81,93.6) v1(125.1,110.53) v1(125.2,140.02) v1(125.25,184.07) v1(125.29,60.4) v1(125.39,181.76) v1(125.35,124.94) v1(125.62,49.3) v1(125.91,140.23) v1(126.12,125.85) v1(126.17,34.89) v1(126.29,30.07) v1(126.29,26.87) v1(126.41,97.46) v1(126.41,95.56) v1(126.4,93.64) v1(126.55,140.23) v1(126.68,182.65) v1(127.14,67.59) v1(127.18,140.23) v1(127.16,59.56) v1(127.44,171.75) v1(127.82,140.23) v1(127.95,172.36) v1(127.89,129.31) v1(127.89,128.65) v1(128.14,96.25) v1(128.14,94.35) v1(128.24,110.24) v1(128.45,140.23) v1(128.58,172.23) v1(128.61,126.23) v1(128.68,174.57) v1(128.71,92.6) v1(128.71,34.89) v1(128.68,20.87) v1(128.83,30.07) v1(128.83,26.87) v1(128.96,131.85) v1(129.09,172.74) v1(129.09,140.23) v1(129.59,47.58) v1(129.67,185.9) v1(129.72,140.23) v1(129.72,59.78) v1(129.88,68.34) v1(129.85,65.66) v1(130.36,140.23) v1(130.59,174.59) v1(130.69,175.71) v1(130.99,130.17) v1(131.25,34.89) v1(131.42,49.42) v1(131.38,39.21) v1(131.37,30.07) v1(131.37,26.87) v1(131.5,139.97) v1(131.57,61.62) v1(131.73,46.55) v1(131.76,82.44) v1(131.88,134.64) v1(131.96,177.18) v1(132.1,176.09) v1(132.14,139.97) v1(132.11,58.62) v1(132.33,86.51) v1(132.52,134.64) v1(132.64,82.11) v1(132.64,81.46) v1(132.64,80.82) v1(132.7,132.48) v1(132.77,139.97) v1(132.77,41.8) v1(132.9,68.22) v1(133,128.7) v1(133.15,134.64) v1(133.41,139.97) v1(133.38,37.36) v1(133.79,34.89) v1(133.89,156.28) v1(133.91,30.07) v1(133.91,26.87) v1(134.04,142.77) v1(134.07,131.01) v1(134.09,59.97) v1(134.09,47.77) v1(134.42,125.6) v1(134.42,39.26) v1(134.47,124.96) v1(134.5,113.14) v1(134.7,129.41) v1(135.19,41.8) v1(135.31,134.64) v1(135.44,133.19) v1(135.97,131.24) v1(136.2,58.78) v1(136.2,46.58) v1(136.33,155.42) v1(136.29,66.04) v1(136.71,133.19) v1(137.06,158.34) v1(137.09,34.89) v1(137.85,80.28) v1(137.98,133.19) v1(138.23,30.07) v1(138.23,26.87) v1(138.32,175.62) v1(138.39,178.1) v1(138.41,176.96) v1(138.54,58.6) v1(138.54,46.4) v1(138.87,129.31) v1(138.99,96.06) v1(138.99,94) v1(139.43,128.65) v1(139.55,122.45) v1(139.6,61.01) v1(139.6,58.47) v1(139.63,34.89) v1(139.91,46.88) v1(140.09,176.02) v1(140.14,129.23) v1(140.16,177.08) v1(140.47,177.85) v1(140.77,129.23) v1(140.77,30.07) v1(140.77,26.87) v1(141.15,95.22) v1(141.15,94.56) v1(141.33,49.38) v1(141.41,129.22) v1(141.35,66.68) v1(141.35,65.89) v1(141.37,60.28) v1(141.37,59.19) v1(141.37,46.99) v1(142.17,34.89) v1(142.22,31.16) v1(142.68,129.23) v1(142.78,17.14) v1(143.19,60.33) v1(143.17,58.81) v1(143.17,46.61) v1(143.31,48.03) v1(143.31,30.07) v1(143.31,26.87) v1(144.71,34.89) v1(144.86,153.33) v1(145.12,35.94) v1(145.07,27.5) v1(145.34,68.47) v1(145.51,60.11) v1(145.66,47.88) v1(145.93,156.23) v1(145.85,30.07) v1(145.85,26.87) v1(146.36,34.89) v1(146.94,29.79) v1(146.97,61.08) v1(148.04,157.58) v1(148.35,111.63) v1(148.39,30.07) v1(148.39,26.87) v1(148.65,66.31) v1(148.64,65.64) v1(148.65,45.31) v1(149.03,38.07) v1(149.66,123.08) v1(149.92,26.87) v1(150.31,111.91) v1(150.55,87.65) v1(150.75,17.95) v1(150.93,74.29) v1(151.03,57.12) v1(153.85,100.22) v1(154.11,135.81) v1(154.74,134.39) v1(155,137.56) v1(155,105.05) v1(155.25,131.8) v1(155.89,141.62) v1(155.86,68.75) v1(156.39,135.02) v1(156.44,125.6) v1(156.42,124.45) v1(156.39,123.36) v1(156.52,51.23) v1(156.62,49.6) v1(156.62,48.97) v1(156.9,136.39) v1(157.13,142.89) v1(157.16,131.46) v1(157.23,121.89) v1(157.46,157.04) v1(157.99,68.35) v1(157.99,66.44) v1(158.17,137.69) v1(158.37,147.04) v1(158.63,84.3) v1(159.19,67.38) v1(159.31,147.09) v1(159.31,146.45) v1(159.31,145.82) v1(159.31,145.18) v1(159.31,144.55) v1(159.44,134.39) v1(159.8,107.33) v1(159.95,124.45) v1(160.13,126.89) v1(160.33,124.99) v1(160.33,68.35) v1(160.33,66.44) v1(160.43,122.68) v1(161.04,71.39) v1(161.32,143.53) v1(161.32,142.77) v1(161.47,75.58) v1(161.61,61.08) v1(161.61,60.45) v1(162.24,61.19) v1(162.62,120.54) v1(163.81,108.86) v1(163.81,66.82) v1(163.89,131.9) v1(164.52,131.9) v1(164.52,113.05) v1(164.83,115.08) v1(164.78,107.31) v1(165.13,111.14) v1(165.21,113.05) v1(165.28,138.2) v1(165.28,135.53) v1(165.72,131.46) v1(165.92,138.17) v1(165.92,137.54) v1(165.92,136.9) v1(165.92,136.27) v1(165.92,135.53) v1(166.25,128.72) v1(166.17,71.39) v1(166.17,70.12) v1(166.17,68.85) v1(166.3,146.53) v1(166.43,127.1) v1(166.43,119.4) v1(166.43,118.76) v1(166.65,122.18) v1(166.65,121.3) v1(166.68,74.7) v1(166.83,148.89) v1(166.81,147.59) v1(166.86,128.29) v1(167.09,111.27) v1(167.2,113.19) v1(167.39,116.68) v1(167.44,71.39) v1(167.44,70.12) v1(167.44,68.85) v1(167.52,179.14) v1(167.49,128.29) v1(167.65,131.44) v1(168.71,71.22) v1(168.71,70.12) v1(168.71,68.85) v1(168.97,150.92) v1(169.09,148.99) v1(169.98,86.76) v1(170.14,118.13) v1(171.02,86.99) v1(171.07,88.54) v1(171.66,75.74) v1(171.91,87.09) v1(172.14,79.7) v1(172.24,128.92) v1(172.27,138.45) v1(172.6,62.02) v1(172.9,76.65) v1(172.9,74.87) v1(172.95,40.53) v1(173.41,50.82) v1(174.17,116.73) v1(174.17,116.1) v1(174.17,115.46) v1(174.17,114.83) v1(174.17,113.94) v1(174.17,113.3) v1(174.17,112.41) v1(174.17,111.78) v1(174.17,110.94) v1(174.17,110.28) v1(174.68,32.4) v1(174.94,112.08) v1(174.94,59.71) v1(175.95,32.4) v1(176.43,62.35) v1(177.35,32.89) v1(177.4,181.78) v1(177.48,177.06) v1(179.38,56.92) v1(179.51,59.63) v1(180.14,116.86) v1(180.14,116.22) v1(180.14,115.34) v1(180.14,114.7) v1(180.14,113.81) v1(180.14,113.18) v1(180.14,112.29) v1(180.14,111.65) v1(180.14,111.02) v1(180.68,149.17) v1(181.16,113.81) v1(181.29,62.38) v1(181.54,61.74) v1(181.49,60.6) v1(182.81,100.35) v1(182.81,60.6) v1(183.09,151.66) v1(184.51,152.8) v1(184.97,138.58) v1(184.97,106.95) v1(186.16,180.21) v1(186.24,138.58) v1(186.62,168.17) v1(187.25,166.77) v1(187.64,164.61) v1(187.64,139) v1(188.07,131.46) v1(188.07,130.46) v1(188.07,126.43) v1(188.93,139.03) v1(188.96,138.27) v1(189.59,138.01) v1(191.45,134.89) v1(192.77,175.56) v1(192.87,173.76) v1(192.87,78) v1(193.86,175.28) v1(194.11,176.55) v1(194.47,174.52) v1(194.49,68.14) v1(195.41,181.22) v1(195.48,179.37) v1(195.89,146.73) v1(196.53,183.03) v1(196.63,174.21) v1(196.65,182.14) v1(196.65,177.18) v1(196.65,176.12) v1(196.65,175.23) v1(197.16,181.76) v1(197.29,151.61) v1(197.29,148.25) v1(197.64,128.54) v1(197.8,121.56) v1(197.9,131.11) v1(198.2,149.42) v1(198.91,150.51) v1(199.42,60.6) v1(199.43,59.8) v1(199.83,134) v1(200.28,60.57) v1(200.27,59.84) v1(200.77,131.08) v1(201.28,183.92) v1(201.99,163.88) v1(201.99,162.33) v1(202.24,131.59) v1(202.27,129.46) v1(202.49,188.06) v1(202.93,188.54) v1(202.88,44.09) v1(202.88,42.18) v1(202.88,40.53) v1(203.59,190.52) v1(204.4,184.93) v1(204.78,44.09) v1(204.78,42.18) v1(204.78,40.66) v1(205.75,175.41) v1(206.43,44.09) v1(206.43,42.18) v1(207.96,27.25) v1(209.05,175.51) v1(209.07,174.7) v1(209.38,111.12) v1(209.96,93.59) v1(210.75,175.48) v1(210.75,34.31) v1(211,17.34) v1(211.16,172.49) v1(211.36,150.59) v1(212.88,176.45) v1(212.91,20.59) v1(212.91,18.43) v1(213.43,150.59) v1(214.15,40.71) v1(214.43,16.91) v1(214.56,111.4) v1(215.25,48.38) v1(215.32,111.4) v1(215.55,129.31) v1(215.7,42.59) v1(216.08,111.4) v1(216.85,111.4) v1(217.56,129.28) v1(217.91,156.99) v1(219,130.58) v1(220.76,79.52) v1(220.96,171.72) v1(221.42,40.28) v1(221.42,38.37) v1(222.28,52.09) v1(222.94,34.69) v1(224.01,178.43) v1(224.97,34.69) v1(225.38,85.41) v1(226.75,101.39) v1(227.13,85.11) v1(227.13,84.47) v1(228.78,110.76) v1(228.78,110) v1(228.78,108.6) v1(228.78,107.59) v1(229.55,142.64) v1(230.16,180.92) v1(230.26,101.37) v1(230.87,148.61) v1(231.48,122.6) v2(0.95,126.89) v2(3.1,127.65) v2(3.1,114.32) v2(3.36,125.62) v2(3.87,94.13) v2(3.87,92.09) v2(3.99,67.33) v2(3.99,65.3) v2(3.99,61.49) v2(4.37,112.67) v2(4.76,113.94) v2(4.88,125.75) v2(4.88,95.65) v2(5.01,90.82) v2(5.39,6.5) v2(5.52,87.4) v2(5.52,85.36) v2(5.52,72.28) v2(5.52,70.63) v2(5.52,41.93) v2(5.77,59.07) v2(5.9,65.3) v2(6.03,61.49) v2(6.15,113.43) v2(6.15,39.52) v2(6.91,95.4) v2(7.17,5.99) v2(7.55,115.59) v2(7.55,41.93) v2(7.8,59.07) v2(8.18,39.52) v2(8.44,112.54) v2(8.82,96.29) v2(9.2,42.06) v2(9.58,23.51) v2(9.99,56.23) v2(9.96,44.72) v2(10.22,39.77) v2(11.61,23.51) v2(12.12,96.41) v2(12.27,39.62) v2(12.5,112.16) v2(12.76,97.3) v2(12.88,41.8) v2(13.26,93.36) v2(13.26,91.33) v2(14.43,23.57) v2(14.53,95.4) v2(15.3,93.36) v2(15.3,91.33) v2(15.68,10.56) v2(15.68,8.53) v2(17.4,11.15) v2(18.04,6.98) v2(17.96,0.91) v2(18.6,2.69) v2(18.73,4.46) v2(20.38,5.73) v2(20.76,127.65) v2(21.01,125.37) v2(22.15,123.84) v2(22.66,127.65) v2(23.04,125.37) v2(23.93,5.73) v2(24.19,123.84) v2(24.44,8.91) v2(24.69,127.65) v2(25.08,125.37) v2(25.96,5.73) v2(26.47,128.29) v2(26.47,8.91) v2(26.6,19.2) v2(26.98,129.94) v2(27.87,6.24) v2(28.63,19.2) v2(28.76,7.89) v2(29.01,129.94) v2(29.52,128.29) v2(30.66,19.2) v2(30.66,8.66) v2(31.3,127.65) v2(32.7,17.16) v2(32.7,15.13) v2(32.7,12.97) v2(32.7,10.94) v2(32.7,8.66) v2(33.33,127.65) v2(34.73,15.13) v2(34.73,12.97) v2(34.73,10.94) v2(34.73,8.66) v2(35.36,127.65) v2(36.76,12.97) v2(36.76,10.94) v2(36.76,8.66) v2(37.39,127.65) v2(38.28,109.75) v2(38.28,108.99) v2(38.28,108.22) v2(38.79,12.97) v2(38.79,10.94) v2(38.79,8.66) v2(39.43,127.15) v2(40.44,106.7) v2(40.44,105.94) v2(40.44,105.18) v2(40.82,12.97) v2(40.82,10.94) v2(40.82,8.66) v2(40.95,125.88) v2(42.47,7.51) v2(42.98,125.62) v2(43.62,5.86) v2(44.13,123.21) v2(44.13,121.18) v2(44.89,8.91) v2(45.01,125.62) v2(45.65,5.86) v2(46.16,123.21) v2(46.16,121.18) v2(46.92,8.91) v2(47.05,125.62) v2(47.68,5.86) v2(47.86,79.78) v2(48.19,123.21) v2(48.19,121.18) v2(49.08,125.62) v2(49.71,8.15) v2(50.07,80.54) v2(50.22,123.21) v2(50.22,121.18) v2(50.73,96.16) v2(50.73,94.63) v2(51.11,125.62) v2(51.62,93.75) v2(51.62,8.91) v2(52.25,123.21) v2(52.25,121.18) v2(52.46,81.1) v2(53.14,125.62) v2(53.07,80.66) v2(53.27,60.17) v2(53.4,7.89) v2(53.4,6.5) v2(53.85,60.8) v2(53.9,59.79) v2(54.23,37.23) v2(54.29,123.21) v2(54.29,121.18) v2(54.36,61.34) v2(54.49,60.4) v2(54.54,2.94) v2(54.95,61.84) v2(55.1,60.93) v2(55.17,125.62) v2(55.33,28.24) v2(55.33,25.9) v2(55.53,25.01) v2(56.19,28.24) v2(56.32,123.21) v2(56.32,121.18) v2(56.57,25.93) v2(56.57,2.94) v2(56.72,49.02) v2(56.7,25.01) v2(57.03,59.71) v2(57.11,28.26) v2(57.21,125.62) v2(57.36,48.41) v2(57.56,60.22) v2(57.59,6.75) v2(57.74,25.93) v2(57.77,24.99) v2(58.02,48.97) v2(58.6,8.66) v2(58.76,72.16) v2(58.76,48.43) v2(58.76,47.21) v2(58.81,25.9) v2(58.86,25.01) v2(59.37,94.89) v2(59.44,27.12) v2(59.52,26.23) v2(59.57,72.13) v2(59.75,95.52) v2(59.85,24.99) v2(60.13,94.89) v2(60.2,26.84) v2(60.25,25.62) v2(60.43,72.16) v2(60.51,95.52) v2(60.66,125.65) v2(60.84,26.28) v2(60.76,8.4) v2(60.89,94.89) v2(61.25,27.1) v2(61.27,95.52) v2(61.4,7) v2(61.65,94.89) v2(61.91,96.18) v2(62.24,124.38) v2(62.19,25.45) v2(62.41,2.94) v2(62.77,79.55) v2(62.79,78.79) v2(62.79,78.05) v2(63.51,79.55) v2(63.53,78.79) v2(63.53,78.05) v2(63.53,24.18) v2(64.04,122.85) v2(64.24,79.55) v2(64.27,78.79) v2(64.27,78.05) v2(64.7,2.94) v2(64.95,67.69) v2(64.95,66.31) v2(65.59,7.13) v2(66.2,122.19) v2(66.73,8.91) v2(68.76,8.91) v2(69.07,122.55) v2(70.29,42.82) v2(70.29,41.93) v2(70.29,41.04) v2(70.41,7.89) v2(70.41,5.86) v2(70.59,76.12) v2(70.62,75.13) v2(70.57,74.04) v2(70.59,73.02) v2(70.74,57.55) v2(71.25,123.9) v2(71.3,42.82) v2(71.3,41.93) v2(71.3,41.04) v2(71.35,58.06) v2(71.35,57.04) v2(72.32,125.45) v2(73.01,127.93) v2(73.21,74.95) v2(73.18,73.45) v2(73.49,130.25) v2(73.97,42.31) v2(73.97,41.42) v2(74.07,59.43) v2(74.07,58.54) v2(74.07,57.78) v2(75.49,129.05) v2(75.88,131.08) v2(76.97,129.28) v2(77.78,131.85) v2(77.87,128.38) v2(79.3,129.81) v2(79.48,127.83) v2(79.69,132.48) v2(80.92,129.27) v2(81.59,133.24) v2(82.35,130.7) v2(82.35,0.91) v2(83.37,134) v2(84.38,0.91) v2(85.15,134.89) v2(86.42,0.91) v2(86.92,135.91) v2(88.45,0.91) v2(88.58,136.93) v2(89.59,6.37) v2(89.59,4.34) v2(89.59,2.31) v2(89.85,8.4) v2(90.23,138.07) v2(91.88,139.34) v2(93.4,140.74) v2(94.93,142.13) v2(96.32,143.66) v2(97.72,145.18) v2(98.99,146.83) v2(100.13,148.48) v2(101.28,150.26) v2(102.29,152.04) v2(102.55,143.15) v2(102.55,142.39) v2(102.55,141.62) v2(102.55,136.8) v2(102.55,136.04) v2(103.18,153.82) v2(103.31,143.15) v2(103.31,142.39) v2(103.31,141.62) v2(103.31,136.8) v2(103.31,136.04) v2(103.94,155.59) v2(104.45,9.04) v2(104.7,157.5) v2(105.34,159.4) v2(106.23,161.18) v2(106.48,9.04) v2(107.12,162.96) v2(107.5,11.32) v2(108.01,164.74) v2(108.51,9.04) v2(108.9,166.52) v2(109.53,11.32) v2(109.78,168.29) v2(110.52,13.33) v2(110.55,9.04) v2(110.67,170.07) v2(111.56,171.85) v2(112.58,173.63) v2(112.58,9.04) v2(113.59,175.28) v2(114.61,9.04) v2(114.74,176.93) v2(116.01,178.45) v2(116.39,11.32) v2(116.64,9.04) v2(117.4,179.98) v2(118.42,13.35) v2(118.42,11.32) v2(118.67,9.04) v2(118.8,181.5) v2(120.02,157.55) v2(120.33,182.77) v2(120.3,158.31) v2(120.45,13.35) v2(120.45,11.32) v2(120.71,9.04) v2(121.04,157.53) v2(121.18,158.39) v2(121.85,184.04) v2(122.48,13.35) v2(122.48,11.32) v2(122.74,9.04) v2(122.99,157.25) v2(122.99,156.48) v2(122.99,154.83) v2(123.5,185.31) v2(123.73,157.25) v2(123.73,156.48) v2(123.73,155.72) v2(123.73,154.83) v2(124.52,13.35) v2(124.52,11.32) v2(124.77,9.04) v2(125.15,186.33) v2(125.94,158.36) v2(125.94,157.63) v2(125.94,156.89) v2(125.96,156.15) v2(126.29,186.96) v2(126.83,158.39) v2(126.83,156.86) v2(126.8,9.04) v2(126.85,157.6) v2(126.85,156.13) v2(126.9,132.1) v2(126.9,131.36) v2(127.06,170.2) v2(128.25,170.2) v2(128.33,18.18) v2(128.83,9.04) v2(129.72,157.53) v2(129.93,158.29) v2(130.71,157.55) v2(130.79,158.29) v2(130.87,9.04) v2(132.19,156.84) v2(132.85,156.41) v2(132.82,155.65) v2(132.82,154.88) v2(132.8,154.1) v2(132.8,153.26) v2(132.8,152.37) v2(132.82,151.56) v2(132.92,157.25) v2(132.9,9.04) v2(134.93,9.04) v2(135.46,156.56) v2(135.82,157.6) v2(136.18,156.92) v2(136.68,157.6) v2(136.81,156.53) v2(139.63,189.88) v2(139.63,157.37) v2(139.81,158.11) v2(140.52,157.4) v2(140.72,158.13) v2(141.66,189.88) v2(142.3,157.12) v2(142.55,156.36) v2(142.55,14.24) v2(142.7,155.57) v2(142.7,154.73) v2(142.68,153.84) v2(142.7,152.95) v2(143.06,157.12) v2(143.31,156.36) v2(143.44,155.59) v2(143.47,154.78) v2(143.69,189.88) v2(143.82,157.12) v2(144.07,156.36) v2(144.2,155.59) v2(144.2,154.83) v2(144.58,17.93) v2(144.58,15.89) v2(144.58,13.86) v2(144.58,11.83) v2(145.73,189.88) v2(146.61,17.93) v2(146.61,15.89) v2(146.61,13.86) v2(146.61,11.83) v2(146.64,10.03) v2(147.35,170.68) v2(147.38,169.95) v2(147.35,169.16) v2(147.38,168.35) v2(147.5,158.06) v2(147.5,157.04) v2(147.5,156.03) v2(147.5,155.01) v2(147.5,7.77) v2(147.76,189.88) v2(147.88,171.27) v2(148.04,156.53) v2(148.04,155.52) v2(148.11,170.5) v2(148.65,17.93) v2(148.65,15.89) v2(149.54,7.77) v2(149.79,189.88) v2(150.68,10.31) v2(151.19,12.34) v2(151.57,7.77) v2(151.72,158.72) v2(151.72,157.96) v2(151.82,189.88) v2(152.7,158.73) v2(152.74,157.96) v2(152.71,10.31) v2(153.6,7.77) v2(153.85,189.88) v2(154.74,10.31) v2(155,157.37) v2(155,156.61) v2(155.63,7.77) v2(155.89,189.88) v2(156.77,10.31) v2(157.92,189.88) v2(159.95,189.88) v2(160.08,157.75) v2(161.98,189.88) v2(163.51,170.15) v2(164.01,189.88) v2(165.23,178.99) v2(165.79,178.45) v2(166.05,189.88) v2(165.99,170.68) v2(166.17,179.09) v2(166.68,178.45) v2(166.86,170.68) v2(167.32,7.77) v2(167.44,189.12) v2(167.47,178.1) v2(168.08,187.34) v2(168.33,179.98) v2(169.35,7.77) v2(170.36,186.96) v2(171.38,7.77) v2(173.41,7.77) v2(174.55,71.27) v2(174.55,70.4) v2(174.55,69.64) v2(174.88,74.19) v2(174.88,73.2) v2(175.44,7.77) v2(177.48,7.77) v2(179.51,7.77) v2(181.44,98.04) v2(181.54,182.9) v2(181.54,99.59) v2(181.51,94.15) v2(181.46,93.24) v2(181.54,91.74) v2(181.54,7.77) v2(181.57,98.85) v2(181.92,100.35) v2(182.3,99.59) v2(182.5,94.15) v2(182.45,93.24) v2(182.5,91.71) v2(182.94,98.75) v2(183.19,99.59) v2(183.34,94.15) v2(183.44,98.04) v2(183.44,93.19) v2(183.42,91.74) v2(183.57,182.9) v2(183.57,7.77) v2(184.03,98.75) v2(184.08,99.71) v2(185.6,182.9) v2(185.6,7.77) v2(187.64,182.9) v2(187.64,7.77) v2(189.67,7.77) v2(191.06,185.31) v2(191.45,194.33) v2(193.33,78.91) v2(193.4,76.96) v2(193.43,75.18) v2(193.35,71.5) v2(193.48,194.33) v2(193.48,73.27) v2(193.58,69.84) v2(193.73,77.9) v2(193.68,72.36) v2(193.73,70.71) v2(193.76,76.12) v2(193.81,74.21) v2(193.78,69.08) v2(194.16,78.89) v2(194.21,71.52) v2(194.27,76.98) v2(194.29,75.2) v2(194.34,73.3) v2(194.44,69.87) v2(194.65,72.38) v2(194.7,77.92) v2(194.72,76.14) v2(194.7,70.73) v2(194.75,69.11) v2(194.77,74.24) v2(195.05,78.86) v2(195.1,71.55) v2(195.15,77.01) v2(195.18,75.23) v2(195.23,73.32) v2(195.33,69.9) v2(195.51,194.33) v2(195.61,77.9) v2(195.64,76.12) v2(195.64,72.41) v2(195.61,70.71) v2(195.69,74.21) v2(195.66,69.08) v2(195.87,78.86) v2(196.04,71.62) v2(196.07,76.98) v2(196.09,75.2) v2(196.14,73.3) v2(196.25,69.87) v2(197.54,194.33) v2(197.8,7.77) v2(199.57,194.33) v2(199.83,7.77) v2(201.61,194.33) v2(201.86,7.77) v2(203.64,194.33) v2(203.89,7.77) v2(205.67,194.33) v2(205.92,7.77) v2(207.7,194.33) v2(207.96,28.98) v2(207.96,7.77) v2(208.72,28.98) v2(209.48,99.21) v2(209.48,98.06) v2(209.48,96.41) v2(209.48,95.14) v2(209.48,28.98) v2(209.63,87.19) v2(209.73,194.33) v2(209.66,89.35) v2(209.99,7.77) v2(210.06,88.36) v2(210.09,85.95) v2(210.62,99.21) v2(210.62,98.09) v2(210.62,96.41) v2(210.62,95.14) v2(210.62,92.6) v2(210.62,91.59) v2(210.62,90.44) v2(210.95,85.62) v2(211.59,160.42) v2(211.64,92.6) v2(211.64,91.59) v2(211.64,90.44) v2(211.77,194.33) v2(211.77,99.21) v2(211.77,98.06) v2(211.77,96.41) v2(211.77,95.14) v2(212.02,7.39) v2(212.12,177.36) v2(212.15,85.72) v2(212.3,28.59) v2(212.4,160.42) v2(212.65,92.6) v2(212.65,91.59) v2(212.65,90.44) v2(212.91,156.99) v2(212.91,99.21) v2(212.91,98.06) v2(212.91,96.41) v2(213.29,156.36) v2(213.37,85.69) v2(213.52,87.7) v2(213.75,178.1) v2(213.67,156.99) v2(213.8,194.33) v2(213.9,175.53) v2(214.33,68.57) v2(214.41,177.62) v2(214.69,87.68) v2(214.69,86.63) v2(214.69,85.62) v2(214.94,72.41) v2(214.99,70.12) v2(214.99,69.08) v2(215.7,103.65) v2(215.7,102.76) v2(215.7,101.87) v2(215.7,87.65) v2(215.7,86.63) v2(215.7,85.62) v2(215.68,17.32) v2(215.65,15.26) v2(215.65,13.23) v2(215.65,11.2) v2(215.83,194.33) v2(217.86,194.33) v2(218.24,104.16) v2(218.24,103.4) v2(218.24,102.51) v2(218.5,23.39) v2(218.5,21.36) v2(218.5,19.32) v2(218.5,17.29) v2(218.5,15.26) v2(218.5,13.23) v2(218.5,11.2) v2(219.13,25.29) v2(219.74,170.91) v2(219.89,194.33) v2(220.48,170.91) v2(221.21,170.91) v2(221.16,25.55) v2(221.34,50.18) v2(221.34,49.42) v2(221.7,171.8) v2(221.93,194.33) v2(221.95,171.09) v2(222.1,50.18) v2(222.1,49.42) v2(222.43,171.8) v2(222.69,171.09) v2(222.69,157.12) v2(222.89,172.49) v2(223.07,156.48) v2(223.07,77.24) v2(223.07,75.2) v2(223.07,73.17) v2(223.07,71.14) v2(223.07,69.11) v2(223.07,67.08) v2(223.17,171.8) v2(223.2,25.55) v2(223.32,65.04) v2(223.45,157.12) v2(223.7,79.01) v2(223.83,156.48) v2(223.83,51.2) v2(223.96,194.33) v2(224.21,157.12) v2(224.59,156.48) v2(224.59,51.2) v2(224.77,177.36) v2(224.85,64.03) v2(224.92,176.45) v2(225.23,25.29) v2(225.48,176.98) v2(225.61,82.19) v2(225.74,79.52) v2(225.99,194.33) v2(227.64,82.19) v2(227.77,79.52) v2(228.02,194.33) v2(228.58,181.99) v2(228.58,181.2) v2(228.61,180.39) v2(229.55,86.38) v2(229.67,82.19) v2(229.93,79.9) v2(230.05,139.08) v2(230.18,194.71) v2(230.69,137.18) v2(230.82,196.74) v2(230.94,140.86) v2(231.63,179.85) v2(231.7,80.79) v2(231.83,182.52) v2(231.78,180.72) v2(231.88,181.6) v2(231.91,136.06) v2(231.93,134.49) v2(231.93,132.46) v2(231.93,130.42) v2(232.09,197.76) v2(232.14,128.34) v2(232.19,193.03) v2(232.54,194.61) v2(232.85,141.5) v2(233.53,191.87) v2(233.99,182.52) v2(233.99,180.49) v2(233.99,178.45) v2(233.99,176.42) v2(233.99,174.39) v2(233.99,172.36) v2(233.99,170.33) v2(233.99,159.28) v2(233.99,157.25) v2(233.99,155.21) v2(233.99,153.18) v2(233.99,151.15) v2(233.99,149.12) v2(233.99,147.09) v2(233.99,145.05) v2(233.99,143.02) v2(233.99,127.15) v2(233.99,125.11) v2(233.99,123.08) v2(233.99,120.8) v2(233.99,118.76) v2(233.99,116.73) v2(234.12,197.76) v2(234.75,112.03) v2(234.75,104.54) v2(234.75,102.51) v2(234.75,100.48) v2(234.75,90.57) v2(234.75,86.25) v2(234.88,184.3) v2(236.15,197.76) v2(236.91,184.68) v2(237.04,194.74) v2(237.06,193.14) v2(237.11,191.49) v2(238.18,197.76) v2(238.94,185.19) v3(128.24,113.42) v3(134.98,112.03)
