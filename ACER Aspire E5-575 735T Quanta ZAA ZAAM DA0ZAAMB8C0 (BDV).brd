# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SEN_A3: length 10.5
  TOP w0.127: v1(166.33,157.83) 166.13,157.83 R4556.2 165.67,156.58 v1(165.69,156.56)
  IN1 w0.089: v1(166.33,157.83) 166.45,157.83 168.41,159.79 172.32,159.79 172.48,159.95 172.48,160.6 v3(172.88,161)
  BOTTOM w0.152: v3(172.88,161) VRAM3005.J10
SEN_B0: length 12.3
  TOP w0.127: v1(218.37,114.32) R11090.2 217.86,113.19 v1(217.86,112.06)
  IN3 w0.114: v3(213.42,120.03) 213.79,119.66 213.79,118.92 213.76,118.89 213.76,116.52 215.19,115.08 217.61,115.08 v1(218.37,114.32)
  BOTTOM w0.127: v3(213.42,120.03) 213.01,120.44 VRAM3003.J10
SEN_B1: length 12.4
  TOP w0.127: v3(215.07,120.9) 214.69,120.9 214.28,121.3 213.16,121.3 212.98,121.13 VRAM3007.J10 ; v1(222.79,124.02) 222.68,123.91 R11092.2 222.43,123.21 v1(222.05,122.83)
  IN3 w0.114: v1(222.05,122.83) 220.91,121.69 215.86,121.69 v3(215.07,120.9)
SEN_B2: length 13.2
  TOP w0.127: v1(221.93,143.53) R11083.2 223.06,144.04 v1(224.36,144.04)
  TOP w0.14: v3(212.63,144.95) 212.63,144.92 VRAM3002.J10
  IN1 w0.089: v1(221.93,143.53) 221.8,143.4 217.48,143.4 216.34,144.55 213.04,144.55 v3(212.63,144.95)
SEN_B3: length 11.2
  TOP w0.127: R11069.2 v1(221.93,142.51)
  IN1 w0.089: v1(221.93,142.51) 214.24,142.51 v3(212.63,144.12)
  BOTTOM w0.14: VRAM3006.J10 212.63,144.2 v3(212.63,144.12)
SENSEA: length 4.3
  BOTTOM w0.203: U23.13 208.8,44.38
  BOTTOM w0.381: 208.8,44.38 209.1,44.09 v1(209.48,44.09) 209.99,44.09 210.24,43.83 R383.2 210.74,44.38 210.88,44.52 R378.2
SIO_A20GATE: length 3.8
  BOTTOM w0.127: U45.126 184.78,44.15 184.91,44.28 184.91,45.3 185.1,45.49 TP77.1
SIO_EXT_SCI#: length 123.5
  TOP w0.127: R571.1 R781.1 145.84,121.19 v1(146.23,121.58) ; v1(183.32,31.01) 183.32,31.26 181.98,32.6 180.71,32.6 179.13,34.18 176.08,34.18 175.82,34.44 175.82,36.21 v1(176.26,36.65) 176.59,36.98 176.59,39.34 178,40.75 178,41.92 177.22,42.69 177.22,45.1 177.48,45.36 177.48,47.69 176.76,48.4 176.76,56.71 v1(177.86,57.8)
  IN1 w0.089: v1(146.23,121.58) 147.47,121.58 148.64,120.42 152.43,120.42 157.33,115.51 157.33,111.75 158.41,110.67 159.59,110.67 165.12,105.15 165.12,93.4 165.82,92.7 165.82,90.77 165.28,90.24 165.28,89.17 164.57,88.46 164.57,87.1 165.32,86.35 165.32,84.23 165.11,84.02 165.1,84.02 164.47,83.39 164.47,80.03 165.77,78.74 165.77,77.81 167.49,76.09 167.49,73.42 169.31,71.6 169.31,68.91 170.56,67.65 170.8,67.65 171.57,66.89 171.57,66.18 172.85,64.9 173.46,64.9 174.4,63.96 174.4,63.22 174.88,62.74 174.88,62.11 175.79,61.2 175.79,60.49 177.48,58.8 177.48,58.18 v1(177.86,57.8)
  BOTTOM w0.127: v1(183.32,31.01) 183.95,31.01 185.54,32.6 U45.23
SIO_RCIN#: length 92.6
  IN1 w0.089: v1(154.26,80.92) 155.35,79.83 155.35,78 154.66,77.32 154.66,68.35 156.13,66.88 156.13,65.45 158.39,63.19 158.39,55.84 161.96,52.27 173.47,52.27 176.16,49.57 176.16,47.66 182.72,41.1 182.72,37.54 v1(183.06,37.21)
  BOTTOM w0.127: R652.1 136.71,91.03 138.6,89.14 141.26,89.14 149.03,81.36 153.82,81.36 v1(154.26,80.92) ; v1(183.06,37.21) 183.51,37.66 184,37.66 184.49,37.18 184.97,37.18 185.45,37.66 185.76,37.66 186.19,38.09 186.19,38.65 185.63,39.21 185.63,39.67 186.16,40.2 U45.4
SLEEVE: length 17.7
  IN1 w1.016: 205.67,27.07 206.05,27.45 206.05,29.1 206.94,29.99 206.94,33.8 209.23,36.09 209.23,38.75 210.11,39.64 210.11,41.17
  BOTTOM w0.203: v1(208.97,42.49) 208.87,42.38 U23.18
  BOTTOM w0.508: v1(209.61,42.49) v1(208.97,42.49)
  vias: v1(205.67,25.93) v1(205.67,25.29) v1(206.2,25.6)
SLEEVE_R: length 8
  IN1 w1.016: 208.72,14.88 208.08,15.51 208.08,17.59 206.18,19.5 206.18,21.86
  vias: v1(206.3,23.41) v1(206.3,22.76) v1(208.97,14.88) v1(209.61,15.01) v1(209.61,14.37)
SM_RCOMP_0: length 34
  TOP w0.381: R685.2 v1(150.3,90.44)
  IN3 w0.229: v1(131.3,105.83) 131.75,105.37 131.75,103.65 132.14,103.27 132.76,103.27
  IN3 w0.381: v1(150.3,90.44) 150.3,91.84 150.81,92.35 150.81,95.78 150.42,96.16 150.42,96.54 148.44,98.52 144.28,98.52 143.44,97.68 138.97,97.68 133.39,103.27 132.76,103.27
  BOTTOM w0.305: U35.AR18 v1(131.3,105.83)
SM_RCOMP_1: length 29.9
  TOP w0.381: R678.2 v1(151.95,91.33)
  IN1 w0.381: v1(151.95,91.33) 150.3,91.33 148.62,89.66 142.45,89.66 139.76,92.35 139.76,96.54 137.47,98.83 136.82,98.83 133.48,102.17 132.35,102.17 131.92,102.6 131.92,102.75
  BOTTOM w0.305: U35.AT18 v3(131.3,105.18)
SM_RCOMP_2: length 1.4
  TOP w0.381: v1(131.3,104.53) 131,104.23 R681.2
  BOTTOM w0.305: U35.AU18 v1(131.3,104.53)
SMB1ALERT#: length 255.7
  TOP w0.127: R205.1 v1(151.82,97.3)
  IN1 w0.089: v1(153.47,106.57) 152.96,106.57 152.15,105.76 149.08,105.76 148.19,106.65 140.32,106.65 140.04,106.93 138.44,106.93 137.87,107.49 137.22,107.49 136.84,107.11 136.81,107.11 v3(136.81,107.1)
  IN2 w0.114: v1(79.41,78.51) 78.92,78.02 78.92,75.52 80.19,74.25 80.19,71.01 79.3,70.12 79.3,49.81 80.2,48.91 80.2,46.65 82.86,43.99 118.85,43.99 119.89,42.95 126.93,42.95 128.59,41.29 136.11,41.29 138.06,43.24 144.81,43.24 145.05,43.48 151.09,43.48 153.44,45.84 153.44,47.74 155.38,49.68 155.38,51.71 155.97,52.3 157.49,52.3 158.04,52.85 158.04,58.06 156.77,59.33 156.77,61.74 156.58,61.93 156.58,62.57 152.58,66.57 152.58,70.5 151.57,71.52 151.57,76.09 151.31,76.35 151.31,85.49 149.92,86.89 149.92,89.01 151.19,90.28 151.19,93.46 151.82,94.1 v1(151.82,97.3) 151.82,97.68 152.96,98.83 152.96,102.38 153.85,103.27 153.85,106.19 v1(153.47,106.57)
  BOTTOM w0.127: v3(136.81,107.1) 136.81,107.1 137.16,107.45 U35.AM7 ; U12.1 79.99,127.4 79.61,127.02 78.39,127.02 77.27,125.9 R218.2 76.08,121.14 v1(76.08,117.14) 76.08,114.88 83.37,107.59 83.37,91.33 80.19,88.16 80.19,85.72 80.45,85.47 80.45,79.55 v1(79.41,78.51)
SMB_ME1_CLK: length 6.3
  BOTTOM w0.076: U35.W3 139.7,113.57 140.16,114.04 140.16,114.42
  BOTTOM w0.114: 140.16,114.42 140.3,114.56 141.27,114.56 142.91,116.2 143.69,116.2
  BOTTOM w0.127: R171.2 143.96,116.2 143.69,116.2
SMB_ME1_DAT: length 6.4
  BOTTOM w0.076: 139.85,115.12 139.85,114.74 139.35,114.24 U35.V3
  BOTTOM w0.114: 143.69,116.48 142.9,116.48 141.61,115.19 139.92,115.19 139.85,115.12
  BOTTOM w0.127: 143.69,116.48 143.94,116.48 R175.2
SMBALERT#: length 5.3
  TOP w0.102: R160.1 139.83,116.86 v1(139.15,116.17) 138.92,115.95 136.76,115.95 136.55,115.74 136.1,115.74 135.81,115.45 v3(135.81,115.35)
  BOTTOM w0.127: v3(135.81,115.35) 135.48,115.67 U35.R10
SML0ALERT#: length 10.2
  BOTTOM w0.127: U35.W1 141.3,113.57 142.69,114.97 145.15,114.97 v1(145.27,114.85) 145.48,114.64 148.46,114.64 149.66,115.84 R586.2
SP1: length 59.4
  TOP w0.127: v1(29.27,28.42) 29.27,27.45 29.4,27.32 R11254.1 ; v1(32.91,76.01) 33.16,76.01 33.56,75.61 33.56,75.18 34.28,74.46 U15.14
  IN1 w0.089: v1(29.27,28.42) 29.27,29.18 29.18,29.27 28.59,29.27 28.5,29.36 28.5,29.65 28.59,29.74 29.18,29.74 29.27,29.83 29.27,30.12 29.18,30.21 28.59,30.21 28.5,30.3 28.5,30.59 28.59,30.68 29.18,30.68 29.27,30.77 29.27,31.01 28.47,31.8 28.47,37.26 27.52,38.22 27.52,62.43 31.17,66.09 31.17,68.09 31.76,68.68 31.76,71.49 31.17,72.08 31.17,73.74 32.52,75.09 32.52,75.62 v1(32.91,76.01)
SP1=SD_D1: length 5.1
  TOP w0.127: R11254.2 C4611.1 28.17,24.2 27.71,24.2 27,23.49 26.19,23.49 25.74,23.04 CN4.8
SP2: length 58.1
  TOP w0.127: v1(31.8,73.81) 31.8,74.41 32.34,74.95 32.77,74.95 32.8,74.92 33.38,74.92 34.24,74.06 U15.15 ; R11253.1 30.16,27.33 v1(30.16,27.45)
  IN1 w0.089: v1(30.16,27.45) 30.16,27.92 30.24,28.01 30.73,28.01 30.87,28.15 30.87,28.34 30.73,28.48 30.24,28.48 30.07,28.66 29.79,28.66 29.65,28.79 29.65,28.99 29.79,29.13 30.16,29.13 30.3,29.26 30.3,29.46 30.16,29.6 29.75,29.6 29.61,29.73 29.61,29.93 29.75,30.07 30.07,30.07 30.16,30.16 30.16,30.63 28.82,31.97 28.82,37.4 27.86,38.36 27.86,62.29 31.51,65.94 31.51,67.95 32.1,68.53 32.1,71.64 31.51,72.22 31.51,73.52 v1(31.8,73.81)
SP2=SD_D0=MS_D1: length 7.1
  TOP w0.127: CN4.7 27.37,23.4 27.82,23.85 29.71,23.85 C4612.1 30.53,24.89 R11253.2 30.8,25.54 30.41,25.93 v1(30.41,26.31)
SP3: length 59.7
  TOP w0.127: R11255.1 31.93,26.93 v1(31.93,27.6) ; U15.16 34.32,73.66 33.62,74.37 33.13,74.37 v1(32.64,73.87)
  IN1 w0.089: v1(32.64,73.87) 32.59,73.82 32.59,72.17 32.82,71.94 32.82,69.07 32.91,68.98 33.33,68.98 33.46,68.84 33.46,68.65 33.33,68.51 32.91,68.51 32.82,68.42 32.82,68.13 32.91,68.04 33.49,68.04 33.62,67.9 33.62,67.71 33.49,67.57 32.57,67.57 32.34,67.34 32.34,65.6 28.71,61.98 28.71,38.58 29.9,37.4 29.9,32.66 31.04,31.52 31.04,30.99 31.2,30.84 31.81,30.84 31.95,30.7 31.95,30.5 31.81,30.36 31.16,30.36 31.03,30.22 31.03,30.03 31.16,29.89 32.07,29.89 32.21,29.75 32.21,29.56 32.07,29.42 31.28,29.42 31.15,29.28 31.15,29.09 31.28,28.95 31.84,28.95 31.93,28.86 v1(31.93,27.6)
SP3=SD_CLK=MS_D0: length 2.5
  TOP w0.127: R11141.2 C4616.1 R11255.2 v1(33.97,26.44)
SP4: length 60.1
  TOP w0.127: v1(33.45,73.87) 33.64,73.87 34.25,73.26 U15.17 ; R11136.1 37.52,25.55 35.49,27.58 v1(33.2,27.58)
  IN1 w0.089: v1(33.45,73.87) 34.15,73.87 35.72,72.3 35.72,66.15 30.67,61.1 30.67,39.16 32.06,37.77 32.06,33.5 34.37,31.18 34.37,28.62 33.33,27.58 v1(33.2,27.58)
SP4=SD_CMD=MS_D2: length 4.9
  TOP w0.127: v1(40.57,25.55) R11136.2 C4614.1 40.32,24.66 40.52,24.45 40.52,23.79 40.44,23.72 40.12,23.72 39.87,23.46 39.87,22.58 39.87,22.57 CN4.2
SP5: length 61.5
  TOP w0.127: U15.18 34.17,72.86 33.77,73.26 v1(33.62,73.26) ; v1(33.2,28.21) 35.49,28.21 37.52,26.18 41.59,26.18 41.83,25.94 R11137.1
  IN1 w0.089: v1(33.2,28.21) 33.46,28.21 33.99,28.75 33.99,31.08 31.72,33.35 31.72,37.63 30.33,39.02 30.33,61.24 35.38,66.29 35.38,72.14 34.25,73.26 v1(33.62,73.26)
SP5=SD_D3=MS_D3: length 4.1
  TOP w0.127: v1(43.36,25.42) 43.24,25.55 R11137.2 C4613.1 42.61,23.76 42.37,23.51 42.37,22.68 CN4.1
SP6: length 61.4
  TOP w0.127: v1(33.2,29.1) v1(34.24,29.1) 35.54,29.1 37.7,26.94 43.62,26.94 44.37,26.19 R11138.1 ; U15.19 33.66,72.46 v1(33.57,72.38)
  IN1 w0.089: v1(33.2,29.1) 33.2,30.63 30.79,33.04 30.79,37.53 29.52,38.8 29.52,61.59 33.84,65.91 33.84,66.69 34.35,67.2 34.35,71.6 v1(33.57,72.38)
SP6=SD_D2=MS_CLK: length 4.4
  TOP w0.127: v1(45.95,24.84) 45.24,25.55 R11138.2 C4615.1 45.14,24.52 45.14,23.64 44.87,23.37 44.87,22.6 CN4.9
SP7: length 59.2
  TOP w0.127: v1(28.52,27.97) 26.73,26.18 R11139.1 ; U15.28 36.9,68.64 v1(36.63,68.37)
  IN1 w0.089: v1(28.52,27.97) 29.69,26.8 33.19,26.8 34.75,28.37 34.75,31.29 32.48,33.56 32.48,37.85 31.01,39.32 31.01,60.95 37.39,67.34 37.39,69.36 37.14,69.62 36.79,69.62 36.63,69.46 v1(36.63,68.37)
SP7=SD_WP=MS_BS: length 5
  TOP w0.127: R11139.2 26.33,24.25 23.98,24.25 v1(23.73,24) 23.29,23.56 CN4.11
SP8: length 60.2
  TOP w0.127: v1(41.97,72.41) 41.91,72.46 U15.42 ; v1(28.52,26.68) 27.62,25.78 R11256.1
  IN1 w0.089: v1(41.97,72.41) 38.03,68.47 38.03,67.49 31.36,60.81 31.36,39.46 32.82,37.99 32.82,33.7 35.1,31.43 35.1,28.2 33.36,26.46 28.73,26.46 v1(28.52,26.68)
SP8=SD_CD#: length 6.4
  TOP w0.127: CN4.10 24.44,23.13 25.13,23.82 26.79,23.82 R11256.2 27.47,24.65 27.17,24.94 27.17,25.8 27.34,25.96 v1(27.34,26.16)
SPI_CLK_8M: length 4.4
  TOP w0.127: v1(180.02,56.92) 180.14,56.79 R684.1 179.63,55.65 179.63,55.14 180.14,54.63 R687.2
  BOTTOM w0.127: U41.6 v1(180.02,56.92)
SPI_CS0#_UR_ME: length 24.5
  TOP w0.127: R602.1 R591.2 v1(183.83,49.8)
  IN3 w0.114: v1(178.11,37.26) 178.62,37.76 178.62,38.76 180.4,40.54 180.4,42.56 182.81,44.98 182.81,49.55 183.06,49.8 v1(183.83,49.8)
  BOTTOM w0.127: U45.101 174.78,42.16 174.76,42.13 174.76,40.06 177.56,37.26 v1(178.11,37.26)
SPI_HOLD_IO3_ME: length 3.6
  TOP w0.127: R239.2 R698.1 181.28,56.83 181.29,56.84 v1(181.29,56.92) 181.67,57.3 v1(181.67,57.42)
  BOTTOM w0.127: U41.7 v1(181.29,56.92)
SPI_SI_8M: length 4.4
  TOP w0.127: v1(178.75,56.92) 178.75,56.42 R691.1 178.49,55.65 178.49,54.76 178.99,54.26 R654.2
  BOTTOM w0.127: U41.5 v1(178.75,56.92)
SPI_SO_8M: length 3.6
  TOP w0.127: v1(181.29,49.3) 181.79,49.8 R650.2 R588.2
  BOTTOM w0.127: U41.2 v1(181.29,49.3)
SPI_WP_IO2_ME: length 3.4
  TOP w0.127: v1(179.89,49.35) 179.76,49.47 R649.2 R589.2
  BOTTOM w0.127: U41.3 180.02,49.47 v1(179.89,49.35)
SPKR: length 135
  TOP w0.127: v1(150.93,74.92) 152.1,76.09 160.33,76.09 v1(160.84,75.58)
  IN1 w0.089: v1(215.69,43.23) 215.69,46.54 212.83,49.4 212.83,50.03 211.89,50.97 211.89,52.12 210.21,53.8 196.09,53.8 195.51,54.38 191.57,54.38 190.98,53.79 183.25,53.79 182.05,54.99 177.11,54.99 173.58,58.51 173.1,58.51 169.21,62.4 169.21,62.87 167.79,64.3 166.25,64.3 164.9,65.65 164.9,67.18 164.17,67.92 164.17,69.46 163.62,70.01 162.86,70.01 161.73,71.14 161.73,72.79 161.07,73.45 161.07,74.85 160.84,75.08 v1(160.84,75.58)
  IN3 w0.114: v1(150.93,74.92) 150.93,83.2 151.9,84.17 151.9,86.33 153.47,87.9 153.47,95.02 152.58,95.9 152.58,99.84 150.68,101.75 150.68,102.13 149.94,102.86 147.71,102.86 v1(147.58,102.74)
  BOTTOM w0.076: U35.AW5 138.39,103.38 138.91,103.38 139.16,103.13 139.16,101.84 139.24,101.76 139.24,101.59 139.41,101.42 139.79,101.42 140.03,101.18 140.03,100.86 140.18,100.72
  BOTTOM w0.127: v1(215.69,43.23) 215.68,43.23 215.19,43.71 D9.2 ; R625.2 148.26,103.37 147.62,102.74 v1(147.58,102.74) 147.41,102.74 147,103.14 R624.1 146.5,102.89 145.34,102.89 144.84,102.38 144.84,102 144.48,101.65 143.59,101.65 142.66,100.72 140.18,100.72
SRTC_RST#: length 194.4
  TOP w0.127: v1(160.71,85.74) 159.72,84.75 v1(150.68,84.75) 149.05,84.75 144.07,79.78 137.34,79.78 136.51,80.61 136.51,89.78 134.3,91.99 134.3,94.19 128.94,99.55 128.94,101.37 128.71,101.59 128.71,103.14 129.95,104.39 129.95,106.04 130.41,106.5 v3(131.25,106.5) ; v1(79.96,35.69) 80.57,36.31 80.57,45.23 79.5,46.31 79.5,47.01 79.18,47.33 78,47.33 77.64,47.68 C382.1 R300.2
  IN1 w0.089: v1(150.68,84.75) 150.68,80 152.45,78.23 152.45,65.87 153.47,64.86 153.47,45.07 150.77,42.37 150.77,41.33 149.24,39.81 148.71,39.81 147.44,38.54 145.07,38.54 143.35,36.81 96.78,36.81 95.9,35.94 80.2,35.94 v1(79.96,35.69)
  BOTTOM w0.127: v3(131.25,106.5) 130.94,106.8 U35.AN18 ; Q6059.3 160.33,86.76 160.71,86.38 v1(160.71,85.74)
SSD_ID: length 117.8
  TOP w0.127: v1(158.68,114.45) 159.44,114.45 159.89,114.89 v1(160.84,114.89) 160.9,114.89 162.11,113.68 162.11,109.24 165.11,106.24 173.68,106.24 176.05,108.62 181.79,108.62 182.59,109.42 186.31,109.42 187.64,108.1 190.81,108.1 191.52,108.81 194.7,108.81 201.35,115.46 205.29,115.46 207.57,113.18 207.57,112.8 207.83,112.54 207.83,112.03 209.23,110.64 217.61,110.64 218.24,111.27 227.77,111.27 v1(228.15,111.65)
  IN3 w0.114: v1(228.15,111.65) 228.78,111.65 229.42,111.02 229.42,108.86 231.7,106.57 231.7,104.41 232.09,104.03 232.09,100.22 232.76,99.55 CN9.7
  BOTTOM w0.127: v1(158.68,114.45) 158.21,114.92 158.21,116.7 157.03,117.89 155.22,117.89 154.36,118.74 154.36,119.86 152.48,121.74 148.21,121.74 146.49,123.46 R568.1
STRAP0: length 6.8
  BOTTOM w0.127: R4308.2 R4300.1
  BOTTOM w0.14: R4308.2 188.82,114.99 188.82,118.82 189.33,119.32 U3002.J2
STRAP1: length 13.8
  TOP w0.127: R4301.1 R4309.2 195.38,114.95 195.38,115.84 v1(194.78,116.45) 193.98,117.25 192.85,117.25 190.56,119.54 190.56,121.71 189.73,122.54 v1(189.73,123.21)
  BOTTOM w0.14: U3002.J7 189.73,123.24 v1(189.73,123.21)
STRAP2: length 11.1
  TOP w0.127: R4302.1 R4310.2 190.81,114.95 v1(190.81,116.46) 190.81,116.73 190.2,117.34 190.2,121.71 189.52,122.39 v1(188.93,122.39)
  BOTTOM w0.14: U3002.J6 v1(188.93,122.39)
STRAP3: length 9.8
  TOP w0.127: v1(188.87,121.54) 188.47,121.14 188.47,120.34 188.65,120.16 188.65,119.53 v1(188.56,119.43) 188.4,119.27 188.4,116.63 187.76,116 187.76,114.95 R4311.2 R4303.1
  BOTTOM w0.127: U3002.J5 188.93,121.54 v1(188.87,121.54)
STRAP4: length 10.3
  BOTTOM w0.127: v1(186.62,111.22) 186.7,111.3 186.7,112.2 186.68,112.21 186.68,112.76 187.11,113.19 R4304.1 R4312.2
  BOTTOM w0.14: R4312.2 187.76,114.95 187.76,116 188.4,116.63 188.4,118.76 188.93,119.3 188.93,119.95 U3002.J3
SUSACK#_R: length 25.2
  TOP w0.127: TP4368.1 154.11,96.64 v1(153.85,96.9)
  IN1 w0.132: v1(153.85,96.9) 152.94,97.81 151.06,97.81 150.81,98.06 150.18,98.06 148.4,99.84 146.58,99.84 145.76,100.66 140.23,100.66 139.53,101.36 137.63,101.36 136.35,102.64 136.35,103.25 135.43,104.17 135.43,105.59 135.15,105.87 v3(134.95,105.87)
  BOTTOM w0.127: U35.AP11 134.67,106.15 v3(134.95,105.87)
SUSB#: length 459.7
  TOP w0.127: v1(160.2,115.97) 159.16,114.93 158.5,114.93 158.04,114.47 158.04,108.35 158.81,107.59 158.81,101.87 157.54,100.6 v1(157.54,96.85) 157.54,96.79 156.01,95.27 v1(155.1,95.27) ; v1(178.36,39.9) 178.36,40.28 178.96,40.88 190.09,40.88 191.83,39.14 191.83,38.5 191.27,37.94 191.27,31.31 v1(191.19,31.24) ; v1(36.12,50.95) 36.25,50.95 36.63,51.33 PQ6057.2
  IN1 w0.089: v1(178.36,39.9) 177.09,39.9 176.07,38.88 172.64,38.88 171.38,37.61 171.38,37.21 170.57,36.39 170.11,36.39 168.6,34.88 164.85,34.88 163.37,33.4 161.22,33.4 160.49,32.66 159.67,32.66 v1(156.85,29.84) ; v1(155.1,95.27) 151.74,95.27 148.41,98.59 143.29,98.59 142.09,99.79 139.81,99.79 139.12,100.48 136.84,100.48 133.53,103.78 133.53,105.56 133.26,105.83 v3(133.12,105.83)
  IN2 w0.114: v1(76.72,48.93) 82.55,43.1 118.52,43.1 121.2,40.42 137.42,40.42 138.04,41.04 144.33,41.04 145.52,42.23 152.18,42.23 154.93,44.98 154.93,46.63 157.28,48.98 157.28,50.82 159.63,53.16 159.63,62.95 153.53,69.05 153.53,75.46 152.13,76.86 152.13,86 151.66,86.47 151.66,88.46 153.51,90.32 153.51,92.9 155.1,94.48 v1(155.1,95.27)
  IN3 w0.114: v1(36.12,50.95) 36.12,50.44 34.47,48.79 34.47,38.37 37.81,35.03 37.81,30.92 39.53,29.2 45.49,29.2 54.22,20.47 57.84,20.47 58.96,19.35 66.05,19.35 66.49,19.79 66.49,21.62 75.49,30.63 75.49,45.87 76.72,47.09 v1(76.72,48.93) ; v1(178.36,39.9) 178.36,40.41 179.03,41.07 179.03,42.69 179.69,43.35 179.69,45.49 178.92,46.25 178.92,47.44 179.18,47.7 179.18,50.13 174.39,54.92 174.39,57.39 173.79,57.99 173.79,62.12 173.41,62.5 173.41,63.82 172.38,64.85 172.03,64.85 170.07,66.81 170.07,71.97 170.48,72.37 170.48,73.69 170.73,73.93 170.73,74.47 170.15,75.04 170.15,76.85 169.77,77.24 169.77,80.19 170.11,80.54 170.11,84.82 167.82,87.11 167.82,89.11 167.32,89.61 v1(167,89.61)
  BOTTOM w0.127: U50.2 157.79,30.25 157.38,29.84 v1(156.85,29.84) ; v3(133.12,105.83) U35.AP15 ; v1(178.36,39.9) 178.36,40.15 179.25,41.04 179.76,41.04 180.8,42.08 181.79,42.08 181.98,42.27 U45.119 ; v1(160.2,115.97) 160.66,116.43 160.66,117.13 157.87,119.92 157.17,119.92 154.79,122.3 154.79,125.64 151.34,129.09 149.17,129.09 148.3,129.97 146.67,129.97 146.08,130.55 139.27,130.55 137.52,132.3 137.52,133.42 137.75,133.65 138.11,133.65 138.97,134.51 140.47,134.51 141.1,133.88 U47.2 ; v1(155.1,95.27) 155.1,94.74 154.67,94.3 154.67,92.32 155.43,91.56 157.97,91.56 159.41,90.11 161.69,90.11 161.9,90.32 166.69,90.32 166.93,90.56 R282.2 167.57,89.94 167.25,89.61 v1(167,89.61) ; v1(191.19,31.24) 194.21,31.24 194.52,31.54 194.52,32.61 195.08,33.17 U49.2
SUSC#: length 134.8
  TOP w0.127: v1(167.5,81.43) 167.95,81.43 168.43,80.94 172.37,80.94 v1(172.5,81.07)
  IN1 w0.089: v1(192.97,53.61) 191.19,53.61 190.84,53.26 190.84,52.37 189.31,50.84 189.31,44.4 190.09,43.62 190.09,41.47 189.31,40.68 189.31,37.38 186.62,34.69 v1(185.6,34.69)
  IN2 w0.114: v1(167.5,81.43) 167.5,81.92 167.19,82.23 167.19,88.28 167.82,88.92 167.82,90.19 168.08,90.44 168.6,90.44 v1(169.11,89.94)
  IN3 w0.114: v1(172.5,81.07) 173.1,81.07 173.41,80.76 173.41,80.16 173.44,80.13 173.44,77.12 173.99,76.56 173.99,75.79 173.91,75.71 173.91,68.43 178.76,63.59 178.76,61.41 181.09,59.07 181.82,59.07 184.57,56.33 185.16,56.33 187.88,53.61 v1(192.97,53.61)
  BOTTOM w0.076: U35.BA16 131.84,101.87 131.84,99.96 133.76,98.04 133.76,97.94
  BOTTOM w0.127: U48.2 v1(192.97,53.61) ; v1(169.11,89.94) 169.6,90.42 R274.2 ; v1(185.6,34.69) 186.11,34.69 186.2,34.6 U45.18 ; 133.76,97.94 133.76,92.7 134.3,92.16 134.3,90.48 137.51,87.27 140.97,87.27 148.4,79.84 154.8,79.84 155.81,80.86 166.97,80.86 167.5,81.38 v1(167.5,81.43)
SUSCLK: length 231.2
  IN1 w0.089: v1(201.86,184.17) 202.24,184.17 203.13,183.28 203.13,180.36 202.87,180.1 202.87,176.82 203.24,176.45 203.24,172.26 204.62,170.88 205.27,170.88 206.69,169.46 206.69,159.63 208.3,158.02 219.88,158.02 223.58,154.32 224.53,154.32 226.92,151.93 226.92,123.13 226.8,123 226.8,121.72 227.55,120.97 227.55,114.73 219.64,106.83 216.69,106.83 213.3,103.43 195.17,103.43 194.25,102.52 186.98,102.52 186.48,102.01 180.37,102.01 178.47,100.12 178.47,95.78 178.16,95.47 178.16,91.37 176.68,89.88 176.68,87.02 175.37,85.71 175.37,78.84 174.68,78.16 174.68,77.91 v1(174.17,77.4)
  BOTTOM w0.076: 133.31,97.94 133.31,98 131.51,99.8 131.51,101.09 131.07,101.52 U35.BA17
  BOTTOM w0.127: 133.31,97.94 133.31,92.45 133.79,91.97 133.79,90.27 137.53,86.53 140.97,86.53 148.17,79.33 155.01,79.33 156.02,80.35 168,80.35 168.2,80.14 170.73,80.14 172.13,78.73 172.84,78.73 v1(174.17,77.4) ; v1(201.86,184.17) 202.11,183.92 U43.2 203.64,183.92 203.89,184.17 203.89,184.68 203,185.57 R716.2
SUSD: length 11.1
  TOP w0.381: PR142.2 68.4,102.32 68.59,102.13 PQ8.3 70.11,101.44 69.69,101.02 PC101.2 v1(71.62,100.73) 74.33,100.73 v1(75.11,101.52)
  BOTTOM w0.381: 75.11,100.48 v1(75.11,101.52)
SUSLED#: length 146.4
  TOP w0.127: v1(53.9,15.64) 53.9,18.18 54.29,18.56 R427.1 R433.1
  IN2 w0.114: v1(53.9,15.64) 54.57,15.64 57.02,13.19 66.36,13.19 74.65,21.48 77.6,21.48 80.3,24.18 112.17,24.18 113.01,25.01 168.43,25.01 170.47,27.05 177.69,27.05 179.22,28.58 184.06,28.58 184.64,29.15 184.64,30.04 v1(185.1,30.5)
  BOTTOM w0.127: U45.28 185.19,30.6 v1(185.1,30.5)
SUSON: length 23.9
  IN1 w0.089: v1(184.46,44.6) 186.89,44.6 188.4,46.11 188.4,51.12 189.74,52.47 v1(189.74,52.78)
  BOTTOM w0.127: R790.2 195.13,54.13 195,54.26 U48.1 193.46,54.26 192.84,54.88 190.18,54.88 189.85,54.55 v1(189.85,53.64) 189.85,52.88 v1(189.74,52.78) ; R739.1 184.46,45.1 v1(184.46,44.6) 183.95,44.6 183.85,44.7 183.01,44.7 182.38,44.07 U45.120
SUSON_R: length 327.8
  TOP w0.127: PR304.2 47.32,62.57 v1(47.5,62.76) ; PQ6.2 v1(73.92,105.3) ; v1(43.49,51.79) 43.57,51.86 43.57,52.04 44,52.47 PR263.2
  IN1 w0.089: v1(73.92,105.3) 69.91,105.3 68.38,103.78 57.71,103.78 46.28,92.35 46.28,80.41 49.81,76.89 49.81,74.28 49.08,73.55 49.08,70.18 49.93,69.34 49.93,67.49 49.97,67.46 49.97,65.22 v1(47.5,62.76) ; v1(32.75,58.19) 32.75,42.38 34.6,40.53 34.6,36.69 38.54,32.75 38.54,31.9 39.83,30.61 39.83,19.56 45.45,13.94 51.8,13.94 52.16,13.58 55.56,13.58 56.2,12.94 67.93,12.94 73.6,18.61 74.71,18.61 82.79,26.69 107.69,26.69 108.93,25.45 158.66,25.45 163.13,29.92 168.51,29.92 170.94,32.34 170.94,32.84 172.15,34.05 175.03,34.05 176.12,35.15 179.02,35.15 179.23,35.36 183.92,35.36 184.99,34.28 186.72,34.28 189.5,37.06 189.5,40.61 190.28,41.39 190.28,43.7 189.5,44.48 189.5,50.39 191.3,52.2 v1(191.3,52.78)
  BOTTOM w0.127: R790.1 194.88,52.6 193,52.6 192.63,52.96 U48.4 191.48,52.96 191.3,52.79 v1(191.3,52.78) ; v1(43.49,51.79) 43.49,52.09 41.99,53.59 36.48,53.59 32.75,57.32 v1(32.75,58.19) 33.42,58.85 v1(33.95,58.85) 37.8,62.71 43.77,62.71 44.35,63.29 46.97,63.29 v1(47.5,62.76)
SYS_HWPG: length 182.1
  TOP w0.127: v1(56.09,43.1) 55.96,42.97 PR6283.2
  IN1 w0.089: v1(173.67,35.03) 173.25,35.45 172.1,35.45 169.97,33.32 165.19,33.32 163.53,31.66 163.21,31.66 158.44,26.89 v1(157.66,26.89) 157.21,26.89 156.77,27.32 118.8,27.32 118.25,26.77 109.28,26.77 108.05,28 81.57,28 67.5,13.93 56.99,13.93 56.34,14.59 52.93,14.59 44.89,22.63 44.63,22.63 41.87,25.39 41.87,32.13 40.32,33.67 v1(40.32,34.82)
  IN3 w0.114: v1(40.32,34.82) 41.2,35.71 43.36,35.71 50.76,43.1 v1(56.09,43.1)
  BOTTOM w0.127: U45.77 172.43,33.8 v1(173.67,35.03) ; D4014.1 158.13,25.34 157.66,25.8 v1(157.66,26.89)
SYS_PEX_RST_MON#: length 46.7
  IN1 w0.089: v1(188.03,120.73) 187.64,120.34 187.64,119.78 188.87,118.54 188.87,114.92 188.27,114.32 v1(188.27,111.78)
  BOTTOM w0.127: v1(188.03,120.73) 188.02,120.73 U3002.L3 ; R11108.2 216.83,107.83 217.1,107.56 217.1,106.94 216.85,106.69 U4002.2 215.69,106.69 214.18,105.18 209.86,105.18 v1(209.45,105.58) 208.34,106.7 201.22,106.7 198.79,109.14 189.77,109.14 188.78,110.13 188.78,110.65 R4321.1 v1(188.27,111.78)
SYS_PWROK: length 178.8
  TOP w0.127: R560.1 179.46,37.87 179.25,37.66 v1(179.25,37.23) 178.75,37.23 178.52,37 178.52,36.75 178.65,36.61 U8.4 179.6,36.61 179.72,36.49 179.72,35.92 180.14,35.5 180.14,34.44 181.03,33.55 182.3,33.55 182.56,33.29 183.19,33.29 183.58,33.68 R113.1
  IN1 w0.089: v1(167.21,79.84) 166.44,80.61 166.44,83.09 166.76,83.41 166.76,88.05 167.88,89.18 167.88,90.16 167.73,90.31 167.73,93.91 167.15,94.49 167.15,100.84 167.73,101.42 167.73,106.18 161.98,111.94 161.98,112.01 v1(160.2,113.79) ; v1(154.23,78.82) 154.23,78.51 153.72,77.99 153.72,67.59 154.49,66.82 154.49,64.28 156.77,62 156.77,59.71 157.41,59.07 157.41,55.49 161.57,51.33 164.17,51.33 164.84,50.65 172.59,50.65 173.5,49.74 173.5,49.3 173.88,48.91 174.94,48.91 175.22,48.64 175.22,46.48 176.71,44.98 176.71,43.71 177.82,42.6 179.31,42.6 180.02,41.9 180.02,39.54 179.76,39.29 179.76,37.74 v1(179.25,37.23)
  BOTTOM w0.127: R643.1 132.52,90.09 137.09,85.52 140.37,85.52 147.57,78.32 153.73,78.32 v1(154.23,78.82) 155.22,78.82 156.23,79.84 v1(167.21,79.84) ; v1(160.2,113.79) 159.7,114.29 159.7,117.02 157.55,119.16 156.86,119.16 153.85,122.16 153.85,125.5 151.05,128.3 R556.1
SYS_PWROK_R: length 10.9
  BOTTOM w0.127: U35.B6 138.11,122.88 138.11,123.08 138.26,123.24 138.26,123.57 137.98,123.84 137.98,124.61 138.23,124.86 140.44,124.86 142.04,126.46 R555.1 R131.1 R556.2 144.32,127.52 144.58,127.78 v1(144.84,127.78)
SYS_RESET#: length 69.5
  IN1 w0.089: v1(167,88.96) 167.41,89.37 167.41,89.97 167.26,90.11 167.26,93.71 166.68,94.3 166.68,101.04 167.26,101.62 167.26,105.99 v1(160.2,113.05)
  BOTTOM w0.127: v1(160.2,113.05) 159.19,114.07 159.19,116.8 157.34,118.65 156.65,118.65 153.35,121.95 153.35,125.24 150.81,127.78 145.98,127.78 145.47,127.27 144.84,127.27 144.45,126.88 R561.2 143.72,125.78 142.1,125.78 140.54,124.23 139.25,124.23 138.87,123.84 138.87,123.38 U35.B5 ; R267.2 173.67,90.27 173.16,89.76 173.16,89.3 172.88,89.03 170.86,89.03 170.47,89.42 168.2,89.42 167.74,88.96 v1(167,88.96)
SYS_SHDN#: length 336
  TOP w0.127: v1(182.34,37.13) 183.2,37.99 R11283.2 ; v1(53.52,34.01) 53.22,34.31 PR6278.2 ; v1(54.92,105.46) 47.28,105.46 v1(46.82,105.91) 46.16,106.57 PQ14.3
  TOP w0.203: PU6010.6 53.21,41.33 v1(53.83,41.96)
  IN1 w0.089: v1(90.1,127.76) 83.78,121.43 82.1,121.43 69.53,108.86 58.32,108.86 v1(54.92,105.46) 44.13,94.66 44.13,80.28 42.96,79.12 42.96,74.03 43.14,73.85 43.14,70.54 39.14,66.54 38.9,66.54 33.34,60.98 33.34,52.4 34.68,51.06 34.68,42.22 40.82,36.08 v1(40.82,34.31) 40.82,33.44 42.07,32.19 42.07,25.57 44.38,23.26 45.21,23.26 51.56,16.91 52,16.91 54.13,14.78 56.41,14.78 57.07,14.12 67.42,14.12 81.49,28.19 108.12,28.19 109.36,26.96 116.17,26.96 117.11,27.9 158.9,27.9 163.05,32.04 163.36,32.04 165.02,33.7 168.76,33.7 170.39,35.33 171.11,35.33 172.52,36.74 175.48,36.74 175.57,36.82 178.39,36.82 178.49,36.72 181.67,36.72 182.02,37.08 182.29,37.08 v1(182.34,37.13)
  IN3 w0.114: v1(53.52,34.01) 53.52,36.21 53.27,36.47 53.27,37.61 53.83,38.17 v1(53.83,41.96) 53.68,41.8 49.97,41.8 43.49,35.33 41.84,35.33 v1(40.82,34.31)
  BOTTOM w0.127: Q5.3 90.63,128.29 v1(90.1,127.76)
  BOTTOM w0.206: PR6280.2 55.22,42.08 53.96,42.08 v1(53.83,41.96)
SYSTEM_AGND: length 4.9
  TOP w0.508: v2(57.21,37.51) 57.56,37.51 57.97,37.1 57.97,36.55 57.51,36.09 56.58,36.09 PR6124.2
  BOTTOM w0.762: PR6125.2 56.94,38.06 57.21,37.79 v2(57.21,37.51)
  vias: v1(56.55,40.25)
TEMP_MBAT#: length 169.5
  TOP w0.127: v1(162.24,163.72) 157.92,163.72 156.14,165.5 155.63,165.5 155.34,165.79 155.34,167.47 156.14,168.27 156.14,168.96 155.83,169.27 PR9.1 PR8.2
  TOP w0.305: PR8.2 155.35,170.17 154.96,170.56 154.96,171.23 153.5,172.69 153.5,176.27 152.84,176.93 PR12.1
  IN2 w0.114: v1(166.84,81.35) 166.17,82.02 166.17,93.09 164.65,94.61 164.65,100.83 164.39,101.08 164.39,103.25 162.87,104.77 162.87,119.71 163.33,120.17 163.33,131.98 163.85,132.51 166.56,132.51 167.44,133.39 167.44,138.96 165.54,140.86 165.54,144.79 163.25,147.07 163.25,147.59 v1(163.76,148.1)
  IN3 w0.114: v1(172.8,32.48) 173.39,33.07 173.82,33.07 175.35,34.6 175.35,39.73 175.91,40.29 175.91,41.47 173.18,44.2 173.18,49.16 172.47,49.87 172.47,52.42 171.2,53.7 171.2,60.36 170.02,61.54 170.02,64.07 167.35,66.73 167.35,68.09 166.93,68.51 166.93,72.55 167.43,73.04 167.43,76.61 166.68,77.36 166.68,81.19 v1(166.84,81.35)
  BOTTOM w0.127: v1(172.8,32.48) 172.52,32.2 U45.73 ; v1(163.76,148.1) v1(163.76,148.93) 163.76,149.52 165.46,151.22 165.46,154.83 162.49,157.8 162.49,163.47 v1(162.24,163.72)
TERM9:
  vias: v1(25.04,91.21) v2(24.67,92.63) v2(25.46,92.63)
TESTMODE: length 9.3
  BOTTOM w0.127: v1(164.29,124.3) 164.73,124.74 R4011.1 166.43,124.74 166.62,124.94 170.31,124.94 170.52,125.14 170.52,126.39 170.76,126.64 171.33,126.64 U3002.AK11
TH_FAN_POWER: length 28.4
  IN2 w0.114: v1(81.24,119.91) 80.59,119.26 80.59,118.25 80.1,117.76 79.33,117.76 78.53,118.56 v1(68.81,118.56)
  BOTTOM w0.127: CN8.1 64.06,119.15 65.36,117.85 v1(66.56,117.85) 68.1,117.85 v1(68.81,118.56) ; U12.3 80.12,124.86 79.55,124.29 C723.2 C728.2 79.55,120.97 80.61,119.91 v1(81.24,119.91)
THRMTRIP#: length 16.3
  TOP w0.127: R530.1 v1(104.83,129.43)
  IN1 w0.089: v1(104.83,129.43) 104.83,129.81 104.57,130.07 102.9,130.07 102.34,129.51 102.34,129.13 101.75,128.55 97.71,128.55 95.69,130.58 v1(94.8,130.58)
  BOTTOM w0.127: v1(94.8,130.58) 94.54,130.32 93.53,130.32 93.53,130.97 R488.1
TP_INT: length 6.2
  TOP w0.127: v1(130.97,179.98) 130.97,180.11 131.63,180.77 Q1.1
  BOTTOM w0.127: CN5.1 130.32,179.37 130.64,179.37 130.97,179.7 v1(130.97,179.98) 130.97,180.11 131.49,180.62 R443.2 R8.2 132.78,180.61 R7.1
TP_INT_PCH: length 109.3
  TOP w0.127: v1(153.35,118.38) v1(153.35,119.5) 153.35,126.16 158.55,131.36 158.55,134.77 160.23,136.44 160.23,146.5 162.6,148.86 163.07,148.86 165.46,151.26 165.46,154.83 162.36,157.92 162.36,160.93 v1(161.85,161.44) ; v1(133.93,179.69) 133.5,179.69 133.08,179.27 Q1.3
  IN2 w0.114: v1(133.93,179.69) 133.93,178.04 134.52,177.44 134.52,176.17 135.2,175.5 135.2,174.45 137.03,172.63 145.63,172.63 145.9,172.89 149.95,172.89 150.29,172.55 152.59,172.55 156.93,168.21 156.93,166.87 158.55,165.25 158.55,164.61 161.73,161.44 v1(161.85,161.44)
  BOTTOM w0.076: 140.9,112.67 140.67,112.67 140.54,112.54 139.81,112.54 U35.AB3
  BOTTOM w0.127: v1(153.35,118.38) 153.35,116.97 152.52,116.14 152.52,115.65 152.13,115.26 149.84,115.26 148.71,114.13 145.94,114.13 145.3,113.48 142.35,113.48 141.53,112.67 140.9,112.67 ; v1(133.93,179.69) 133.77,179.84 R8.1
TP_PWR:
  vias: v1(115.75,170.07) v1(118.57,170.02) v1(119.06,170.45)
TP_RST#: length 2.5
  BOTTOM w0.127: v1(121.54,169.06) 121.15,168.66 R444.1 120.76,169.13 CN5.29
TPCLK: length 72.6
  IN1 w0.089: v1(174.94,31.77) 175.08,31.63 175.08,31.63 175.08,31.36 174.07,30.36 172.21,30.36 169.8,27.95 163.93,27.95 159.36,23.38 122.09,23.38 120.43,21.71 120.43,21.18 v1(120.04,20.8)
  BOTTOM w0.127: v1(174.94,31.77) 175.14,31.97 175.14,33 175.95,33.82 175.95,37.21 174.44,38.72 172.61,38.72 172.49,38.6 U45.89 ; R415.2 v1(120.04,20.8) R411.1
TPCLK_R: length 3.3
  BOTTOM w0.127: R411.2 120.04,18.3 C787.2 120.36,17.74 120.36,17.51 120,17.15 CN17.7
TPD_EN: length 73.9
  IN1 w0.089: v1(125.14,19.82) 127.46,22.14 v1(153.82,22.14) ; v1(153.42,34.44) 153.8,34.06 156.74,34.06 160.58,37.9 160.58,42.18 163.07,44.67 164.57,44.67 165.35,45.45 168.28,45.45 169.16,46.33 169.16,46.84 170.08,47.77 v1(171.7,47.77)
  BOTTOM w0.127: R190.2 171.87,48.16 171.7,47.99 v1(171.7,47.77) ; v1(153.42,34.44) 154.06,33.8 154.06,26.99 153.82,26.76 v1(153.82,22.14) ; CN17.1 v1(126,18.82) 126,18.97 v1(125.14,19.82)
TPD_INT#: length 178.1
  TOP w0.127: v1(179,40.15) 179.38,39.77 R349.2 ; v1(172.7,65.68) v1(171.41,65.68) 163.51,65.68 162.58,66.61 v1(162.58,67.26)
  IN1 w0.089: v1(124.14,19.82) 126.86,22.54 159.71,22.54 163.99,26.82 169.86,26.82 172.52,29.48 174.53,29.48 176.69,31.64 v1(176.69,32.89)
  IN2 w0.114: v1(158.68,113.68) 157.92,112.92 157.92,111.47 159.38,110.01 159.38,109.44 158.93,108.99 158.93,101.54 159.37,101.11 159.37,92.98 158.72,92.34 158.72,87.95 157.82,87.05 157.82,79.8 158.53,79.1 158.53,71.42 161.6,68.35 161.6,68.23 v1(162.58,67.26)
  IN3 w0.114: v1(172.7,65.68) 172.7,64.86 173.64,63.92 173.64,62.6 174.05,62.19 174.05,58.06 174.62,57.49 174.62,55.02 176.15,53.49 178.85,53.49 179.25,53.08 179.25,51.33 179.42,51.16 179.42,47.33 179.91,46.83 179.91,41.07 v1(179,40.15) 179,39.79 177,37.79 177,35.93 177.86,35.07 177.86,34.31 176.69,33.14 v1(176.69,32.89)
  BOTTOM w0.127: R164.1 152.76,117.16 152.76,118.82 152.84,118.89 Q20.1 153.73,119.91 154.11,119.53 154.11,118.64 155.12,117.62 156.93,117.62 157.96,116.6 157.96,114.41 v1(158.68,113.68) ; v1(124.14,19.82) 125,18.97 CN17.2
TPD_INT#_D: length 15.8
  BOTTOM w0.076: U35.W4 139.03,113.41 139.18,113.25 139.51,113.25 139.69,113.34 139.98,113.34 140.06,113.31 140.27,113.31 140.38,113.36 140.6,113.36 140.71,113.31 141.41,113.31 141.73,113.62
  BOTTOM w0.127: 141.73,113.62 142.82,114.71 144.64,114.71 144.97,114.38 148.59,114.38 149.73,115.52 150.11,115.52 R177.1 151.2,116.61 R164.2 151.43,116.8 151.82,117.19 Q20.3
TPDATA: length 73.1
  IN1 w0.089: v1(121.06,20.77) 120.67,21.16 120.67,21.61 122.19,23.13 159.46,23.13 164.03,27.71 169.9,27.71 172.31,30.12 174.17,30.12 175.32,31.26 175.32,31.53 v1(175.57,31.78)
  BOTTOM w0.127: R416.2 v1(121.06,20.77) R412.1 ; v1(175.57,31.78) 175.42,31.93 175.42,32.89 176.23,33.7 176.23,37.32 174.55,39 U45.90
TPDATA_R: length 3.4
  BOTTOM w0.127: CN17.6 121,17.15 120.64,17.51 120.64,17.65 C788.2 121.06,18.3 R412.2
TPM_BADD: length 1.9
  BOTTOM w0.127: R729.2 166.55,65.99 v1(166.55,66.44) 166.69,66.58 U44.6
TPM_CLKRUN#: length 2
  BOTTOM w0.127: R743.1 163.73,69.9 v1(163.79,69.95) 164.21,70.37 U44.13
TPM_LRESET#: length 2.4
  BOTTOM w0.127: U44.17 165.69,73.91 165.66,73.93 R742.2 165,74.31 v1(164.93,74.24)
TPM_PP: length 3.9
  BOTTOM w0.127: TP4358.1 167.44,64.66 167.44,66.44 167.69,66.69 U44.4
TS_EN: length 399.6
  TOP w0.127: R442.1 v1(129.34,178.84) 129.85,179.34 v1(131.25,179.34)
  IN2 w0.114: v1(191.2,26.56) 189.92,26.56 189.16,25.8 186.62,25.8 185.1,24.28 173.03,24.28 171.89,23.13 168.84,23.13 167.42,24.56 113.2,24.56 112.36,23.72 80.49,23.72 77.74,20.97 74.99,20.97 65.84,11.83 64.83,11.83 62.9,9.9 62.25,9.9 60.22,11.93 56.82,11.93 54.84,13.91 52.44,13.91 50.29,16.06 40.4,16.06 32.7,23.77 32.7,26.05 26.85,31.9 26.85,41.68 27.87,42.69 27.87,59.07 30.98,62.19 30.98,66.73 31.65,67.41 31.65,70.92 32.16,71.42 33.74,71.42 34.45,72.14 34.45,74.28 33.59,75.15 33.59,77.64 32.6,78.63 32.6,97.33 34.45,99.18 38.16,99.18 55.96,116.99 65.72,116.99 67.94,119.22 75.18,119.22 94.35,138.39 94.35,139.15 101.89,146.69 101.89,147.67 102.5,148.28 102.5,149.09 102.88,149.47 102.88,149.63 103.19,149.94 103.19,150.27 104.12,151.2 104.12,151.91 105.72,153.51 105.72,154.96 106.36,155.59 106.36,156.74 107.12,157.5 107.12,158.9 107.5,159.28 107.5,159.63 108.27,160.41 108.27,161.35 108.82,161.89 108.82,162.5 109.58,163.27 109.58,164.16 111.94,166.52 111.94,168.93 114.23,171.22 114.23,173.12 115.5,174.39 115.5,175 119.84,179.34 v1(131.25,179.34)
  BOTTOM w0.127: R443.1 131.75,179.84 v1(131.25,179.34) ; R751.1 191.84,26.77 191.62,26.56 v1(191.2,26.56)
TS_EN_C: length 4.9
  BOTTOM w0.127: U45.32 187.99,29 188.27,28.72 v1(188.27,28.16) 188.27,28.14 188.7,27.71 189.42,27.71 C800.1 R751.2
TS_EN_R: length 2.1
  TOP w0.127: R442.2 127.23,178.84 v1(127.11,178.71)
  BOTTOM w0.127: v1(127.11,178.71) 127.44,178.71 CN5.6
TST: length 3.8
  TOP w0.127: U9.22 29.64,119.4 29.41,119.63 28.76,119.63 v1(28.44,119.95) 28.1,120.29 R617.1 R11209.1
TYPEC_CHG: length 3.1
  TOP w0.203: U28.7 32.81,110.83 33,111.02 33.69,111.02 v1(34.17,110.54) 34.78,111.14 R11205.2
TYPEC_CHG_HI: length 5.9
  TOP w0.203: U28.8 32.31,110.86 33.28,111.83 v1(33.99,111.83) 34.64,111.83 R11198.2 35.58,112.77 36.4,112.77 R11279.1
TYPEC_SBU1: length 16.4
  TOP w0.127: v1(12.5,115.97) 13.09,116.56 14.19,116.56 14.28,116.64 U4513.4 16.1,116.64 TP143.1
  IN3 w0.114: v1(8.29,120.6) 8.29,121.06 8.72,121.48 10.15,121.48 10.72,120.91 10.72,117.62 12.38,115.97 v1(12.5,115.97)
  BOTTOM w0.127: v1(8.29,120.6) 8.24,120.65 CN2021.A8
TYPEC_SBU2: length 18.4
  TOP w0.127: v1(13.14,115.97) 13.41,116.24 U4513.7 17.6,116.24 TP144.1
  IN3 w0.114: CN2021.B8 5.33,119.02 6.41,119.02 6.79,119.4 6.79,119.91 8.77,121.89 10.06,121.89 10.98,120.97 10.98,118.89 13.14,116.73 v1(13.14,115.97)
UART2_CTS#: length 17.4
  BOTTOM w0.076: 141.03,111.51 140.9,111.38 140.72,111.38 140.6,111.32 140.13,111.32 140.09,111.27 139.21,111.27 U35.AD4
  BOTTOM w0.127: R290.1 154.11,115.18 152.88,113.95 151.69,113.95 151.45,114.19 TP4357.1 149.98,113.37 146.26,113.37 145.61,112.72 142.73,112.72 141.51,111.51 141.03,111.51
UART2_RTS#: length 22.1
  BOTTOM w0.076: 141.53,110.76 141.08,110.76 140.92,110.61 139.83,110.61 U35.AD3
  BOTTOM w0.127: R283.1 156.9,113.76 157.38,113.28 TP4356.1 157.23,112.62 155.43,112.62 154.9,113.15 151.2,113.15 150.66,112.61 146.57,112.61 145.93,111.96 143.11,111.96 141.92,110.76 141.53,110.76
UART2_RXD: length 17.7
  BOTTOM w0.127: U35.AD1 140.89,111 141.77,111 142.99,112.21 145.82,112.21 146.47,112.86 150.54,112.86 151.1,113.42 155.21,113.42 TP4354.1 156.01,114.22 R275.1
UART2_TXD: length 16.7
  BOTTOM w0.076: 141.15,111.27 141.07,111.19 140.71,111.19 140.63,111.15 140.39,111.15 U35.AD2
  BOTTOM w0.127: R280.1 155,115.34 TP4355.1 153.35,113.68 150.93,113.68 150.36,113.11 146.36,113.11 145.72,112.47 142.86,112.47 141.66,111.27 141.15,111.27
USB2_ID: length 4.6
  TOP w0.127: R587.1 142.65,108.35 142.12,108.88 v1(142.09,108.88) 141.69,108.88 v1(141.41,108.6)
  BOTTOM w0.076: U35.AG3 139.51,108.75 139.73,108.52 141.33,108.52 v1(141.41,108.6)
USB2_TYPC_7N_C: length 20.4
  TOP w0.127: v1(13.13,114.72) 13.31,114.54 U4513.9 16.28,114.54 16.57,114.83 17.06,114.83 17.21,114.98 L69.3 17.72,114.98 R818.2
  IN1 w0.089: CN2021.B7 6.26,119.5 7.23,118.52 8.96,118.52 9.71,119.27 9.71,119.81 9.44,120.07 9.16,120.07 v1(8.95,120.29)
  IN3 w0.114: v1(8.95,120.29) 9.4,119.83 9.4,118.05 12.02,115.44 12.42,115.44 13.13,114.72 v1(13.13,114.72)
  BOTTOM w0.127: CN2021.A7 7.94,120.15 8.06,120.03 8.68,120.03 v1(8.95,120.29)
USB2_TYPC_7P_C: length 20.4
  TOP w0.127: R819.2 17.72,114.43 L69.2 17.21,114.43 17.06,114.57 16.67,114.57 16.39,114.29 15.54,114.29 15.39,114.14 U4513.1 13.22,114.14 v1(13.14,114.07)
  IN1 w0.089: v1(8.95,119.53) 8.95,119.76 9.07,119.88 9.36,119.88 9.52,119.73 9.52,119.35 8.88,118.71 7.31,118.71 6.58,119.44 6.58,119.77 CN2021.B6
  IN3 w0.114: v1(13.14,114.07) 13.01,114.07 12.68,114.4 12.68,114.85 12.32,115.21 11.93,115.21 9.18,117.96 9.18,119.3 v1(8.95,119.53)
  BOTTOM w0.127: CN2021.A6 7.94,119.65 8.06,119.77 8.7,119.77 v1(8.95,119.53)
USB3_RXN0: length 262.7
  TOP w0.127: R392.2 18.34,8.65 C518.2 18.47,8.28 v1(18.47,7.89)
  IN3 w0.114: v1(18.47,7.89) 18.73,8.15 18.73,8.73 21.13,11.13 21.89,11.13 24.85,14.09 66.99,14.09 77.79,24.89 83.15,24.89 90.77,32.51 150.43,32.51 158.35,40.42 158.35,41.5 157.79,42.06 157.79,65.42 158.45,66.09 158.45,68.83 158.04,69.23 158.04,73.3 158.73,73.98 158.73,75.96 161.78,79.01 161.78,83.08 162.64,83.93 162.64,87.74 163.02,88.13 163.02,90.72 163.63,91.33 163.63,100.17 163.94,100.47 163.94,103.79 160.2,107.52 160.2,109.75 159.34,110.61 159.34,115.56 153.5,121.41 147.38,121.41 146.89,120.92 145.6,120.92 144.48,119.81 141.62,119.81 141.44,119.98 138.48,119.98 138.32,119.82 137.5,119.82 137.24,119.57 137.24,119.16 v3(136.81,118.73)
  BOTTOM w0.127: v3(136.81,118.73) 136.63,118.73 U35.H8
USB3_RXN0_R: length 10.6
  TOP w0.127: CN16.5 12.92,11.57 14.14,12.78 14.86,12.78 15.16,12.48 18.56,12.48 18.6,12.44 U24.6 19.41,12.44 19.74,12.11 19.74,11.76 19.46,11.48 19,11.48 18.62,11.1 18.62,10.6 R392.1
USB3_RXN1: length 261.5
  TOP w0.127: v1(48.06,15.26) 48.32,15.51 48.32,23.97 43.94,28.34 37.67,28.34 35.77,30.24 23.66,30.24 23.45,30.03 23.45,29.8 23.27,29.62 C475.2 23.03,29.61 R355.2
  IN3 w0.114: v1(137.68,118.75) 137.85,118.92 137.85,118.92 137.88,118.94 138.29,118.94 138.44,118.79 144.99,118.79 146.03,119.83 146.87,119.83 147.35,120.31 152.3,120.31 157.44,115.18 157.44,108.71 162.77,103.37 162.77,93.59 162.26,93.08 162.26,88.63 161.14,87.51 161.14,79.38 158.07,76.31 158.07,74.57 157.16,73.65 157.16,67.58 156.93,67.36 156.93,62.85 156.65,62.57 156.65,59.07 157.05,58.67 157.05,40.05 150.16,33.15 90.47,33.15 83.24,25.93 77.89,25.93 66.71,14.75 51.82,14.75 50.81,15.77 48.57,15.77 v1(48.06,15.26)
  BOTTOM w0.127: v1(137.68,118.75) 137.32,118.39 U35.J6
USB3_RXN1_R: length 10.8
  TOP w0.127: R355.1 20.88,29.61 20.56,29.93 20.08,29.93 19.4,30.6 U21.6 18.54,30.6 18.42,30.73 16.69,30.73 16.41,30.45 16.41,29.81 16.09,29.48 14.28,29.48 13.49,28.7 13.11,28.7 12.92,28.51 CN13.5
USB3_RXN2: length 123.4
  TOP w0.127: C394.1 39.05,116.1 39.32,116.36 39.68,116.73 39.68,117.11 v1(39.81,117.24)
  IN1 w0.089: v3(135.87,118.71) 136.33,119.17 136.33,120.29 136.4,120.37 136.4,121.61 135.34,122.68 134.3,122.68 133.75,123.22 132.13,123.22 131.73,122.82 124.52,122.82 123.31,124.04 122.97,124.04 122.56,124.45 122.56,126.68 118.29,130.95 118.29,131.45 114.46,135.29 105.46,135.29 105.13,134.96 96.19,134.96 91.54,130.31 87.76,130.31 70.5,113.05 43.63,113.05 39.81,116.88 v1(39.81,117.24)
  BOTTOM w0.127: U35.J10 135.55,118.39 v3(135.87,118.71)
USB3_RXN3: length 122.8
  TOP w0.127: v1(38.66,120.29) 38.54,120.16 C4777.1
  IN1 w0.089: v1(38.66,120.29) 38.66,120.35 38.41,120.61 38.09,120.61 38.02,120.53 38.02,117 42.6,112.41 70.7,112.41 88.01,129.72 91.9,129.72 96.55,134.37 105.57,134.37 105.9,134.7 114.22,134.7 117.66,131.26 117.66,130.72 121.96,126.41 121.96,124.2 123.97,122.19 125.15,122.19 125.46,121.88 127.91,121.88 127.95,121.84 128.85,121.84 129.14,122.13 129.68,122.13 130.1,121.7 130.72,121.7 131.16,122.14 132.33,122.14 132.72,121.75 133.45,121.75 133.71,122 134.35,122 134.64,121.71 135.23,121.71 135.39,121.56 135.39,121.33 135.31,121.25 v3(134.97,121.25)
  BOTTOM w0.127: U35.E10 135.23,120.99 v3(134.97,121.25)
USB3_RXP0: length 262.7
  TOP w0.127: v1(19.11,7.89) 19.11,8.28 C517.2 19.23,8.65 R387.2
  IN3 w0.114: v3(136.78,119.36) 136.78,119.43 137.4,120.05 138.22,120.05 138.38,120.21 141.53,120.21 141.71,120.03 144.39,120.03 145.5,121.15 146.8,121.15 147.28,121.64 153.59,121.64 159.57,115.66 159.57,110.71 160.43,109.84 160.43,107.61 164.17,103.88 164.17,100.38 163.86,100.07 163.86,91.24 163.25,90.63 163.25,88.03 162.87,87.65 162.87,83.84 162.01,82.98 162.01,78.92 158.96,75.86 158.96,73.89 158.27,73.2 158.27,69.33 158.68,68.92 158.68,65.99 158.02,65.33 158.02,42.15 158.58,41.59 158.58,40.33 150.53,32.28 90.86,32.28 83.24,24.66 77.88,24.66 67.09,13.86 24.95,13.86 21.99,10.9 21.22,10.9 18.95,8.63 18.95,8.05 18.95,8.05 v1(19.11,7.89)
  BOTTOM w0.127: U35.G8 136.66,119.36 v3(136.78,119.36)
USB3_RXP0_R: length 10.6
  TOP w0.127: R387.1 18.88,10.67 18.88,10.99 19.11,11.22 19.56,11.22 20,11.65 20,12.22 19.48,12.74 17.58,12.74 17.47,12.84 U24.5 16.82,12.84 16.71,12.74 15.27,12.74 14.96,13.04 14.03,13.04 13.71,12.72 13.4,12.72 CN16.6
USB3_RXP1: length 261.5
  TOP w0.127: R353.2 23.03,30.5 C469.2 35.88,30.49 37.78,28.59 44.05,28.59 48.57,24.07 48.57,15.39 v1(48.7,15.26)
  IN3 w0.114: v1(137.74,119.39) 137.95,119.17 138.39,119.17 138.54,119.02 144.89,119.02 145.94,120.06 146.77,120.06 147.26,120.54 152.4,120.54 157.66,115.28 157.66,108.8 163,103.47 163,93.5 162.49,92.99 162.49,88.54 161.37,87.41 161.37,79.29 158.3,76.22 158.3,74.47 157.38,73.56 157.38,67.49 157.16,67.26 157.16,62.76 156.88,62.48 156.88,59.17 157.28,58.76 157.28,39.96 150.25,32.93 90.56,32.93 83.34,25.7 77.98,25.7 66.81,14.52 51.73,14.52 50.71,15.54 48.98,15.54 v1(48.7,15.26)
  BOTTOM w0.127: U35.H6 137.58,119.39 v1(137.74,119.39)
USB3_RXP1_R: length 10.8
  TOP w0.127: CN13.6 12.92,29.09 13.06,28.95 13.38,28.95 14.17,29.74 15.98,29.74 16.16,29.92 16.16,30.55 16.61,31 U21.5 18.53,31 18.62,30.91 19.46,30.91 20.19,30.18 20.56,30.18 20.88,30.5 R353.1
USB3_RXP2: length 123.4
  TOP w0.127: C4781.1 36.13,116.83 36.61,116.35 38.94,116.35 39.06,116.47 39.43,116.83 39.43,116.99 v1(39.17,117.24)
  IN1 w0.089: v1(39.17,117.24) 43.55,112.86 70.58,112.86 87.84,130.12 91.62,130.12 96.27,134.77 105.21,134.77 105.54,135.1 114.38,135.1 118.1,131.38 118.1,130.87 122.37,126.6 122.37,124.37 122.43,124.31 122.89,123.84 123.23,123.84 124.44,122.63 131.81,122.63 132.21,123.03 133.67,123.03 134.22,122.49 135.26,122.49 136.21,121.53 136.21,120.44 136.14,120.37 136.14,119.91 136.01,119.78 135.72,119.78 135.57,119.63 135.57,119.45 135.69,119.32 v3(135.87,119.32)
  BOTTOM w0.127: v3(135.87,119.32) 135.59,119.04 U35.H10
USB3_RXP3: length 122.8
  TOP w0.127: v1(38.66,120.92) 38.54,121.05 C4776.1
  IN1 w0.089: v1(38.66,120.92) 38.54,120.8 38.01,120.8 37.83,120.61 37.83,116.92 42.52,112.22 70.78,112.22 88.09,129.53 91.98,129.53 96.63,134.18 105.64,134.18 105.97,134.51 114.14,134.51 117.47,131.18 117.47,130.64 121.77,126.33 121.77,124.12 123.89,122 125.07,122 125.38,121.69 127.83,121.69 127.87,121.65 128.93,121.65 129.22,121.94 129.6,121.94 130.02,121.51 130.8,121.51 131.24,121.95 132.25,121.95 132.64,121.56 133.53,121.56 133.79,121.81 134.27,121.81 134.55,121.53 134.55,121.09 134.97,120.67 v3(134.97,120.64)
  BOTTOM w0.127: v3(134.97,120.64) 135.11,120.64 U35.F10
USB3_TXN0: length 265.2
  TOP w0.127: C499.1 18.85,21.71 v1(18.95,21.81)
  IN3 w0.076: v3(131.87,121.54) 131.77,121.44 131.77,120.61 131.68,120.52 131.68,118.94 131.65,118.91 131.65,118.89
  IN3 w0.114: v1(18.95,21.81) 18.67,21.53 18.67,21.36 18.95,21.08 28.45,21.08 29.03,20.49 34.7,20.49 38.18,17.01 53.68,17.01 54.44,16.25 67.27,16.25 77.71,26.69 82.92,26.69 90.03,33.8 112.64,33.8 113.12,34.28 116,34.28 116.48,33.8 149.66,33.8 156.14,40.28 156.14,47.94 155.81,48.27 155.81,54.5 155.35,54.96 155.35,60.83 155.89,61.36 155.89,62.63 155.56,62.96 155.56,67.32 156.29,68.06 156.29,74.09 155.76,74.63 155.76,76.42 159.98,80.63 159.98,88.18 161.37,89.58 161.37,98.85 161.55,99.03 161.55,103.45 156.14,108.86 156.14,115.46 154.62,116.99 153.78,116.99 151.5,119.27 149.28,119.27 149.03,119.02 147,119.02 145.79,117.82 140.07,117.82 139.64,117.38 138.98,117.38 138.48,117.89 134.96,117.89 134.72,118.13 133.72,118.13 133.44,118.41 131.9,118.41 131.65,118.66 131.65,118.89
  BOTTOM w0.076: v3(131.87,121.54) 132,121.42 132.43,121.42 132.47,121.46 132.84,121.46 132.87,121.43 133.18,121.43 133.39,121.65 133.39,121.93 133.69,122.22 U35.C13
USB3_TXN0_C: length 1.2
  TOP w0.127: R384.2 19.23,19.95 C499.2
USB3_TXN0_R: length 11.9
  TOP w0.127: CN16.8 12.92,17.79 13.13,18 13.44,18 13.97,17.47 15.7,17.47 16.11,17.06 16.11,16.25 16.6,15.75 18.61,15.75 18.72,15.64 U24.10 19.26,15.64 19.61,16 19.61,16.35 18.95,17.01 18.95,17.28 C511.1 19.23,17.55 R384.1
USB3_TXN1: length 285.2
  TOP w0.127: C461.1 23.81,33.76 24.07,34.01 33.12,34.01 37.78,29.36 44.89,29.36 49.1,25.14 49.1,17.03 49.33,16.81 49.33,13.88 49.92,13.3 49.92,12.97 49.54,12.59 v1(49.46,12.59)
  IN3 w0.114: v1(134.23,123.42) 134.93,124.12 134.93,124.35 135.34,124.76 136.1,124.76 137.67,126.33 140.34,126.33 140.8,126.79 145.95,126.79 146.18,126.56 154.92,126.56 155.76,127.4 160.29,127.4 161.02,126.67 161.02,107.79 164.78,104.03 164.78,99.82 164.42,99.46 164.42,90.98 163.76,90.32 163.76,83.53 162.43,82.2 162.43,78.65 159.39,75.6 159.39,73.55 158.83,72.99 158.83,69.46 159.39,68.9 159.39,68 159.72,67.67 159.72,66.92 159.17,66.37 159.17,65.61 158.45,64.88 158.45,42.67 159.01,42.11 159.01,40.1 154.62,35.71 154.62,34.96 151.51,31.86 91.33,31.86 83.37,23.9 77.74,23.9 67.2,13.35 50.22,13.35 v1(49.46,12.59)
  BOTTOM w0.127: v1(134.23,123.42) 133.87,123.06 U35.B13
USB3_TXN1_C: length 1
  TOP w0.127: R341.2 C461.2
USB3_TXN1_R: length 9.7
  TOP w0.127: CN13.8 12.92,34.55 13.06,34.69 13.33,34.69 14.22,33.8 15.32,33.8 15.42,33.9 17.5,33.9 17.55,33.86 18.6,33.86 18.65,33.8 U21.10 19.44,33.8 19.49,33.86 19.82,33.86 20.12,33.56 C460.1 20.88,33.56 20.89,33.55 R341.1
USB3_TXN2: length 119.4
  TOP w0.127: C4780.1 38.27,118.49 42.63,118.49 v1(42.86,118.26)
  IN1 w0.089: v1(42.86,118.26) 42.86,118.43 43.12,118.7 43.81,118.7 48.38,114.13 70.16,114.13 87.37,131.34 90.48,131.34 96.46,137.32 103.66,137.32 104.56,136.42 114.74,136.42 119.5,131.66 119.5,131.53 122.94,128.09 123.94,128.09 124.71,127.32 124.71,124.53 125.43,123.8 129.81,123.8 132.02,126.02 133.34,126.02 133.47,125.89 133.47,125.72 133.22,125.47 v1(133.15,125.47)
  BOTTOM w0.076: U35.B15 132.33,123.26 132.06,123.53 132.06,124.3 133.15,125.39 v1(133.15,125.47)
USB3_TXN3: length 122.2
  TOP w0.127: C4779.1 38.28,121.94 38.58,122.23 38.88,122.23 40.47,120.64 40.85,120.64 v1(41.2,120.29)
  IN1 w0.089: v1(41.2,120.29) 41.2,120.61 41.53,120.94 41.74,120.94 41.9,120.77 41.9,117.67 46.08,113.49 70.37,113.49 87.58,130.7 91.37,130.7 96.03,135.36 104.43,135.36 104.79,135.72 114.6,135.72 118.74,131.58 118.74,131.07 124.11,125.7 124.11,123.94 124.83,123.22 130.17,123.22 131.83,124.88 132.67,124.88 132.77,124.78 132.77,124.58 132.9,124.45 133.02,124.45 v1(133.24,124.67)
  BOTTOM w0.076: U35.C15 132.21,122.41 132.11,122.31 132.11,122.16 132.21,122.06 132.39,122.06 132.63,122.29 132.63,122.49 132.57,122.63 132.57,122.87 132.61,122.99 132.61,123.18 132.56,123.33 132.56,123.48 132.58,123.54 132.6,123.59 132.6,124.04 132.98,124.42 133.14,124.42 133.24,124.52 v1(133.24,124.67)
USB3_TXP0: length 265.2
  TOP w0.127: v1(18.22,21.81) 17.96,21.56 C498.1
  IN3 w0.076: 131.88,118.89 131.88,118.91 131.84,118.94 131.84,120.45 132.05,120.66 v3(132.17,120.66)
  IN3 w0.114: 131.88,118.89 131.88,118.75 131.99,118.64 133.53,118.64 133.81,118.36 134.81,118.36 135.06,118.12 138.57,118.12 139.07,117.61 139.54,117.61 139.98,118.05 145.7,118.05 146.9,119.25 148.93,119.25 149.19,119.5 151.59,119.5 153.88,117.22 154.71,117.22 156.37,115.56 156.37,108.95 161.78,103.54 161.78,98.93 161.6,98.76 161.6,89.49 160.2,88.09 160.2,80.54 155.99,76.32 155.99,74.72 156.52,74.19 156.52,67.96 155.78,67.23 155.78,63.06 156.11,62.73 156.11,61.27 155.58,60.73 155.58,55.05 156.04,54.6 156.04,48.36 156.37,48.03 156.37,40.18 149.76,33.57 116.39,33.57 115.91,34.06 113.21,34.06 112.73,33.57 90.13,33.57 83.01,26.46 77.81,26.46 67.37,16.02 54.34,16.02 53.58,16.78 38.09,16.78 34.61,20.26 28.94,20.26 28.35,20.85 18.86,20.85 18.45,21.26 18.45,21.58 v1(18.22,21.81)
  BOTTOM w0.076: U35.D13 133.69,121.58 133.37,121.27 132.8,121.27 132.77,121.29 132.54,121.29 132.48,121.24 132.15,121.24 132.04,121.13 132.04,120.79 v3(132.17,120.66)
USB3_TXP0_C: length 1.1
  TOP w0.127: R381.2 18.22,20.08 C498.2
