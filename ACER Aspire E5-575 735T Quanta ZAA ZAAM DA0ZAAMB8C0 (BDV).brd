# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_DQ17: length 36.8
  IN3 w0.114: v1(196.65,148.25) 197.08,147.82 198.67,147.82 204.98,154.13 204.98,165.05 204.78,165.25 204.27,165.25 202.97,166.54 202.34,166.54 201.73,167.15 201.73,167.41 200.67,168.47 199.59,168.47 v3(199.33,168.22)
  BOTTOM w0.152: v3(199.33,168.22) VRAM3000.U13 ; v1(196.65,148.25) 194.82,148.25 194.27,147.7 193.8,147.7 193.12,147.02 193.12,146.69 193.29,146.52 193.29,145.75 193.05,145.5 193.05,144.97 U3002.D32
VMA_DQ18: length 36.6
  IN3 w0.114: v3(197.73,167.42) 199.14,168.83 200.95,168.83 202.3,167.48 202.8,167.48 203.89,166.39 204.53,166.39 205.29,165.62 205.29,153.95 198.82,147.47 195.99,147.47 v1(195.26,146.73)
  BOTTOM w0.152: U3002.B33 194.72,145.74 194.72,146.29 195.17,146.73 v1(195.26,146.73) ; v3(197.73,167.42) VRAM3000.T11
VMA_DQ19: length 32.2
  IN3 w0.114: v3(199.33,167.42) 199.52,167.61 200.64,167.61 202.06,166.19 202.82,166.19 203.9,165.11 203.9,161.74 204.1,161.54 204.1,153.76 198.6,148.25 v1(197.95,148.25)
  BOTTOM w0.152: v3(199.33,167.42) VRAM3000.T13 ; U3002.C33 193.96,145.71 193.96,146.66 194.92,147.62 197.32,147.62 v1(197.95,148.25)
VMA_DQ20: length 30
  IN3 w0.114: v1(197.57,149.35) 197.57,150.03 201.87,154.33 201.87,161.22 201.2,161.89 201.2,163.49 200.49,164.2 199.73,164.2 199.29,164.64 197.31,164.64 v3(196.92,165.02)
  BOTTOM w0.152: U3002.F33 191.83,145.48 192.23,145.89 192.23,146.73 192.41,146.9 192.41,147.44 194.32,149.35 v1(197.57,149.35) ; VRAM3000.N11 v3(196.92,165.02)
VMA_DQ21: length 31.7
  IN3 w0.114: v3(198.53,165.06) 200.52,165.06 201.53,164.05 201.53,162.04 202.74,160.82 202.74,154.48 v1(199.31,151.05)
  BOTTOM w0.152: VRAM3000.N13 198.53,165.01 v3(198.53,165.06) ; v1(199.31,151.05) 198.59,151.05 198.02,150.49 193.95,150.49 191.42,147.96 191.42,144.94 U3002.F32
VMA_DQ22: length 30.1
  IN3 w0.114: v1(197.75,152.06) 198.59,152.06 201.23,154.7 201.23,160.85 200.54,161.54 200.54,162.77 200.3,163.01 198.38,163.01 198.14,163.25 198.14,163.59 197.93,163.8 197.34,163.8 v3(196.91,164.23)
  BOTTOM w0.152: U3002.H33 190.13,145.51 190.52,145.91 190.52,146.45 190.25,146.72 190.25,148.01 194.3,152.06 v1(197.75,152.06) ; v3(196.91,164.23) 196.91,164.23 VRAM3000.M11
VMA_DQ23: length 29.7
  IN3 w0.114: v1(196.83,151.14) 198.17,151.14 201.55,154.52 201.55,161.03 200.87,161.72 200.87,163.32 200.34,163.85 198.9,163.85 v3(198.55,164.2)
  BOTTOM w0.152: U3002.H32 190.56,144.97 190.56,145.49 190.79,145.72 190.79,146.58 190.55,146.82 190.55,147.7 193.99,151.14 v1(196.83,151.14) ; v3(198.55,164.2) VRAM3000.M13
VMA_DQ24: length 28.1
  TOP w0.152: v3(191.36,168.18) VRAM3004.A4
  BOTTOM w0.152: v3(191.36,168.18) 190.74,168.8 v1(188.02,168.8) 187.19,167.98 187.19,167.37 186.15,166.33 186.15,151.4 185.15,150.39 185.15,148.33 185.25,148.23 185.25,146.26 U3002.P34
VMA_DQ25: length 27.3
  TOP w0.152: v3(189.76,168.18) VRAM3004.A2
  BOTTOM w0.102: U3002.P32 185.53,144.94 185.53,145.66 185.72,145.85 185.72,146.89 185.78,146.94 185.78,147.09
  BOTTOM w0.152: v3(189.76,168.18) 189.57,168.37 188.2,168.37 187.76,167.94 187.76,166.39 v1(187.51,166.14) 187.09,165.72 187.09,151.11 186.01,150.04 186.01,147.61 185.78,147.37 185.78,147.09
VMA_DQ26: length 30.2
  TOP w0.152: VRAM3004.B4 191.34,167.41 189.16,167.41 189.06,167.51 v1(186.62,167.51)
  BOTTOM w0.152: v1(186.62,167.51) 185.72,166.61 185.72,151.58 184.71,150.57 184.71,148.05 184.99,147.77 184.99,146.6 184.74,146.35 184.74,144.12 U3002.P31
VMA_DQ27: length 25.2
  TOP w0.152: v1(186.87,166.26) 187.51,166.26 187.89,166.64 189.76,166.64 VRAM3004.B2
  BOTTOM w0.102: U3002.P33 185.13,145.54 185.52,145.94 185.52,147.21
  BOTTOM w0.152: 185.52,147.21 185.52,147.52 185.58,147.58 185.58,150.21 186.58,151.22 186.58,165.97 v1(186.87,166.26)
VMA_DQ28: length 25.8
  TOP w0.152: VRAM3004.E4 192.09,164.26 193.48,164.26 194.21,163.52 194.21,163.02 v1(193.44,162.25)
  BOTTOM w0.152: v1(193.44,162.25) 193.44,155.35 187.51,149.41 187.51,147.94 187.21,147.64 187.21,144.16 U3002.L31
VMA_DQ29: length 24.7
  TOP w0.152: v3(189.74,164.23) VRAM3004.E2
  BOTTOM w0.152: U3002.L34 187.63,147.59 187.94,147.9 187.94,149.24 193.9,155.19 193.9,162.47 192.97,163.39 190,163.39 189.74,163.65 v3(189.74,164.23)
VMA_DQ30: length 26
  TOP w0.152: VRAM3004.F4 191.73,163.82 v3(191.32,164.23)
  BOTTOM w0.152: U3002.L32 188.1,145.01 188.1,145.51 188.4,145.82 188.4,147.34 188.8,147.75 188.8,148.88 194.76,154.83 194.76,163.08 193.6,164.23 v3(191.32,164.23)
VMA_DQ31: length 24.8
  TOP w0.152: v3(193.73,163.26) 192.94,163.26 192.82,163.39 190.55,163.39 VRAM3004.F2
  BOTTOM w0.152: v3(193.73,163.26) 194.33,162.67 194.33,155.01 188.37,149.06 188.37,147.82 188,147.45 188,145.82 187.63,145.45 U3002.L33
VMA_DQ32: length 15.6
  TOP w0.152: v3(176.89,154.59) 176.89,154.59 VRAM3001.A4
  IN1 w0.114: v3(176.89,154.59) 176.89,152.59 174.35,150.06 174.35,143.92 174.81,143.46 174.81,143.05 175.16,142.7 175.16,142.09 v1(174.72,141.65)
  BOTTOM w0.152: v1(174.72,141.65) 174.33,141.25 U3002.AG28
VMA_DQ33: length 15.3
  TOP w0.152: VRAM3001.A2 178.49,154.59 v3(178.49,154.58)
  IN1 w0.114: v3(178.49,154.58) 178.49,153.56 174.67,149.74 174.67,144.02 175.06,143.63 175.06,143.14 175.61,142.59 v3(175.61,142.52)
  BOTTOM w0.152: U3002.AF29 175.55,142.52 v3(175.61,142.52)
VMA_DQ34: length 16.3
  TOP w0.152: VRAM3001.B4 177.69,155.39 v3(177.69,155.39)
  IN1 w0.114: v3(177.69,155.39) 177.29,154.99 176.59,154.99 176.21,154.61 176.21,152.56 174.03,150.39 174.03,143.81 174.43,143.42 174.43,142.83 v1(174.75,142.51)
  BOTTOM w0.152: U3002.AG29 v1(174.75,142.51)
VMA_DQ35: length 17.7
  TOP w0.152: v3(178.49,155.39) VRAM3001.B2
  IN1 w0.114: v3(178.49,155.39) 179,154.88 179,153.44 174.99,149.42 174.99,144.11 175.34,143.76 175.85,143.76 176.01,143.6 176.01,142.29 175.57,141.85 v3(175.57,141.63)
  BOTTOM w0.152: U3002.AF28 175.52,141.63 v3(175.57,141.63)
VMA_DQ36: length 20.3
  TOP w0.152: VRAM3001.E4 177.69,157.79 v3(177.69,157.79)
  IN1 w0.114: v1(176.42,143.37) 176.93,143.88 176.93,149.34 181.17,153.58 181.17,156.57 180.35,157.39 178.09,157.39 v3(177.69,157.79)
  BOTTOM w0.152: v1(176.42,143.37) 176.42,143.34 U3002.AD30
VMA_DQ37: length 21.3
  TOP w0.152: v3(179.29,157.79) VRAM3001.E2
  IN1 w0.114: v1(176.46,142.51) 176.98,143.03 176.98,143.13 177.28,143.44 177.28,145.23 178.12,146.07 178.36,146.07 178.91,146.61 178.91,148.19 178.24,148.86 178.24,150.2 181.49,153.45 181.49,157.04 180.34,158.19 179.69,158.19 v3(179.29,157.79)
  BOTTOM w0.152: U3002.AD29 176.46,142.46 v1(176.46,142.51)
VMA_DQ38: length 23.7
  TOP w0.152: v3(177.69,159.39) VRAM3001.F4
  IN1 w0.114: v1(178.01,142.49) 178.48,142.96 178.48,144.53 180.27,146.32 180.27,147.34 181.54,148.61 181.54,151.53 182.12,152.12 182.12,158.06 180.39,159.79 178.09,159.79 v3(177.69,159.39)
  BOTTOM w0.152: v1(178.01,142.49) 177.63,142.11 U3002.AC29
VMA_DQ39: length 22.8
  TOP w0.152: v3(179.29,158.59) VRAM3001.F2
  IN1 w0.114: v3(179.29,158.59) 179.69,158.99 180.43,158.99 181.81,157.61 181.81,153.09 180.27,151.56 180.27,149.63 179.76,149.12 179.76,146.83 178.49,145.56 178.06,145.56 177.64,145.13 177.64,143.25 177.41,143.02 177.41,142.61 v1(176.43,141.62)
  BOTTOM w0.152: U3002.AD28 176.44,141.62 v1(176.43,141.62)
VMA_DQ40: length 15.3
  IN1 w0.114: v1(172.97,141.63) 172.59,142 172.59,145.42 172.19,145.82 172.19,155.26 v3(172.09,155.37)
  BOTTOM w0.152: v1(172.97,141.63) 172.97,141.7 U3002.AJ29 ; v3(172.09,155.37) 172.07,155.37 VRAM3005.U11
VMA_DQ41: length 14.3
  IN1 w0.114: v1(171.34,142.46) 171.34,142.74 171.8,143.2 171.8,143.66 171.55,143.9 171.55,145.11 170.49,146.17 170.49,153.84 v3(169.74,154.59)
  BOTTOM w0.152: U3002.AK29 171.34,142.42 v1(171.34,142.46) ; v3(169.74,154.59) 169.74,154.64 VRAM3005.U13
VMA_DQ42: length 14.6
  IN1 w0.114: v1(172.18,142.49) 172.29,142.6 172.29,144.04 172.19,144.14 172.19,145.38 171.84,145.72 171.84,154.84 v3(171.29,155.39)
  BOTTOM w0.152: U3002.AJ30 172.63,142.94 v1(172.18,142.49) ; VRAM3005.T11 v3(171.29,155.39)
VMA_DQ43: length 16.1
  IN1 w0.114: v1(172.13,141.6) 171.77,141.96 171.77,142.77 172.03,143.03 172.03,143.85 171.87,144.01 171.87,145.25 171.47,145.64 171.47,153.66 v3(169.74,155.39)
  BOTTOM w0.152: v1(172.13,141.6) 171.73,141.19 U3002.AK28 ; v3(169.74,155.39) 169.74,155.44 VRAM3005.T13
VMA_DQ44: length 21.3
  IN1 w0.114: v3(172.09,157.79) 171.69,157.39 169.09,157.39 169.08,157.38 168.71,157.38 167.63,156.3 167.63,151.33 168.32,150.64 168.32,146.97 169.09,146.2 169.09,145.4 170.18,144.32 170.18,142.87 v1(169.75,142.44)
  BOTTOM w0.152: U3002.AM29 169.75,142.42 v1(169.75,142.44) ; VRAM3005.N11 171.69,158.19 v3(172.09,157.79)
VMA_DQ45: length 18.4
  IN1 w0.114: v3(169.74,157.79) 169.31,158.21 168.72,158.21 168.31,157.8 168.31,157.43 167.32,156.43 167.32,151.07 168,150.39 168,145.23 168.58,144.65 169.21,144.65 v1(169.74,144.11)
  BOTTOM w0.152: VRAM3005.N13 169.74,157.84 v3(169.74,157.79) ; U3002.AM31 170.13,143.73 v1(169.74,144.11)
VMA_DQ46: length 23.1
  IN1 w0.114: v3(172.09,158.59) VRAM3005.M11 169.25,158.99 169.17,158.91 168.47,158.91 167.44,157.88 167.44,157.46 166.68,156.7 166.68,150.77 167.32,150.13 167.32,144.05 v1(168.92,142.44)
  BOTTOM w0.152: VRAM3005.M11 171.69,158.99 v3(172.09,158.59) ; U3002.AN29 v1(168.92,142.44)
VMA_DQ47: length 21.8
  IN1 w0.114: v1(170.52,142.44) 170.09,142.01 169.57,142.01 169.34,142.24 169.34,143.42 168.74,144.01 168.58,144.01 167.68,144.91 167.68,150.26 167,150.94 167,156.56 167.86,157.42 167.86,157.85 168.6,158.59 v3(169.74,158.59)
  BOTTOM w0.152: U3002.AM30 170.52,142.45 v1(170.52,142.44) ; v3(169.74,158.59) 169.74,158.64 VRAM3005.M13
VMA_DQ48: length 33.6
  TOP w0.152: v3(171.48,168.32) 171.69,168.11 VRAM3001.U11
  IN3 w0.114: v3(171.48,168.32) 170.69,169.11 168.26,169.11 164.8,165.65 164.8,155.41 165.21,155 165.21,146.91 v1(166.3,145.82)
  BOTTOM w0.152: v1(166.3,145.82) 166.3,145.43 167.92,143.81 169.2,143.81 U3002.AN31
VMA_DQ49: length 29.7
  TOP w0.152: v3(169.68,168.3) 169.68,168.2 VRAM3001.U13
  IN3 w0.114: v3(169.68,168.3) 168.46,168.3 165.51,165.35 165.51,155.7 165.92,155.3 165.92,147.82 v1(166.78,146.96)
  BOTTOM w0.152: v1(166.78,146.96) 166.93,146.81 166.93,145.4 168.2,144.14 168.93,144.14 U3002.AN32
VMA_DQ50: length 33.2
  TOP w0.152: VRAM3001.T11 171.3,167.38 v3(171.26,167.38)
  IN3 w0.114: v3(171.26,167.38) 170.97,167.67 170.97,168.32 170.54,168.76 168.42,168.76 165.16,165.5 165.16,155.55 165.56,155.15 165.56,147.31 v1(165.79,147.09)
  BOTTOM w0.152: U3002.AP30 168.26,142.84 165.79,145.31 v1(165.79,147.09)
VMA_DQ51: length 27
  TOP w0.152: v3(169.69,167.39) VRAM3001.T13
  IN3 w0.114: v3(169.69,167.39) 169.63,167.45 168.24,167.45 167.95,167.15 167.95,167.15 165.87,165.07 165.87,155.85 166.27,155.44 166.27,148.79 v1(166.81,148.25)
  BOTTOM w0.152: v1(166.81,148.25) 167.44,147.62 167.44,145.63 U3002.AP32
VMA_DQ52: length 23.9
  TOP w0.152: v1(171.29,164.99) 171.29,164.99 VRAM3001.N11
  IN3 w0.114: v1(169.09,149.63) 168.1,150.62 168.1,163.62 168.46,163.98 169.09,163.98 169.68,164.56 170.86,164.56 v1(171.29,164.99)
  BOTTOM w0.102: 170.52,146.83 170.52,146.66 170.67,146.5 170.67,145.87 170.14,145.34 U3002.AM33
  BOTTOM w0.152: 170.52,146.83 170.52,148.23 169.12,149.63 v1(169.09,149.63)
VMA_DQ53: length 25.7
  TOP w0.152: v3(169.67,164.99) 169.68,164.99 VRAM3001.N13
  IN3 w0.114: v1(169.09,148.36) 168.59,148.86 168.59,149.63 167.75,150.47 167.75,163.77 168.08,164.1 168.08,164.61 168.31,164.84 169.35,164.84 169.5,164.99 v3(169.67,164.99)
  BOTTOM w0.102: U3002.AL31 170.8,143.74 170.56,143.99 170.56,144.67 170.3,144.93 169.98,144.93 169.74,145.17 169.74,145.45 170.05,145.76 170.27,145.76 170.47,145.95 170.47,146.33 170.19,146.61 170.19,146.83
  BOTTOM w0.152: 170.19,146.83 170.19,147.26 v1(169.09,148.36)
VMA_DQ54: length 22.9
  TOP w0.152: v3(172.07,163.4) 172.07,163.41 VRAM3001.M11
  IN3 w0.114: v3(172.07,163.4) 171.65,163.82 170.31,163.82 170.09,163.61 170.09,161.4 169.32,160.62 169.32,153.39 169.49,153.22 169.49,150.68 v1(169.09,150.29)
  BOTTOM w0.102: 171.43,147.09 171.46,147.06 171.46,146.58 171.28,146.4 171.28,145.88 171.82,145.34 U3002.AK33
  BOTTOM w0.152: v1(169.09,150.29) 171,148.38 171,147.52 171.43,147.09
VMA_DQ55: length 26.7
  TOP w0.152: v3(172.1,164.18) 170.48,164.18 VRAM3001.M13
  IN3 w0.114: v1(168.97,151.58) 168.46,152.09 168.46,160.8 169.22,161.56 169.22,163.6 169.81,164.18 v3(172.1,164.18)
  BOTTOM w0.102: 171.7,147.09 171.7,146.53 171.48,146.32 171.48,145.96 171.7,145.75 171.97,145.75 172.21,145.51 172.21,144.92 U3002.AK32
  BOTTOM w0.152: v1(168.97,151.58) 171.51,149.04 171.51,147.72 171.7,147.53 171.7,147.09
VMA_DQ56: length 32.7
  BOTTOM w0.152: VRAM3005.A4 177.29,168.15 177.98,168.84 181.02,168.84 182.04,167.83 v1(182.08,167.83) 182.1,167.83 183.95,165.97 183.95,154.08 180.72,150.85 178.39,150.85 176.79,149.25 176.79,148.1 176.92,147.98 176.92,146.23 U3002.AD34
VMA_DQ57: length 31
  BOTTOM w0.102: U3002.AD32 176.4,144.97 176.4,145.46 176.25,145.61 176.25,146.5 176.37,146.63 176.37,147.16 175.94,147.59
  BOTTOM w0.152: 175.94,147.59 175.93,147.6 175.93,149.61 177.39,151.07 178.03,151.71 180.36,151.71 183.09,154.44 183.09,165.47 v1(182.04,166.52) 181.02,167.54 179.94,167.54 179.83,167.42 179.26,167.42 VRAM3005.A2
VMA_DQ58: length 38.5
  BOTTOM w0.152: U3002.AC30 177.22,143.34 177.22,146.32 177.17,146.37 177.17,148.31 177.35,148.48 177.35,149.17 178.59,150.41 180.9,150.41 184.38,153.9 184.38,166.22 v1(183.92,166.68) 181.32,169.29 177.82,169.29 176.89,168.36 176.89,167.38 VRAM3005.B4
VMA_DQ59: length 32.4
  BOTTOM w0.102: U3002.AD33 176.46,145.71 176.46,146.4 176.62,146.56 176.62,146.96
  BOTTOM w0.152: 176.62,146.96 176.62,147.58 176.36,147.85 176.36,149.43 177.44,150.51 178.21,151.28 180.54,151.28 183.52,154.26 183.52,165.69 180.82,168.4 178.97,168.4 178.52,167.94 178.52,167.36 VRAM3005.B2
VMA_DQ60: length 33.9
  BOTTOM w0.102: U3002.AF31 174.73,144.14 174.73,144.67 175.01,144.95 175.27,144.95 175.52,145.2 175.52,145.71 175.71,145.9 175.71,146.38 175.58,146.51 175.58,146.51 175.5,146.6 175.5,147.09
  BOTTOM w0.152: VRAM3005.E4 177.69,165 178.2,165 178.46,165.25 178.46,166.27 178.8,166.61 179.96,166.61 180.05,166.7 180.93,166.7 v1(182.38,165.24) 182.66,164.97 182.66,154.62 180.18,152.14 177.85,152.14 175.5,149.79 175.5,147.09
VMA_DQ61: length 25.1
  BOTTOM w0.152: 175.06,151.83 174,150.76 174,148.12 174.53,147.59 174.53,146.34 U3002.AG34 ; 175.06,151.83 v1(175.06,151.84) ; 175.06,151.83 176.87,153.64 179.56,153.64 181.16,155.24 181.16,163.79 180.8,164.15 179.33,164.15 VRAM3005.E2
VMA_DQ62: length 22.3
  BOTTOM w0.152: U3002.AG32 173.94,144.92 173.94,145.43 173.69,145.68 173.69,146.46 173.92,146.69 173.92,147.17 173.12,147.97 173.12,151.24 175.34,153.46 v1(175.34,153.76) 175.34,162.22 175.7,162.58 176.71,162.58 176.92,162.79 176.92,163.42 VRAM3005.F4
VMA_DQ63: length 25
  BOTTOM w0.152: U3002.AG33 174.33,145.55 173.94,145.93 173.94,146.34 174.2,146.59 174.2,147.3 173.55,147.95 173.55,151.04 176.59,154.07 179.38,154.07 180.73,155.42 180.73,163.11 180.54,163.29 180.02,163.29 179.93,163.38 179.29,163.38 VRAM3005.F2
VMA_WCK01: length 19.3
  TOP w0.127: v3(192.13,157.01) 192.13,157.02 VRAM3004.P4
  IN1 w0.089: v3(192.13,157.01) 192.13,157.34 192.21,157.42 192.76,157.42 193.35,156.83 193.35,153.19 188.51,148.35 188.51,143.87 188.37,143.73 188.19,143.73 188.07,143.86 v1(188.07,144.11)
  BOTTOM w0.127: U3002.K31 188.1,144.11 v1(188.07,144.11) ; VRAM3004.P4 192.13,157.02 v3(192.13,157.01)
VMA_WCK01#: length 19.4
  TOP w0.127: VRAM3004.P5 192.53,157.42 v3(192.13,157.81)
  IN1 w0.089: v1(188.07,143.35) 188.29,143.57 188.44,143.57 188.68,143.81 188.68,148.28 193.52,153.12 193.52,156.9 192.83,157.59 192.35,157.59 v3(192.13,157.81)
  BOTTOM w0.127: VRAM3004.P5 192.53,157.42 v3(192.13,157.81) ; v1(188.07,143.35) 188.04,143.35 U3002.L30
VMA_WCK23: length 25.7
  TOP w0.127: v3(192.13,165.78) 192.09,165.78 VRAM3004.D4
  BOTTOM w0.127: VRAM3004.D4 192.09,165.78 v3(192.13,165.78) 192.82,165.78 192.84,165.75 193.86,165.75 195.64,163.98 195.64,154.38 189.87,148.61 189.87,146.4 U3002.H34
VMA_WCK23#: length 25.7
  TOP w0.127: v3(192.13,164.99) 192.13,165.02 VRAM3004.D5
  BOTTOM w0.127: VRAM3004.D5 192.13,165.02 v3(192.13,164.99) 192.74,164.99 193.29,165.54 193.77,165.54 195.42,163.89 195.42,154.47 189.65,148.7 189.65,146.31 189.48,146.14 U3002.J34
VMA_WCK45: length 19.6
  TOP w0.127: VRAM3001.D4 176.89,157.79 v3(176.89,157.79)
  IN1 w0.089: v3(176.89,157.79) 176.67,157.57 176.12,157.57 172.87,154.32 172.87,146.33 173.22,145.98 173.22,143.02 173.54,142.7 173.69,142.7 v1(173.91,142.49)
  BOTTOM w0.127: VRAM3001.D4 176.89,157.79 v3(176.89,157.79) ; v1(173.91,142.49) 173.91,142.52 U3002.AG30
VMA_WCK45#: length 19.5
  TOP w0.127: v3(176.89,156.99) VRAM3001.D5
  IN1 w0.089: v1(173.92,143.33) 173.92,143.02 173.77,142.87 173.6,142.87 173.39,143.09 173.39,146.04 173.03,146.4 173.03,154.25 176.18,157.4 176.77,157.4 176.89,157.29 v3(176.89,156.99)
  BOTTOM w0.127: U3002.AG31 173.92,143.33 v1(173.92,143.33) ; v3(176.89,156.99) VRAM3001.D5
VMA_WCK67: length 23.7
  TOP w0.127: v1(176.89,164.99) VRAM3001.P4
  BOTTOM w0.127: U3002.AJ34 172.4,146.37 172.4,152.29 174.66,154.55 174.66,164.66 175.57,165.57 175.83,165.57 175.98,165.42 175.98,165.15 176.13,164.99 v1(176.89,164.99) VRAM3001.P4
VMA_WCK67#: length 23.7
  TOP w0.127: v1(176.89,165.79) VRAM3001.P5
  BOTTOM w0.127: VRAM3001.P5 v1(176.89,165.79) 175.48,165.79 174.44,164.75 174.44,154.64 172.18,152.38 172.18,146.49 U3002.AK34
VMB_CLK0: length 34.8
  TOP w0.127: VRAM3007.J12 212.61,119.21 v3(212.59,119.21) ; R11094.1 v1(211.76,114.34)
  IN3 w0.089: v1(211.76,114.34) 212.11,114.69 212.11,115.79 212.71,116.38 212.71,117.77 213,118.06 213,118.8 v3(212.59,119.21) 212.92,119.21 213.01,119.3 213.01,119.5 212.78,119.72 212.78,120.59 211.83,121.55 202.58,121.55 194.56,129.56 193.63,129.56 192.72,128.65 192.72,128.39 192.84,128.27 v1(193.15,128.27)
  BOTTOM w0.127: v3(212.59,119.21) 212.61,119.21 VRAM3007.J12 ; v1(193.15,128.27) 193.15,128.22 U3002.D12
VMB_CLK0#: length 34.7
  TOP w0.127: v3(213.39,119.21) 213.39,119.23 VRAM3007.J11 ; R11094.2 v1(212.54,114.34)
  IN3 w0.089: v1(212.54,114.34) 212.27,114.6 212.27,115.72 212.87,116.31 212.87,117.7 213.16,117.99 213.16,118.98 v3(213.39,119.21) 213.17,119.42 213.17,119.57 212.95,119.79 212.95,120.66 211.9,121.71 202.65,121.71 194.63,129.72 193.56,129.72 192.55,128.71 192.55,128.49 v3(192.33,128.27)
  BOTTOM w0.127: VRAM3007.J11 213.39,119.23 v3(213.39,119.21) ; U3002.E12 192.33,128.23 v3(192.33,128.27)
VMB_CLK1: length 38.6
  TOP w0.127: VRAM3002.J12 212.6,145.76 v3(212.6,145.76) ; v1(212.01,150.59) R11098.1
  IN1 w0.089: v3(212.6,145.76) 212.78,145.94 212.78,149.14 212.44,149.49 212.44,150.16 v1(212.01,150.59)
  IN3 w0.089: v3(212.6,145.76) 212.75,145.76 212.91,145.92 212.91,146.28 212.65,146.53 212.65,147.36 212.4,147.61 212.4,148.21 211.86,148.75 205.81,148.75 197.41,140.35 196.78,140.35 195.26,138.83 195.26,138.15 194.52,137.42 194.52,135.49 193.65,134.63 192.6,134.63 192.31,134.34 v3(192.31,134.19)
  BOTTOM w0.127: v3(212.6,145.76) 212.6,145.76 VRAM3002.J12 ; v3(192.31,134.19) 192.38,134.19 U3002.E20
VMB_CLK1#: length 38.6
  TOP w0.127: R11098.2 v1(212.79,150.59) ; v3(213.4,145.76) VRAM3002.J11
  IN1 w0.089: v3(213.4,145.76) 212.95,146.22 212.95,149.21 212.6,149.55 212.6,150.4 v1(212.79,150.59)
  IN3 w0.089: v1(192.3,134.92) 192.43,134.79 193.59,134.79 194.35,135.56 194.35,137.48 195.09,138.22 195.09,138.9 196.71,140.52 197.35,140.52 205.74,148.91 211.93,148.91 212.57,148.28 212.57,147.68 212.82,147.43 212.82,146.6 213.07,146.35 213.07,146.09 v3(213.4,145.76)
  BOTTOM w0.127: v1(192.3,134.92) 192.26,134.92 U3002.F20 ; v3(213.4,145.76) VRAM3002.J11
VMB_DQ0: length 16
  IN1 w0.114: v3(191.45,124.92) 191.55,125.03 204.33,125.03 204.53,124.83 v3(206.21,124.83)
  BOTTOM w0.152: U3002.G9 v3(191.45,124.92) ; v3(206.21,124.83) 206.21,124.86 VRAM3003.A4
VMB_DQ1: length 14.8
  IN1 w0.114: v3(206.18,126.43) 204.58,126.43 204.02,125.88 194.37,125.88 194.06,126.18 193.5,126.18 v1(193.1,125.78)
  BOTTOM w0.152: U3002.E9 193.1,125.71 v1(193.1,125.78) ; v3(206.18,126.43) 206.18,126.43 VRAM3003.A2
VMB_DQ2: length 17.3
  IN1 w0.114: v3(206.97,124.83) 206.56,124.43 204.02,124.43 203.74,124.71 192.03,124.71 v1(191.42,124.1)
  BOTTOM w0.152: v3(206.97,124.83) 206.98,124.83 VRAM3003.B4 ; U3002.G8 191.42,124.15 v1(191.42,124.1)
VMB_DQ3: length 17.4
  IN1 w0.114: v1(191.48,125.83) 191.96,125.35 204,125.35 204.68,126.03 206.59,126.03 v3(206.99,126.43)
  BOTTOM w0.152: v1(191.48,125.83) 191.48,125.74 U3002.F9 ; v3(206.99,126.43) 206.99,126.44 VRAM3003.B2
VMB_DQ4: length 20.1
  IN1 w0.114: v3(209.36,125.63) 209.23,125.77 209.23,126.54 207.97,127.79 203.91,127.79 203.52,127.4 193.14,127.4 v3(192.35,126.62)
  BOTTOM w0.152: v3(192.35,126.62) 192.3,126.62 U3002.F11 ; VRAM3003.E4 209.39,125.63 v3(209.36,125.63)
VMB_DQ5: length 25.7
  IN1 w0.114: v3(191.52,126.59) 191.05,127.07 191.05,129.24 191.32,129.52 191.78,129.52 191.83,129.57 192.72,129.57 193.1,129.94 199.45,129.94 200.36,129.03 203.36,129.03 203.71,129.38 209.28,129.38 210.27,128.39 210.27,127.32 v3(210.2,127.25)
  BOTTOM w0.152: U3002.G11 191.48,126.59 v3(191.52,126.59) ; v3(210.2,127.25) VRAM3003.E2
VMB_DQ6: length 21.4
  IN1 w0.114: v3(210.16,125.63) 209.61,126.19 209.61,126.61 208.59,127.62 208.59,128.31 208.31,128.59 204.26,128.59 203.45,127.78 192.69,127.78 v3(192.33,127.43)
  BOTTOM w0.152: U3002.F12 192.29,127.43 v3(192.33,127.43) ; VRAM3003.F4 210.19,125.63 v3(210.16,125.63)
VMB_DQ7: length 24
  IN1 w0.114: v3(211.02,127.25) 210.61,126.84 210.04,126.84 209.43,127.45 209.43,128.33 208.76,129 203.97,129 203.64,128.67 198.68,128.67 197.86,129.49 193.46,129.49 192.64,128.67 192.13,128.67 191.88,128.42 191.88,128.06 191.47,127.66 v1(191.47,127.43)
  BOTTOM w0.152: v3(211.02,127.25) 211,127.25 VRAM3003.F2 ; U3002.G12 191.44,127.43 v1(191.47,127.43)
VMB_DQ8: length 19.9
  TOP w0.152: VRAM3007.U11 v3(206.17,119.22)
  IN3 w0.114: v1(190.53,123.16) 190.85,123.48 191.46,123.48 191.88,123.9 191.88,124.33 192.16,124.61 193.35,124.61 194.14,123.82 197.19,123.82 201.79,119.22 v3(206.17,119.22)
  BOTTOM w0.152: v1(190.53,123.16) 190.61,123.16 U3002.G6
VMB_DQ9: length 17.6
  TOP w0.152: v3(206.17,117.62) VRAM3007.U13
  IN3 w0.114: v1(192.33,122.37) 193.27,122.37 193.81,122.91 194.87,122.91 196.27,121.51 196.27,121.3 199.61,117.97 205.07,117.97 205.42,117.62 v3(206.17,117.62)
  BOTTOM w0.152: v1(192.33,122.37) 192.26,122.37 U3002.F5
VMB_DQ10: length 17
  TOP w0.152: VRAM3007.T11 v3(206.97,119.22)
  IN3 w0.114: v1(197.26,122.88) 197.62,122.88 201.68,118.82 206.57,118.82 v3(206.97,119.22)
  BOTTOM w0.152: U3002.E6 193.1,123.21 196.12,123.21 196.45,122.88 v1(197.26,122.88)
VMB_DQ11: length 19.4
  TOP w0.152: v3(206.97,117.59) 206.97,117.62 VRAM3007.T13
  IN3 w0.114: v1(191.46,122.38) 191.9,121.93 194.22,121.93 194.3,122.01 194.96,122.01 195.26,121.71 195.26,121.08 195.67,120.67 196.27,120.67 199.48,117.46 205.02,117.46 205.26,117.22 206.59,117.22 v3(206.97,117.59)
  BOTTOM w0.152: U3002.F6 v1(191.46,122.38)
VMB_DQ12: length 24.2
  TOP w0.152: VRAM3007.N11 v3(209.37,119.22)
  IN3 w0.114: v3(209.37,119.22) 208.95,118.81 208.39,118.81 208.19,118.6 208.19,118.25 207.96,118.02 205.67,118.02 205.67,118.02 205.52,118.02 205.15,118.38 199.69,118.38 196.65,121.42 196.65,121.81 195.2,123.26 193.66,123.26 193.23,122.83 191.19,122.83 190.96,122.6 190.96,122 v1(191.42,121.55)
  BOTTOM w0.152: v1(191.42,121.55) U3002.F4
VMB_DQ13: length 24.7
  TOP w0.152: VRAM3007.N13 v3(209.37,117.62)
  IN3 w0.114: v1(191.39,120.71) 192.17,120.71 192.63,120.24 192.63,118.71 194.49,116.86 197.43,116.86 198.65,115.63 204.26,115.63 204.81,115.08 208.01,115.08 208.9,115.97 209.23,115.97 209.77,116.51 209.77,117.22 v3(209.37,117.62)
  BOTTOM w0.152: v1(191.39,120.71) 191.39,120.73 U3002.G4
VMB_DQ14: length 22.7
  TOP w0.152: VRAM3007.M11 v3(210.17,119.22)
  IN3 w0.114: v1(193.07,119.15) 193.07,118.79 194.65,117.22 197.57,117.22 198.8,115.99 204.41,115.99 204.96,115.44 207.87,115.44 208.97,116.54 208.97,117.8 209.19,118.03 209.57,118.03 209.78,118.25 209.78,118.84 v3(210.17,119.22)
  BOTTOM w0.152: v1(193.07,119.15) 193.02,119.15 U3002.E2
VMB_DQ15: length 24.5
  TOP w0.152: VRAM3007.M13 v3(210.17,117.62)
  IN3 w0.114: v1(192.2,119.94) 192.2,118.64 194.37,116.48 197.3,116.48 198.51,115.28 204.11,115.28 204.66,114.73 208.16,114.73 209.05,115.62 209.63,115.62 210.62,116.61 210.62,117.16 v3(210.17,117.62)
  BOTTOM w0.152: v1(192.2,119.94) 192.2,119.96 U3002.F3
VMB_DQ16: length 28
  IN1 w0.114: v3(219,120.03) 219,120.08 218.52,120.57 218.52,121.05 217.25,122.32 205.02,122.32 204.01,121.3 v1(198.43,121.3)
  BOTTOM w0.152: VRAM3003.U11 219,120.02 v3(219,120.03) ; U3002.C2 194.35,119.54 194.75,119.15 196.27,119.15 v1(198.43,121.3)
VMB_DQ17: length 30.5
  IN1 w0.114: v1(193.88,120.72) 194.29,120.31 194.29,119.48 195.79,117.98 202.28,117.98 205.18,115.08 217.1,115.08 218.59,116.57 218.59,117.24 v3(218.97,117.62)
  BOTTOM w0.152: VRAM3003.U13 v3(218.97,117.62) ; U3002.D4 193.88,120.79 v1(193.88,120.72)
VMB_DQ18: length 32.9
  IN1 w0.114: v3(219,119.27) 219.51,118.76 219.51,116.61 217.67,114.76 205.05,114.76 202.15,117.66 195.66,117.66 193.88,119.44 v1(193.88,119.94)
  BOTTOM w0.152: v3(219,119.27) 218.95,119.27 VRAM3003.T11 ; U3002.D3 v1(193.88,119.94)
VMB_DQ19: length 27.6
  IN1 w0.114: v3(218.17,117.62) 217.79,117.24 217.79,116.53 216.66,115.4 205.31,115.4 202.41,118.29 196.77,118.29 v1(196.4,118.66)
  BOTTOM w0.152: v1(196.4,118.66) 196.4,118.64 195.92,118.16 194.91,118.16 U3002.C1 ; VRAM3003.T13 v3(218.17,117.62)
VMB_DQ20: length 25.5
  IN1 w0.114: v3(216.6,120.05) 217,120.45 217,121.19 216.19,122 205.6,122 204.27,120.67 198.05,120.67 v1(197.16,121.56)
  BOTTOM w0.152: v1(197.16,121.56) 196.35,120.75 195.53,120.75 U3002.B3 ; VRAM3003.N11 v3(216.6,120.05)
VMB_DQ21: length 26.9
  IN1 w0.114: v1(194.72,121.57) 194.89,121.74 196.23,121.74 197.61,120.35 204.4,120.35 205.74,121.69 215.67,121.69 216.2,121.16 216.2,118.85 v3(216.6,118.45)
  BOTTOM w0.152: VRAM3003.N13 v3(216.6,118.45) ; v1(194.72,121.57) 194.71,121.57 U3002.C4
VMB_DQ22: length 25.5
  IN1 w0.114: v3(215.8,120.05) 215.38,120.47 214.83,120.47 213.92,121.37 205.87,121.37 204.53,120.03 197.48,120.03 196.66,120.86 194.83,120.86 194.29,121.4 194.29,122 v1(194.73,122.44)
  BOTTOM w0.152: VRAM3003.M11 v3(215.8,120.05) ; U3002.B5 v1(194.73,122.44)
VMB_DQ23: length 25.9
  IN1 w0.114: v1(193.93,122.41) 193.93,121.29 194.67,120.54 196.53,120.54 197.36,119.7 204.65,119.7 205.41,120.47 214.32,120.47 214.59,120.2 214.59,118.83 v3(214.97,118.45)
  BOTTOM w0.152: v1(193.93,122.41) 193.95,122.41 U3002.C5 ; VRAM3003.M13 v3(214.97,118.45)
VMB_DQ24: length 30.7
  TOP w0.152: v3(219.9,125.75) VRAM3007.A4
  BOTTOM w0.152: U3002.A11 197.77,127.04 198.16,127.43 201.93,127.43 205.21,130.7 217.48,130.7 218.85,129.33 v1(219.64,129.33) 220.43,128.54 220.43,126.28 v3(219.9,125.75)
VMB_DQ25: length 29.8
  TOP w0.152: v3(219.77,127.22) VRAM3007.A2
  BOTTOM w0.152: v3(219.77,127.22) 220,127.45 220,128.34 219.54,128.8 217.38,128.8 v1(216.91,129.27) 216.34,129.84 205.57,129.84 202.29,126.56 198.1,126.56 197.9,126.36 195.65,126.36 195.41,126.6 194.76,126.6 U3002.C11
VMB_DQ26: length 32.6
  TOP w0.152: VRAM3007.B4 218.62,125.24 219,125.62 219,127.91 219.08,127.99 219.08,129.36 218.37,130.07 v1(218.37,130.58)
  BOTTOM w0.152: U3002.D11 193.94,127.46 197.72,127.46 198.13,127.86 201.75,127.86 205.03,131.13 217.81,131.13 v1(218.37,130.58)
VMB_DQ27: length 27.8
  TOP w0.152: v1(218.22,129.28) 218.22,127.2 VRAM3007.B2
  BOTTOM w0.152: v1(218.22,129.28) 218.22,129.31 217.25,130.27 205.39,130.27 202.11,126.99 198.15,126.99 197.82,126.66 195.71,126.66 195.33,127.04 U3002.B11
VMB_DQ28: length 26
  TOP w0.152: VRAM3007.E4 216.18,124.96 215.78,124.56 v1(215.78,122.83)
  BOTTOM w0.152: v1(215.78,122.83) 215.21,122.26 204.88,122.26 203.78,123.35 v1(199.87,123.35) 197.65,123.35 197.11,123.9 195.53,123.9 195.3,124.13 193.94,124.13 U3002.D8
VMB_DQ29: length 23.9
  TOP w0.152: VRAM3007.E2 215.75,126.41 215.75,125.04 215.58,124.86 215.19,124.86 214.94,124.61 214.94,124.2 214.69,123.95 v1(214.69,123.18)
  BOTTOM w0.152: v1(214.69,123.18) 214.62,123.12 205.24,123.12 203.82,124.54 U3002.A8
VMB_DQ30: length 23.7
  TOP w0.152: v3(214.97,125.62) 215.35,125.24 VRAM3007.F4
  BOTTOM w0.152: U3002.C8 194.73,124.94 196.65,124.94 196.69,124.97 v1(204,124.97) 205.42,123.55 214.39,123.55 214.69,123.84 214.69,123.97 214.97,124.25 v3(214.97,125.62)
VMB_DQ31: length 25.9
  TOP w0.152: v3(215.78,127.2) 215.74,127.2 VRAM3007.F2
  BOTTOM w0.152: v3(215.78,127.2) 215.75,127.17 215.75,123.59 214.85,122.69 205.06,122.69 203.64,124.11 197.58,124.11 197.54,124.15 195.71,124.15 195.32,124.54 U3002.B8
VMB_DQ32: length 16.4
  TOP w0.152: v3(206.2,140.16) 206.2,140.15 VRAM3002.A4
  IN1 w0.114: v1(192.36,138.28) 192.82,137.81 193.09,137.81 193.34,137.56 194.29,137.56 194.83,138.09 202.39,138.09 204.46,140.16 v3(206.2,140.16)
  BOTTOM w0.152: U3002.F24 192.31,138.28 v1(192.36,138.28)
VMB_DQ33: length 16.3
  TOP w0.152: v3(206.2,137.76) VRAM3002.A2
  IN1 w0.114: v3(206.2,137.76) 205.9,137.46 195.09,137.46 194.71,137.08 191.81,137.08 v3(191.47,137.41)
  BOTTOM w0.152: U3002.G23 191.4,137.41 v3(191.47,137.41)
VMB_DQ34: length 17.3
  TOP w0.152: v3(207,139.36) VRAM3002.B4
  IN1 w0.114: v3(207,139.36) 206.6,139.76 206.6,140.48 206.39,140.7 204.49,140.7 202.2,138.41 194.7,138.41 194.13,137.84 193.51,137.84 v3(193.12,138.22)
  BOTTOM w0.152: U3002.E24 193.11,138.22 v3(193.12,138.22)
VMB_DQ35: length 17.6
  TOP w0.152: v3(207,138.56) 207,138.55 VRAM3002.B2
  IN1 w0.114: v3(207,138.56) 203.76,138.56 202.98,137.78 194.96,137.78 194.52,137.33 193.12,137.33 193.02,137.43 192.32,137.43 v3(191.47,138.28)
  BOTTOM w0.152: U3002.G24 191.46,138.28 v3(191.47,138.28)
VMB_DQ36: length 19.7
  TOP w0.152: v3(209.4,139.36) VRAM3002.E4
  IN1 w0.114: v3(209.4,139.36) 209,138.96 209,136.26 208.48,135.74 v1(193.91,135.74)
  BOTTOM w0.152: v1(193.91,135.74) 193.91,135.72 U3002.D21
VMB_DQ37: length 20
  TOP w0.152: v3(209.4,137.76) VRAM3002.E2
  IN1 w0.114: v3(193.15,135.74) 193.61,135.27 194.48,135.27 194.62,135.42 208.86,135.42 209.8,136.36 209.8,137.36 v3(209.4,137.76)
  BOTTOM w0.152: U3002.E21 193.12,135.74 v3(193.15,135.74)
VMB_DQ38: length 25.4
  TOP w0.152: v3(210.99,139.36) VRAM3002.F4
  IN1 w0.114: v3(191.47,135.79) 191.91,135.35 192.47,135.35 193.18,134.64 194.74,134.64 194.88,134.78 209.62,134.78 211.4,136.56 211.4,138.21 210.99,138.62 v3(210.99,139.36)
  BOTTOM w0.152: U3002.G21 v3(191.47,135.79)
VMB_DQ39: length 21.8
  TOP w0.152: VRAM3002.F2 210.2,137.76 v3(210.2,137.76)
  IN1 w0.114: v3(192.29,135.75) 192.52,135.75 193.32,134.96 194.61,134.96 194.75,135.1 209.05,135.1 210.6,136.65 210.6,137.36 v3(210.2,137.76)
  BOTTOM w0.152: U3002.F21 v3(192.29,135.75)
VMB_DQ40: length 18.6
  IN1 w0.114: v3(206.2,145.76) 202.13,145.76 196.77,140.41 194.61,140.41 194.23,140.02 192.22,140.02 v3(191.47,140.76)
  BOTTOM w0.152: v3(191.47,140.76) 191.05,140.34 U3002.G27 ; v3(206.2,145.76) 206.2,145.75 VRAM3006.U11
VMB_DQ41: length 16.2
  IN1 w0.114: v1(193.91,140.76) 194.19,141.04 195.4,141.04 196.49,142.13 197.41,142.13 202.64,147.36 v3(206.2,147.36)
  BOTTOM w0.152: v1(193.91,140.76) 193.91,140.72 U3002.D27 ; v3(206.2,147.36) 206.2,147.35 206.6,146.96 VRAM3006.U13
VMB_DQ42: length 19.7
  IN1 w0.114: v1(191.41,139.13) 191.74,139.13 192.32,139.7 194.36,139.7 194.74,140.09 196.96,140.09 200.99,144.12 v3(207.03,144.12)
  BOTTOM w0.152: v3(207.03,144.12) 207.03,144.99 VRAM3006.T11 ; U3002.G26 191.42,139.15 191.41,139.14 v1(191.41,139.13)
VMB_DQ43: length 18.1
  IN1 w0.114: v3(207,147.36) 206.34,146.7 202.44,146.7 197.48,141.75 196.61,141.75 195.59,140.72 194.48,140.72 194.1,140.34 193.58,140.34 v3(193.15,140.76)
  BOTTOM w0.152: v3(193.15,140.76) 193.15,140.76 U3002.E27 ; v3(207,147.36) 207,147.35 VRAM3006.T13
VMB_DQ44: length 24.2
  IN1 w0.114: v3(209.4,144.96) 209,145.36 209,147.96 208.99,147.97 208.99,148.78 208.26,149.52 201.71,149.52 194.63,142.44 v1(193.15,142.44)
  BOTTOM w0.152: v1(193.15,142.44) 193.13,142.44 U3002.E29 ; v3(209.4,144.96) 209.4,144.96 VRAM3006.N11
VMB_DQ45: length 23.8
  IN1 w0.114: v3(209.4,147.36) 209.84,147.8 209.84,148.75 208.69,149.9 201.5,149.9 194.45,142.85 192.8,142.85 192.44,142.49 v3(192.29,142.49)
  BOTTOM w0.152: v3(192.29,142.49) 192.28,142.49 U3002.F29 ; VRAM3006.N13 209.4,147.35 v3(209.4,147.36)
VMB_DQ46: length 26.6
  IN1 w0.114: v3(210.2,144.96) 210.6,145.36 210.6,149.08 209.03,150.64 201.1,150.64 194.12,143.67 193.49,143.67 v3(193.15,143.33)
  BOTTOM w0.152: U3002.E30 193.12,143.33 v3(193.15,143.33) ; VRAM3006.M11 210.2,144.96 v3(210.2,144.96)
VMB_DQ47: length 22.5
  IN1 w0.114: v3(210.2,147.36) 210.2,148.91 208.83,150.28 201.37,150.28 194.34,143.25 v3(193.91,143.25)
  BOTTOM w0.152: VRAM3006.M13 210.2,147.35 v3(210.2,147.36) ; U3002.D30 193.91,143.22 v3(193.91,143.25)
VMB_DQ48: length 32.6
  TOP w0.152: v3(219.89,146.58) 219.89,145.86 VRAM3002.U11
  BOTTOM w0.152: U3002.A32 196.14,144.54 196.4,144.8 196.83,144.8 203.94,151.91 217.71,151.91 220.02,149.6 v1(220.02,149.15) 220.02,146.7 v3(219.89,146.58)
VMB_DQ49: length 30.7
  TOP w0.152: VRAM3002.U13 219.39,146.96 v3(219.01,147.34)
  BOTTOM w0.102: 196.78,144.16 196.46,144.16 196.28,143.99 195.68,143.99 195.61,144.07 194.7,144.07 U3002.C31
  BOTTOM w0.152: v3(219.01,147.34) 219.01,147.97 219.07,148.04 219.07,148.59 v1(218.65,149.01) 216.62,151.04 204.36,151.04 197.48,144.16 196.78,144.16
VMB_DQ50: length 36.1
  TOP w0.152: v3(219,145.77) VRAM3002.T11
  BOTTOM w0.152: v3(219,145.77) 219.72,145.77 220.53,146.58 220.53,149.73 217.92,152.34 v1(203.75,152.34) 196.64,145.23 196.36,145.23 196.06,144.93 194.72,144.93 U3002.C32
VMB_DQ51: length 30.8
  TOP w0.152: VRAM3002.T13 218.23,147.32 218.23,149.36 v1(218.62,149.75)
  BOTTOM w0.102: U3002.B32 195.44,144.54 195.79,144.2 196.18,144.2 196.47,144.49 196.68,144.49
  BOTTOM w0.152: v1(218.62,149.75) 218.62,150.36 217.51,151.48 204.18,151.48 197.19,144.49 196.68,144.49
VMB_DQ52: length 26.8
  TOP w0.152: VRAM3002.N11 216.57,144.98 v3(216.6,144.98)
  BOTTOM w0.152: v3(216.6,144.98) 216.6,144.27 216.85,144.02 216.85,143.53 215.98,142.67 203.28,142.67 201.81,141.19 v1(201.31,141.19) 198,141.19 197.7,141.49 196.37,141.49 196.3,141.42 195.53,141.42 195.38,141.57 194,141.57 U3002.D29
VMB_DQ53: length 24.3
  TOP w0.152: VRAM3002.N13 215.79,147.36 v3(215.79,147.39)
  BOTTOM w0.152: v3(215.79,147.39) 215.79,147.87 215.59,148.07 215.59,148.48 215.34,148.73 204.9,148.73 198.35,142.18 196.54,142.18 196.4,142.04 U3002.A29
VMB_DQ54: length 29.5
  TOP w0.152: VRAM3002.M11 215.82,145.78 215.82,146.38 215.97,146.53 216.53,146.53 v1(216.58,146.58)
  BOTTOM w0.152: U3002.C29 194.73,142.44 196.18,142.44 196.33,142.59 198.15,142.59 204.72,149.16 v1(216.05,149.16) 216.55,148.66 216.55,146.6 v1(216.58,146.58)
VMB_DQ55: length 25.9
  TOP w0.152: v3(214.98,146.53) 214.98,146.54 215.4,146.96 VRAM3002.M13
  BOTTOM w0.152: v3(214.98,146.53) 215.62,146.53 215.79,146.35 215.79,143.58 215.51,143.3 203.03,143.3 201.48,141.75 v1(200.01,141.75) 196.27,141.75 196.19,141.67 195.73,141.67 195.37,142.04 U3002.B29
VMB_DQ56: length 33
  BOTTOM w0.152: VRAM3006.A4 220.63,138.52 220.63,136.37 217.76,133.5 217.43,133.5 216.59,132.66 216.59,132.35 216.34,132.1 204.28,132.1 200.89,135.49 v1(200.87,135.49) 196.34,135.49 196.15,135.68 196.1,135.68 196.08,135.71 195.54,135.71 195.17,135.34 U3002.B21
VMB_DQ57: length 29.4
  BOTTOM w0.152: U3002.C23 194.72,136.65 197.29,136.65 197.49,136.44 202.4,136.44 205.3,133.55 216.26,133.55 v1(218.35,135.64) 219.12,136.41 219.12,136.96 219.03,137.05 219.03,137.79 VRAM3006.A2
VMB_DQ58: length 35.2
  BOTTOM w0.152: U3002.A21 196.05,135.21 197.1,135.21 197.29,135.02 200.75,135.02 204.1,131.67 v1(217.81,131.67) 218.62,132.48 218.62,132.73 221.11,135.22 221.11,138.85 219.78,140.18 219.02,140.18 VRAM3006.B4
VMB_DQ59: length 32.3
  BOTTOM w0.152: VRAM3006.B2 219.02,138.58 219.55,138.58 220.12,138.01 220.12,136.52 217.99,134.39 v1(217.83,134.39) 217.71,134.39 216.44,133.12 205.09,133.12 202.22,135.99 197.19,135.99 196.94,135.75 196.45,135.75 196.25,135.94 196.21,135.94 196.18,135.96 195.44,135.96 195.21,135.74 194.72,135.74 U3002.C21
VMB_DQ60: length 27
  BOTTOM w0.152: VRAM3006.E4 216.58,139.37 216.58,136.41 215.22,135.05 205.97,135.05 202.97,138.04 v1(199.93,138.04) 196.41,138.04 196.25,138.21 195.62,138.21 195.26,137.84 U3002.B24
VMB_DQ61: length 25.4
  BOTTOM w0.152: U3002.C24 194.73,138.25 195.3,138.25 195.52,138.46 196.35,138.46 196.49,138.32 197.16,138.32 197.41,138.58 v1(202.9,138.58) 203.05,138.58 206.15,135.48 214.76,135.48 215.74,136.46 215.74,137.05 215.79,137.1 215.79,137.76 VRAM3006.E2
VMB_DQ62: length 24.5
  BOTTOM w0.152: U3002.B26 195.36,139.54 195.76,139.94 196.3,139.94 196.63,139.62 v1(199.94,139.62) 203.23,139.62 206.51,136.34 213.42,136.34 214.19,137.12 214.19,138.43 214.34,138.58 214.81,138.58 214.98,138.74 214.98,139.34 VRAM3006.F4
VMB_DQ63: length 24.3
  BOTTOM w0.152: VRAM3006.F2 215.01,137.77 215.01,137.2 214.89,137.08 214.89,136.37 214.43,135.91 206.33,135.91 203.1,139.14 v1(201.22,139.14) 197.92,139.14 197.8,139.26 196.32,139.26 196.22,139.16 194.8,139.16 194.43,139.54 U3002.C26
VMB_WCK01: length 20.6
  TOP w0.127: v3(209.39,124.83) VRAM3007.P4
  IN1 w0.089: v3(209.39,124.83) 209.16,124.61 209.16,124.08 208.41,123.34 204,123.34 203.47,123.87 195.85,123.87 195.34,123.36 192.94,123.36 192.53,123.78 192.53,123.89 v3(192.31,124.1)
  BOTTOM w0.127: U3002.F8 191.88,124.54 v3(192.31,124.1) ; v3(209.39,124.83) VRAM3007.P4
VMB_WCK01#: length 20.5
  TOP w0.127: v3(208.59,124.83) VRAM3007.P5
  IN1 w0.089: v1(193.15,124.1) 192.8,124.1 192.69,124 192.69,123.84 193.01,123.52 195.27,123.52 195.79,124.04 203.54,124.04 204.07,123.5 208.34,123.5 209,124.15 209,124.71 208.87,124.83 v3(208.59,124.83)
  BOTTOM w0.127: v3(208.59,124.83) VRAM3007.P5 ; U3002.E8 193.15,124.12 v1(193.15,124.1)
VMB_WCK23: length 25.4
  TOP w0.127: v3(217.35,124.86) 216.98,125.23 VRAM3007.D4
  BOTTOM w0.127: U3002.A5 196.03,122.14 199.96,122.14 200.71,121.39 215.74,121.39 217.15,122.8 217.15,123.82 217.35,124.02 v3(217.35,124.86) 217.35,124.87 VRAM3007.D4
VMB_WCK23#: length 25.4
  TOP w0.127: VRAM3007.D5 v3(216.59,124.83)
  BOTTOM w0.127: VRAM3007.D5 v3(216.59,124.83) 216.59,124.23 216.93,123.89 216.93,122.89 215.65,121.61 200.8,121.61 200.05,122.36 196.11,122.36 195.93,122.54 U3002.A6
VMB_WCK45: length 19.3
  TOP w0.127: VRAM3002.D4 208.6,140.15 v3(208.6,140.16)
  IN1 w0.089: v1(193.96,138.28) 193.96,138.53 194.23,138.79 194.38,138.79 194.62,139.03 195.08,139.03 195.32,139.28 201.8,139.28 204.02,141.5 208.32,141.5 208.93,140.89 208.93,140.5 v3(208.6,140.16)
  BOTTOM w0.127: U3002.D24 v1(193.96,138.28) ; VRAM3002.D4 208.6,140.15 v3(208.6,140.16)
VMB_WCK45#: length 19.3
  TOP w0.127: v3(209.4,140.16) 209.39,140.16 VRAM3002.D5
  IN1 w0.089: v3(193.94,139.14) 194.12,138.96 194.31,138.96 194.55,139.2 195.01,139.2 195.25,139.44 201.73,139.44 203.95,141.66 208.39,141.66 209.1,140.95 209.1,140.46 v3(209.4,140.16)
  BOTTOM w0.127: U3002.D25 193.94,139.1 v3(193.94,139.14) ; v3(209.4,140.16) 209.39,140.16 VRAM3002.D5
VMB_WCK67: length 26.8
  TOP w0.127: VRAM3002.P4 216.6,140.15 v3(216.6,140.16)
  BOTTOM w0.127: VRAM3002.P4 216.6,140.15 v3(216.6,140.16) 216.6,140.81 216.78,140.98 216.95,140.98 217.18,141.22 217.18,141.43 216.87,141.75 204.19,141.75 202.74,140.3 196.53,140.3 196.13,140.7 195.69,140.7 195.53,140.54 195.53,140.12 195.36,139.95 195.13,139.95 195,140.08 195,140.21 U3002.B27
VMB_WCK67#: length 26.8
  TOP w0.127: v3(217.4,140.16) 217.39,140.16 VRAM3002.P5
  BOTTOM w0.127: VRAM3002.P5 217.39,140.16 v3(217.4,140.16) 217.4,141.52 216.96,141.96 204.1,141.96 202.65,140.52 196.62,140.52 196.22,140.91 195.6,140.91 195.42,140.74 194.72,140.74 U3002.C27
VR_SVID_ALERT#_VCORE: length 81.9
  TOP w0.127: PU1.36 135.76,176.72 v1(135.51,176.47)
  IN1 w0.089: v1(104.63,150.01) 104.63,151.15 106.3,152.83 106.3,154.97 106.94,155.61 106.94,156.1 106.97,156.13 106.97,156.63 108.55,158.2 108.55,159.75 109.45,160.66 109.45,162.34 110.42,163.3 110.42,164.4 112.5,166.48 112.5,168.41 113.65,169.55 113.65,170.57 115.93,172.85 115.93,174.2 116.96,175.23 122.43,175.23 124.35,177.15 125.11,177.15 125.2,177.06 125.2,176.32 125.35,176.17 125.65,176.17 125.8,176.32 125.8,176.99 125.95,177.15 126.24,177.15 126.4,176.99 126.4,176.32 126.55,176.17 126.84,176.17 126.99,176.32 126.99,176.99 127.15,177.15 128.63,177.15 128.78,176.99 128.78,176.45 128.94,176.3 129.23,176.3 129.38,176.45 129.38,176.99 129.53,177.15 130.08,177.15 130.23,176.99 130.23,175.28 130.36,175.15 131.12,175.15 131.37,174.9 133.15,174.9 134.73,176.47 v1(135.51,176.47)
  BOTTOM w0.127: v1(104.63,150.01) 104.63,147.64 100.54,143.55 v1(100.54,136.54) 100.54,135.56 102.62,133.48 102.62,130.37 102.94,130.06 R134.2 R552.2
VREF_CA_DIMM0: length 8.6
  TOP w0.508: R10887.2 130.19,40.75 R10878.2 128.92,40.92 R10895.1 127.77,40.88 C1255.1 125.32,40.88 C1259.1 125.28,41.65 v1(125.53,41.9) 125.53,42.19 R10883.2
  BOTTOM w0.254: v1(125.53,41.9) 125.47,41.96 JDIM1.164
VREF_CA_DIMM1: length 17.9
  TOP w0.508: R10934.2 C1323.1 117.67,63.39 117.5,63.22 C1327.1 117.5,61.87 117.16,61.53 R10938.1 R10935.2 117.16,59.58 116.9,59.32 R10932.2 116.94,58.7 118.26,58.7 v1(119.18,57.79) 120.94,56.03 124.58,56.03 v1(125.39,56.84)
  BOTTOM w0.203: v1(125.39,56.84) 125.47,56.76 JDIM2.164
VREF_VMA1_MOS: length 32.3
  TOP w0.508: R4515.2 v1(204.53,163.72) 205.8,164.99 205.8,169.95 205.16,170.58 202.24,170.58 201.73,170.07 196.53,170.07 194.49,172.11 v1(194.38,172.11) R4517.2
  BOTTOM w0.483: R4511.2 R4513.2
  BOTTOM w0.508: v1(204.53,163.72) 205.42,162.83 205.42,161.44 Q4500.3 206.69,157.45 206.28,157.04 204.98,157.04 204.4,157.63 R4513.2
VREF_VMA3_MOS: length 24.6
  TOP w0.508: R4521.2 v1(174.3,172.61) ; R4519.2 v1(164.27,166.39)
  IN1 w0.508: v1(164.27,166.39) 165.28,167.41 165.28,171.22 165.94,171.88 173.56,171.88 v1(174.3,172.61)
  BOTTOM w0.508: R4519.2 v1(164.27,166.39) 163.51,165.63 163.51,164.22 R4523.2 ; v1(174.3,172.61) 174.43,172.74 175.01,172.74 v1(175.69,173.42) 176.41,174.14 Q4501.3
VREF_VMB1_MOS: length 23.7
  TOP w0.508: v1(224.08,116.45) v1(224.83,116.45) Q4509.3 ; R11066.2 v1(224.08,121.18) ; R11085.2 v1(213.92,112.29)
  IN3 w0.508: v1(213.92,112.29) 215.19,113.56 222.56,113.56 223.07,114.07 223.07,115.72 223.81,116.45 v1(224.08,116.45) 224.44,116.45 224.72,116.73 224.72,120.54 v1(224.08,121.18)
  BOTTOM w0.508: R11085.2 v1(213.92,112.29) ; R11066.2 v1(224.08,121.18)
VREF_VMB3_MOS: length 26
  TOP w0.508: R11097.2 v1(215.96,152.8) ; R11078.2 v1(223.96,146.58)
  IN3 w0.508: v1(208.46,154.71) 208.46,154.3 208.95,153.82 212.53,153.82 213.04,153.31 213.04,152.29 213.29,152.04 215.19,152.04 v1(215.96,152.8) 217.23,151.53 218.24,151.53 220.91,148.86 222.18,148.86 223.32,147.72 223.32,147.21 v1(223.96,146.58)
  BOTTOM w0.508: 226.12,145.94 225.23,145.94 v1(224.87,146.3) 224.59,146.58 v1(223.96,146.58) R11078.2 ; R11079.2 207.96,154.2 v1(208.46,154.71)
VREFC_VMA1: length 5.7
  BOTTOM w0.356: VRAM3000.J14 200.09,161.06 200.59,161.06
  BOTTOM w0.508: R4511.1 R4528.2 R4510.2 202.74,161.06 v1(202.38,161.06) 200.59,161.06
VREFC_VMA2: length 5.7
  TOP w0.356: 200.64,161.23 199.91,161.23 VRAM3004.J14
  TOP w0.508: R4515.1 R4530.2 R4514.2 203.12,161.63 202.72,161.23 v1(202.03,161.23) 200.64,161.23
VREFC_VMA3: length 8.9
  TOP w0.356: VRAM3001.J14 169.05,161.39 168.84,161.18 168.46,161.18
  TOP w0.508: 168.46,161.18 168.33,161.18 167.32,162.2 167.32,164.36 v1(166.81,164.87) 166.43,165.25 R4532.2 R4519.1 R4518.2
VREFC_VMA4: length 6.6
  BOTTOM w0.381: R4534.2 165.67,164.03 R4523.1 R4522.2 165.8,161.69 v1(166.54,161.69) 167.19,161.69 167.82,161.06 168.95,161.06 VRAM3005.J14
VREFC_VMB1: length 6.2
  BOTTOM w0.356: VRAM3003.J14 212.98,116.73
  BOTTOM w0.508: 212.98,116.73 212.98,115.9 213.92,114.95 v1(213.92,114.76) R11070.1 R11105.2 R11077.2
VREFC_VMB2: length 6.2
  TOP w0.356: VRAM3007.J14 212.98,116.61
  TOP w0.508: 212.98,116.61 212.98,115.72 v1(213.01,115.69) 213.92,114.78 R11085.1 R11091.2 R11101.2
VREFC_VMB3: length 6.1
  TOP w0.356: VRAM3002.J14 213,148.7
  TOP w0.508: R11097.1 R11099.2 R11100.2 214.08,151.12 v1(214.08,150.12) 214.08,149.78 213,148.7
VREFC_VMB4: length 11.3
  IN3 w0.381: v1(212.02,153.17) 212.15,153.05 212.15,152.33 213.08,151.4 213.53,151.4 214.05,150.88 214.05,149.12 213.53,148.6 v3(213.53,148.24)
  BOTTOM w0.356: v3(213.53,148.24) 213.48,148.24 VRAM3006.J14
  BOTTOM w0.381: R11079.1 R11095.2 R11093.2 210.36,153.17 210.6,153.41 v1(210.71,153.41) 211.78,153.41 v1(212.02,153.17)
VREFD_VMA1: length 28
  TOP w0.381: v1(196.58,154.05) 195.79,154.05 194.99,154.85 194.99,168.16 195.43,168.6 v1(195.97,168.6)
  BOTTOM w0.356: v1(195.97,168.6) 196.53,168.04 VRAM3000.U10 ; v1(196.58,154.05) 196.37,154.25 196.37,154.86 VRAM3000.A10
  BOTTOM w0.381: v1(196.58,154.05) 196.81,153.82 201.47,153.82 v1(202.47,154.82) R4529.2 R4512.2 R4513.1
VREFD_VMA2: length 22.2
  TOP w0.356: 196.53,168.29 196.53,167.82 196.3,168.04 196.02,168.04 ; VRAM3004.U10 196.02,155.02
  TOP w0.381: R4516.2 R4531.2 R4517.1 194.38,171.33 v1(194.9,170.81) 196.53,169.18 196.53,168.29 ; 196.02,155.02 195.96,155.02 195.51,155.47 195.51,167.79 195.76,168.04 196.02,168.04 ; 196.53,167.82 VRAM3004.A10
VREFD_VMA3: length 21.4
  TOP w0.356: 172.01,168.93 172.49,168.46 VRAM3001.U10 172.61,167.91 173.28,167.91 ; 173.06,154.99 VRAM3001.A10
  TOP w0.508: 173.06,154.99 173.92,155.85 173.92,167.28 173.28,167.91 ; 172.01,168.93 171.63,169.31 v1(171.63,170.07) R4520.2 R4533.2 R4521.1
VREFD_VMA4: length 25.3
  BOTTOM w0.356: 172.49,168.42 VRAM3005.A10 172.64,167.94 173.03,167.94 ; 173.09,155.28 172.81,154.99 VRAM3005.U10
  BOTTOM w0.381: 173.03,167.94 173.26,167.94 173.67,167.53 173.67,155.85 173.09,155.28 ; 172.49,168.42 172.49,168.58 172.01,169.06 168.2,169.06 166.68,167.53 v1(166.44,167.53) R4524.2 R4525.1 R4535.2
VREFD_VMB1: length 22.7
  TOP w0.381: v3(206.18,120.06) 206.05,120.19 206.05,120.8 207.57,122.32 214.75,122.32 215.02,122.05 219.4,122.05 220.27,121.18 v1(220.27,121.05)
  BOTTOM w0.356: v3(206.18,120.06) 206.2,120.06 VRAM3003.A10 ; VRAM3003.U10 220,121.05 v1(220.27,121.05)
  BOTTOM w0.508: 222.68,120.42 R11067.1 R11103.2 ; 222.68,120.42 v1(221.88,120.42) 220.91,120.42 v1(220.27,121.05) ; 222.68,120.42 R11081.2
VREFD_VMB2: length 20
  TOP w0.356: VRAM3007.U10 206.58,120.56 207.83,121.81 214.56,121.81 214.81,121.56 219.08,121.56 219.55,121.09 219.55,120.6 VRAM3007.A10 220.25,120.44
  TOP w0.508: R11102.2 R11066.1 222.68,120.42 ; 222.68,120.42 v1(221.49,120.42) 220.27,120.42 220.25,120.44 ; 222.68,120.42 R11074.2
VREFD_VMB3: length 20.7
  TOP w0.381: 222.55,144.8 R11076.2 R11078.1 ; 222.55,144.8 221.67,144.8 221.43,144.56 v1(221.41,144.56) VRAM3002.U10 219.64,144.31 219.64,143.66 219.3,143.32 206.81,143.32 206.43,143.7 206.43,144.39 VRAM3002.A10 ; 222.55,144.8 R11104.2
VREFD_VMB4: length 23.3
  TOP w0.381: v1(220.2,144) 220.2,143.33 219.64,142.77 206.56,142.77 205.92,143.4 205.92,144.69 v3(206.2,144.96)
  BOTTOM w0.381: VRAM3006.U10 206.6,144.57 v3(206.2,144.96) ; VRAM3006.A10 219.95,144 v1(220.2,144)
  BOTTOM w0.508: v1(220.2,144) 221.13,144 221.67,144.55 v1(221.69,144.55) R11082.2 R11087.2 R11088.1
VRON: length 14.9
  IN3 w0.114: v1(168.03,31.62) 167.6,31.19 162.03,31.19 161.6,30.75 v1(160.33,30.75)
  BOTTOM w0.127: U50.1 158.44,30.1 158.55,29.99 159.07,29.99 R792.2 160.19,30.62 v1(160.33,30.75) ; U45.69 169.64,30.6 R463.1 169.03,31.21 168.43,31.21 v1(168.03,31.62)
VRON_R: length 378.9
  TOP w0.127: v1(49.31,82.95) 49.51,83.15 PR136.1 ; v1(132.42,171.55) 132.91,171.55 PR28.1
  IN1 w0.089: v1(40.44,38.12) 40.95,38.12 42.12,36.95 42.12,33.99 43.63,32.48 43.63,27.36 46.2,24.8 47.28,24.8 55.73,16.34 58.52,16.34 59.11,16.92 61.12,16.92 61.77,16.27 64.07,16.27 64.4,16.59 67.66,16.59 80.82,29.76 113.66,29.76 113.96,29.46 155.48,29.46 157.28,31.26 157.66,31.26 v1(159.19,32.79)
  IN2 w0.114: v1(132.42,171.55) 136.3,171.55 136.75,171.1 145.55,171.1 146.84,172.38 149.06,172.38 153.77,167.67 155.16,167.67 157.82,165.01 157.82,150.11 159.82,148.1 161.35,148.1 163.25,146.2 163.25,141.45 166.76,137.94 166.76,133.68 166.25,133.17 163.81,133.17 162.74,132.1 162.74,122.92 159.57,119.74 159.57,115.31 159.98,114.9 160.41,114.9 161.22,114.09 161.22,103.4 161.7,102.92 161.7,90 162.62,89.08 162.62,83.97 161.47,82.82 161.47,77.78 162.19,77.06 162.19,74.66 v1(161.47,73.93)
  IN3 w0.114: v1(161.47,73.93) 161.47,73.67 160.05,72.26 160.05,69.97 161.25,68.77 161.25,65.96 159.67,64.38 159.67,43.42 160.23,42.86 160.23,33.83 v1(159.19,32.79) ; v1(49.31,82.95) 46.59,82.95 46.08,82.44 46.08,79.73 51.11,74.7 51.11,70.73 44.28,63.9 42.97,63.9 40.02,60.95 40.02,53.83 39.43,53.24 39.43,40.66 39.68,40.41 39.68,38.63 40.19,38.12 v1(40.44,38.12)
  BOTTOM w0.127: PR196.2 132.97,172.1 v1(132.42,171.55) ; U50.4 157.14,31.94 157.44,31.64 158.94,31.64 159.19,31.4 R792.1 v1(159.7,32.17) 159.7,32.28 v1(159.19,32.79)
VSA_SENSE: length 98.9
  TOP w0.127: v1(146.11,186.84) 145.58,186.84 PR50.2 ; v3(127.63,118.53) 127.18,118.99 127.18,124.98 127.39,125.19 127.39,126.34 129.98,128.92 129.98,130.73 130.96,131.72 131.38,131.72 R122.2 132,131.59 133.15,131.59 133.86,132.3 140.94,132.3 141.66,133.01 143.08,133.01 145.85,135.78 145.85,137.59 148.74,140.48 149.79,140.48 v1(149.92,140.61)
  IN1 w0.089: v1(149.92,140.61) 150.01,140.52 152.21,140.52 155.69,144 155.69,156.47 156.48,157.26 156.48,165.69 153.04,169.13 153.04,182.15 149.23,185.96 146.75,185.96 146.45,186.27 146.45,186.5 v1(146.11,186.84)
  BOTTOM w0.127: v3(127.63,118.53) 127.78,118.38 128.25,118.38 128.57,118.7 129.58,118.7 U35.H20
VSASS_SENSE: length 96.8
  TOP w0.127: v1(146.84,186.82) 146.19,187.47 PR52.2 ; v1(149.92,139.97) 149.79,140.1 148.9,140.1 146.23,137.43 146.23,135.62 143.24,132.63 141.81,132.63 141.1,131.92 134.02,131.92 133.31,131.21 131.75,131.21 R109.1 131.38,131.34 131.12,131.34 130.36,130.58 130.36,128.77 127.77,126.18 127.77,125.04 127.56,124.82 127.56,122.07 128.12,121.51 128.12,119.73 128.44,119.41 v3(128.59,119.41)
  IN1 w0.089: v1(149.92,139.97) 150.12,140.18 152.36,140.18 156.04,143.86 156.04,156.33 156.83,157.12 156.83,165.83 153.38,169.27 153.38,182.29 149.37,186.3 146.89,186.3 146.79,186.41 146.79,186.77 v1(146.84,186.82)
  BOTTOM w0.127: v3(128.59,119.41) 128.96,119.04 U35.H21
