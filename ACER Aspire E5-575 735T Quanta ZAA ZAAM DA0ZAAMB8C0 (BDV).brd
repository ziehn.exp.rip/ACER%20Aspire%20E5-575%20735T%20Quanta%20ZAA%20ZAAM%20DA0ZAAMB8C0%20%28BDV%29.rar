# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_TXP0_R: length 11.9
  TOP w0.127: R381.1 18.22,17.55 C505.1 18.55,17.55 18.7,17.39 18.7,16.91 19.36,16.25 19.36,16.1 19.2,15.94 18.78,15.94 18.72,16.01 17.62,16.01 17.58,16.04 U24.1 16.67,16.04 16.36,16.35 16.36,17.17 15.81,17.72 14.08,17.72 13.54,18.26 13.06,18.26 12.92,18.39 CN16.9
USB3_TXP1: length 285.2
  TOP w0.127: C459.1 23.81,34.56 24.11,34.27 33.23,34.27 37.88,29.61 44.99,29.61 49.36,25.25 49.36,17.14 49.59,16.91 49.59,13.99 50.17,13.41 v1(50.17,12.59)
  IN3 w0.114: v1(50.17,12.59) 50.17,12.98 50.32,13.13 67.29,13.13 77.83,23.67 83.46,23.67 91.43,31.63 151.61,31.63 154.84,34.87 154.84,35.61 159.24,40.01 159.24,42.2 158.68,42.76 158.68,64.79 159.4,65.51 159.4,66.28 159.95,66.82 159.95,67.76 159.62,68.09 159.62,69 159.06,69.56 159.06,72.9 159.62,73.46 159.62,75.51 162.66,78.55 162.66,82.11 163.99,83.43 163.99,90.22 164.65,90.88 164.65,99.37 165,99.72 165,104.13 161.25,107.89 161.25,126.77 160.38,127.63 155.66,127.63 154.83,126.79 146.28,126.79 146.05,127.02 140.7,127.02 140.25,126.56 137.58,126.56 136,124.99 135.24,124.99 134.7,124.45 134.7,124.22 134.54,124.06 v1(134.23,124.06)
  BOTTOM w0.127: U35.A13 133.89,123.71 v1(134.23,124.06)
USB3_TXP1_C: length 1
  TOP w0.127: C459.2 R340.2
USB3_TXP1_R: length 9.8
  TOP w0.127: R340.1 20.76,34.56 20.75,34.55 C458.1 19.93,34.11 17.66,34.11 17.56,34.2 U21.1 16.74,34.2 16.69,34.16 15.32,34.16 15.21,34.05 14.33,34.05 13.44,34.94 13.08,34.94 12.92,35.11 CN13.9
USB3_TXP2: length 119.4
  TOP w0.127: v1(42.86,119.02) 42.58,118.74 38.19,118.74 C369.1
  IN1 w0.089: v1(133.79,125.47) 133.66,125.6 133.66,125.97 133.42,126.21 131.94,126.21 129.73,123.99 125.51,123.99 124.9,124.61 124.9,127.4 124.02,128.28 123.02,128.28 119.69,131.61 119.69,131.74 114.82,136.61 104.64,136.61 103.74,137.51 96.38,137.51 90.4,131.53 87.29,131.53 70.08,114.32 48.46,114.32 43.89,118.89 42.98,118.89 v1(42.86,119.02)
  BOTTOM w0.076: U35.A15 132.23,123.82 132.23,124.23 133.06,125.06 133.81,125.06 133.91,125.17 133.91,125.34 v1(133.79,125.47)
USB3_TXP3: length 122.2
  TOP w0.127: C4778.1 38.28,122.83 38.63,122.49 38.99,122.49 40.57,120.9 40.93,120.9 v1(41.2,121.18)
  IN1 w0.089: v1(133.89,124.66) 133.48,125.07 131.76,125.07 130.09,123.41 124.91,123.41 124.3,124.02 124.3,125.78 118.93,131.15 118.93,131.66 114.68,135.91 104.71,135.91 104.35,135.55 95.95,135.55 91.29,130.89 87.5,130.89 70.3,113.68 46.16,113.68 42.09,117.75 42.09,120.85 41.81,121.13 41.26,121.13 v1(41.2,121.18)
  BOTTOM w0.076: U35.D15 132.79,122.22 132.79,122.53 132.73,122.66 132.73,122.84 132.77,122.96 132.77,123.21 132.72,123.36 132.72,123.45 132.77,123.56 132.77,123.97 133.05,124.25 133.48,124.25 v1(133.89,124.66)
USB3_TYPC_RX2N_C: length 13.9
  IN1 w0.089: v1(12.88,119.53) 12.69,119.34 12.49,119.34 12.17,119.02 11.34,119.02 10.26,117.94 5.61,117.94 CN2021.B10
  BOTTOM w0.127: v1(12.88,119.53) 14.43,119.53 14.53,119.63 U4509.8 15.48,119.63 15.54,119.58 16.11,119.58 16.57,119.12 16.93,119.12 17.22,119.42 RP2.2 17.83,119.65 R11196.2
USB3_TYPC_RX2N_C_RE: length 3
  TOP w0.127: U9.1 33.67,117.4 33.76,117.31 33.76,116.78 34.06,116.48 34.22,116.48 v1(34.47,116.22) 34.6,116.1 C394.2
USB3_TYPC_RX2N_RE: length 18.9
  TOP w0.127: U9.27 29.91,117.4 29.75,117.24 29.75,116.89 29.37,116.5 29.37,116.25 v1(29.52,116.1)
  BOTTOM w0.127: v1(29.52,116.1) 29.39,116.1 29.22,116.28 29.22,116.4 29.37,116.56 30.38,116.56 30.64,116.3 30.64,115.59 30.33,115.29 29.37,115.29 28.05,116.61 28.05,116.91 26.98,117.98 24.88,117.98 23.73,119.12 19.53,119.12 19.44,119.22 19.44,119.34 19.35,119.42 RP2.1 18.61,119.65 R11196.1
USB3_TYPC_RX2P_C: length 13.9
  IN1 w0.089: CN2021.B11 5.5,117.75 10.34,117.75 11.42,118.83 12.25,118.83 12.57,119.15 12.68,119.15 12.88,118.94 v1(12.88,118.89)
  BOTTOM w0.127: R11199.2 17.83,118.64 RP2.3 16.46,118.87 16.01,119.32 14.62,119.32 14.53,119.23 U4509.2 13.23,119.23 v1(12.88,118.89)
USB3_TYPC_RX2P_C_RE: length 3
  TOP w0.127: C4781.2 34.6,116.99 v1(34.47,116.86) 34.35,116.73 34.17,116.73 34.02,116.89 34.02,117.41 33.63,117.8 U9.2
USB3_TYPC_RX2P_RE: length 18.8
  TOP w0.127: U9.26 29.77,117.8 29.5,117.52 29.5,117.11 29.37,116.99 v1(29.16,116.99)
  BOTTOM w0.127: v1(29.16,116.99) 29.34,116.81 30.49,116.81 30.89,116.41 30.89,115.48 30.44,115.03 29.26,115.03 27.79,116.5 27.79,116.81 26.88,117.72 24.77,117.72 23.62,118.87 RP2.4 18.61,118.64 R11199.1
USB3_TYPC_RX3N_C: length 12
  BOTTOM w0.127: R817.2 17.83,122.57 RP3.1 17.2,122.81 17.05,122.96 16.81,122.96 16.44,122.59 16.44,121.94 15.88,121.38 15.57,121.38 15.53,121.33 U4509.6 14.76,121.33 14.67,121.43 13.16,121.43 13.03,121.56 9.86,121.56 9.65,121.76 8.01,121.76 7.89,121.65 CN2021.A10
USB3_TYPC_RX3N_C_RE: length 4.2
  TOP w0.127: U9.7 33.73,119.8 33.88,119.95 35.81,119.95 35.97,120.11 v1(36.25,120.11) 36.45,120.31 36.98,120.31 C4777.2
USB3_TYPC_RX3N_RE: length 13.3
  TOP w0.127: U9.21 29.65,119.8 29.57,119.87 29.25,119.87 27.82,121.3 27.21,121.3 v1(26.93,121.02)
  BOTTOM w0.127: v1(26.93,121.02) 26.65,121.3 25.08,121.3 23.42,122.96 19.49,122.96 19.34,122.81 RP3.2 18.61,122.57 R817.1
USB3_TYPC_RX3P_C: length 12
  BOTTOM w0.127: CN2021.A11 7.95,122.15 8.08,122.02 9.76,122.02 9.96,121.81 13.14,121.81 13.27,121.68 13.65,121.68 13.7,121.73 U4509.5 14.74,121.73 14.84,121.64 15.78,121.64 16.19,122.05 16.19,122.69 16.7,123.21 17.07,123.21 17.22,123.36 RP3.4 17.83,123.59 R816.2
USB3_TYPC_RX3P_C_RE: length 4.3
  TOP w0.127: C4776.2 36.56,121.05 v1(36.25,120.75) 35.87,120.37 35.87,120.37 35.7,120.2 U9.8
USB3_TYPC_RX3P_RE: length 13.3
  TOP w0.127: v1(26.93,121.84) 27.21,121.56 27.92,121.56 29.35,120.13 29.57,120.13 29.65,120.2 U9.20
  BOTTOM w0.127: R816.1 18.61,123.59 RP3.3 19.34,123.36 19.49,123.21 23.53,123.21 25.18,121.56 26.65,121.56 v1(26.93,121.84)
USB3_TYPC_TX2N_C: length 12.4
  BOTTOM w0.127: CN2021.A3 7.94,118.15 8.06,118.03 8.92,118.03 9.25,117.7 12.42,117.7 13.36,118.64 14.59,118.64 14.69,118.73 U4509.9 15.52,118.73 15.56,118.69 15.88,118.69 16.41,118.16 16.41,117.48 16.67,117.23 16.95,117.23 17.11,117.39 RP4.2 17.83,117.62 R820.2
USB3_TYPC_TX2N_C_RE: length 4.2
  TOP w0.127: C4780.2 36.38,118.13 v1(36.25,118.26) 36.05,118.46 35.26,118.46 35.05,118.66 33.74,118.66 33.67,118.6 U9.4
USB3_TYPC_TX2N_R: length 2.9
  BOTTOM w0.127: C4771.1 20.41,117.29 20.28,117.29 19.89,117.67 v1(19.89,117.8) 19.39,117.29 19.16,117.29 19.06,117.39 RP4.1 18.84,117.39 R820.1
USB3_TYPC_TX2N_RE: length 13.2
  TOP w0.127: U9.24 29.77,118.6 29.68,118.7 29.35,118.7 v1(29.19,118.54)
  IN3 w0.114: v1(29.19,118.54) 29.83,118.54 30.16,118.87 30.16,119.47 29.62,120.01 28.23,120.01 27.36,119.15 27.36,118.64 26.6,117.88 25.2,117.88 24.95,117.62 v1(22.41,117.62)
  BOTTOM w0.127: C4771.2 21.86,117.29 22.08,117.29 v1(22.41,117.62)
USB3_TYPC_TX2P_C: length 12.4
  BOTTOM w0.127: R821.2 17.83,116.61 RP4.3 17.1,116.84 16.96,116.97 16.56,116.97 16.16,117.38 16.16,118.05 15.77,118.44 14.75,118.44 14.65,118.33 U4509.1 13.77,118.33 13.72,118.39 13.47,118.39 12.53,117.44 9.15,117.44 8.82,117.77 8.06,117.77 7.94,117.65 CN2021.A2
USB3_TYPC_TX2P_C_RE: length 4.2
  TOP w0.127: U9.5 33.69,119 33.77,118.92 35.16,118.92 35.36,118.71 36.07,118.71 v1(36.25,118.89) 36.38,119.02 C369.2
USB3_TYPC_TX2P_R: length 2.9
  BOTTOM w0.127: C4770.1 20.45,117.03 20.3,117.03 19.89,116.63 v1(19.89,116.53) 19.39,117.03 19.25,117.03 19.06,116.84 RP4.4 18.61,116.61 R821.1
USB3_TYPC_TX2P_RE: length 13.2
  TOP w0.127: v1(29.19,119.17) 29.41,118.95 29.71,118.95 29.76,119 U9.23
  IN3 w0.114: v1(22.41,116.73) 22.33,116.81 22.33,117.04 22.47,117.17 22.68,117.17 22.9,117.39 25.04,117.39 25.3,117.65 26.69,117.65 27.59,118.54 27.59,119.05 28.32,119.78 29.52,119.78 29.93,119.37 29.93,118.96 29.73,118.76 29.6,118.76 v1(29.19,119.17)
  BOTTOM w0.127: v1(22.41,116.73) 22.1,117.04 21.83,117.04 C4770.2
USB3_TYPC_TX3N_C: length 13.7
  IN1 w0.089: v1(12.76,120.42) 12.53,120.64 10.38,120.64 9.2,121.81 5.56,121.81 CN2021.B3
  BOTTOM w0.127: R11207.2 17.83,120.54 RP5.3 17.2,120.78 17.05,120.92 16.57,120.92 16.13,120.49 15.56,120.49 15.51,120.43 U4509.7 14.63,120.43 14.52,120.54 12.88,120.54 v1(12.76,120.42)
USB3_TYPC_TX3N_C_RE: length 4.9
  TOP w0.127: C4779.2 36.33,121.94 v1(36.25,122.02) 36,122.27 34.72,122.27 34.36,121.91 34.36,121.36 34.07,121.06 33.71,121.06 33.65,121 U9.10
USB3_TYPC_TX3N_R: length 2.3
  BOTTOM w0.127: R11207.1 18.61,120.54 RP5.4 19.35,120.78 19.5,120.92 20.37,120.92 C4762.1
USB3_TYPC_TX3N_RE: length 10.8
  TOP w0.127: v1(28.76,122.32) 28.81,122.37 29.26,122.37 29.44,122.19 29.44,121.25 29.7,121 U9.18
  IN3 w0.114: v1(28.76,122.32) 28.56,122.52 25.79,122.52 24.26,121 22.61,121 v1(22.28,120.67)
  BOTTOM w0.127: C4762.2 v1(22.28,120.67)
USB3_TYPC_TX3P_C: length 13.7
  IN1 w0.089: CN2021.B2 5.55,122 9.28,122 10.45,120.83 12.53,120.83 v1(12.76,121.05)
  BOTTOM w0.127: v1(12.76,121.05) 12.97,120.83 U4509.4 14.6,120.83 14.69,120.75 16.03,120.75 16.46,121.18 17.05,121.18 17.2,121.33 RP5.2 17.83,121.56 R11202.2
USB3_TYPC_TX3P_C_RE: length 4.9
  TOP w0.127: U9.11 33.62,121.4 33.7,121.32 33.96,121.32 34.11,121.47 34.11,122.02 34.62,122.52 36.02,122.52 v1(36.25,122.75) 36.33,122.83 C4778.2
USB3_TYPC_TX3P_R: length 2.3
  BOTTOM w0.127: R11202.1 18.61,121.56 RP5.1 19.35,121.33 19.5,121.18 20.24,121.18 C4763.1
USB3_TYPC_TX3P_RE: length 10.7
  TOP w0.127: U9.17 29.79,121.4 29.7,121.49 29.7,122.3 29.37,122.63 29.09,122.63 v1(28.76,122.96)
  IN3 w0.114: v1(28.76,122.96) 28.56,122.75 25.69,122.75 24.17,121.23 22.61,121.23 v1(22.28,121.56)
  BOTTOM w0.127: v1(22.28,121.56) C4763.2
USB_BC_ON: length 178.4
  TOP w0.127: U22.4 17.72,27.69 v1(17.33,28.09)
  IN1 w0.089: v1(172.45,42.26) 172.45,41.73 170.43,39.71 170.43,38.68 167.23,35.48 158.97,35.48 156.78,33.29 148.35,33.29 147.61,32.56 84.2,32.56 83.75,33.01 81.78,33.01 77.59,28.82 77.59,28.45 67.38,18.24 58.7,18.24 57.91,19.03 54.91,19.03 47.48,26.46 v1(46.83,26.46)
  IN3 w0.114: v1(17.33,28.09) 17.2,28.21 17.2,29.1 18.89,30.79 19.98,30.79 22.48,33.29 32.72,33.29 39.55,26.46 v1(46.83,26.46)
  BOTTOM w0.127: v1(172.45,42.26) 172.98,42.26 173.18,42.46 U45.97
USB_CHARGE_ON: length 182.9
  TOP w0.127: U22.5 16.2,26.3 16.06,26.44 v1(16.06,27.02) 16.06,27.83 16.3,28.08 R364.1 v1(16.57,27.45)
  IN1 w0.089: v1(46.32,26.97) 46.32,26.27 46.67,25.93 47.74,25.93 54.83,18.84 57.83,18.84 58.62,18.05 67.47,18.05 77.91,28.49 77.91,28.87 81.86,32.82 83.67,32.82 84.12,32.37 147.69,32.37 148.43,33.1 156.89,33.1 159.07,35.28 167.3,35.28 170.63,38.6 170.63,39.52 172.9,41.8 v1(172.95,41.8)
  IN3 w0.114: v1(16.57,27.45) 16.57,28.43 16.97,28.84 16.97,29.36 18.98,31.36 20.02,31.36 22.33,33.67 32.82,33.67 39.53,26.97 v1(46.32,26.97)
  BOTTOM w0.127: v1(172.95,41.8) 172.55,41.4 U45.96
USB_CLT1: length 191.8
  TOP w0.127: U22.6 v1(15.81,25.8)
  IN2 w0.114: v1(15.81,25.8) 17.14,24.46 28.19,24.46 36.89,15.77 50.26,15.77 52.34,13.68 54.74,13.68 56.72,11.7 60.13,11.7 62.16,9.67 64.32,9.67 72.07,17.42 75.08,17.42 77.78,20.12 81.14,23.48 112.45,23.48 113.28,24.31 167.34,24.31 168.74,22.91 171.98,22.91 173.13,24.05 185.78,24.05 v1(186.59,24.86)
  BOTTOM w0.127: v1(186.59,24.86) 186.44,25.01 186.44,27.5 v1(186.37,27.57) 186.11,27.83 186.11,29.14 186.37,29.4 U45.31
USB_OC0#: length 226.9
  TOP w0.127: U22.13 21.04,24.8 v1(21.15,24.91)
  IN1 w0.089: v1(55.68,117.88) 56.44,117.11 71.08,117.11 86.87,132.9 89.86,132.9 95.97,139.01 104.8,139.01 105.55,138.26 115.39,138.26 118.62,135.03 122.24,135.03 123.96,136.75 127.64,136.75 128.08,136.31 140.35,136.31 v1(141.26,135.4)
  IN2 w0.114: v1(21.15,24.91) 21.27,24.91 22.79,26.44 22.79,29.48 26.35,33.04 26.35,42.06 27.64,43.35 27.64,59.23 30.73,62.31 30.73,66.81 31.43,67.51 31.43,71.01 32.06,71.65 33.64,71.65 34.23,72.23 34.23,74.18 33.36,75.05 33.36,77.55 32.37,78.54 32.37,97.49 34.35,99.46 38.06,99.46 55.68,117.09 v1(55.68,117.88)
  BOTTOM w0.127: v1(141.26,135.4) 140.8,134.94 138.97,134.94 137.93,133.9 137.62,133.9 137.27,133.55 137.27,130.98 137.79,130.46 137.79,128.34 R541.1 138.22,127.9 136.45,126.13 136.45,124 U35.A9
USB_OC1#: length 213.8
  TOP w0.127: U20.3 v1(22.66,35.9)
  IN1 w0.089: v1(140.62,135.4) 139.9,136.12 127.99,136.12 127.57,136.54 124.03,136.54 122.32,134.83 118.54,134.83 115.31,138.07 105.47,138.07 104.81,138.73 95.97,138.73 89.93,132.7 86.94,132.7 71.11,116.86 56.06,116.86 v1(55.05,117.88)
  IN2 w0.114: v1(55.05,117.88) 53.27,116.1 53.27,115.34 37.65,99.71 34.18,99.71 32.14,97.68 32.14,74.76 31.17,73.79 31.17,67.58 30.41,66.82 30.41,65.17 27.41,62.17 27.41,43.76 25.23,41.58 25.23,38.22 22.92,35.9 v1(22.66,35.9)
  BOTTOM w0.127: U35.C9 135.86,122.72 135.86,123.88 136.07,124.1 136.07,126.63 R540.1 136.84,128.41 136.84,131.46 136.25,132.05 136.25,133.55 136.86,134.16 137.72,134.16 138.84,135.27 140.49,135.27 v1(140.62,135.4)
USB_OC2#: length 159.5
  IN1 w0.089: v1(183.32,58.72) 183.19,58.85 179.48,58.85 177.79,60.54 177.79,61.68 177.16,62.31 177.16,63.35 171.91,68.6 171.91,69.34 171,70.25 171,71.94 170.37,72.58 170.37,73.05 169.17,74.24 169.17,76.44 168.73,76.88 168.73,80.91 167.19,82.44 167.19,83.18 167.23,83.21 167.23,87.86 168.71,89.34 168.71,90.32 169.33,90.94 169.33,93.88 169.02,94.19 167.62,95.59 167.62,100.65 168.2,101.23 168.2,106.38 162.87,111.71 162.87,114.57 156.98,120.46 151.57,125.88 v1(140.01,125.88)
  IN3 w0.114: v1(212.27,29.54) 213.85,31.12 213.85,43.5 213.29,44.06 213.29,47.26 207.7,52.85 194.37,52.85 192.46,54.76 187.6,54.76 185.18,57.17 184.19,57.17 183.32,58.04 v1(183.32,58.72)
  BOTTOM w0.114: 136.75,123.2 136.42,122.87 136.37,122.82 136.37,122.66 136.49,122.53 136.49,122.31 136.48,122.29 136.48,122.28 136.29,122.1 136.29,122.1 136.16,121.98 U35.D9
  BOTTOM w0.127: 136.75,123.2 137,123.45 137,124.52 137.93,125.45 139.58,125.45 v1(140.01,125.88) 140.26,126.13 R543.1 ; U4511.3 v1(212.27,29.54)
USB_OC3#: length 130.6
  TOP w0.127: R11281.1 v1(34.85,102.25)
  IN1 w0.089: v1(55.68,109.62) 48.06,109.62 41.2,102.76 35.36,102.76 v1(34.85,102.25)
  IN2 w0.114: v1(138.49,125.9) 135.79,125.9 135.03,126.66 132.41,126.66 129.47,123.72 125.91,123.72 123.06,126.58 121.02,126.58 120.71,126.26 120.71,125.5 118.55,123.34 110.29,123.34 109.15,124.48 109.15,126.64 107.24,128.54 102.63,128.54 102.34,128.26 97.81,128.26 96.07,126.51 96.07,125.96 90.37,120.27 88.71,120.27 78.34,109.89 68.22,109.89 67.52,109.2 66.52,109.2 65.51,110.21 57.8,110.21 57.21,109.62 v1(55.68,109.62)
  BOTTOM w0.127: R542.1 139.25,126.66 v1(138.49,125.9) 138.42,125.84 137.56,125.84 136.73,125.01 136.73,123.63 U35.B9
USBCOMP: length 3.6
  TOP w0.127: v3(137.76,113.14) 137.93,113.3 138.77,113.3 139.15,113.68 v1(139.5,113.68) 140,113.68 R178.1
  BOTTOM w0.127: v3(137.76,113.14) 137.76,112.85 U35.AB6
USBON#: length 265.5
  TOP w0.127: v1(27.61,35.43) 25.86,35.43 25.39,35.9 U20.4
  IN1 w0.089: v1(215.45,29.99) 215.96,30.5 215.96,41.12 215.29,41.78 215.29,46.64 212.6,49.32 212.6,49.98 211.51,51.07 211.51,52.22 210.12,53.61 196.01,53.61 195.43,54.19 194.18,54.19 189.92,49.93 v1(189.9,49.93) ; v1(27.61,35.43) 27.61,26.57 35.92,18.26 37.95,18.26 44.05,12.16 55.32,12.16 55.71,11.77 68.45,11.77 71.05,14.37 73.97,14.37 75.65,16.04 75.65,17.89 82.83,25.08 102.77,25.08 103.69,24.16 108.57,24.16 109.15,23.57 118.11,23.57 118.71,24.16 159.03,24.16 163.62,28.75 169.49,28.75 172.27,31.53 172.27,32.51 172.64,32.88 175.75,32.88 176.16,33.29 v1(177.86,33.29)
  IN3 w0.114: v1(177.86,33.29) 178.62,34.06 178.62,37.26 179.72,38.36 179.72,39.22 180.41,39.91 181.27,39.91 182.48,41.12 182.48,41.48 189.84,48.84 190.19,48.84 190.48,49.13 190.48,49.47 190.2,49.75 190.07,49.75 v1(189.9,49.93)
  BOTTOM w0.127: U45.99 173.98,42.18 173.79,42 173.79,40.66 176.92,37.53 176.92,34.23 v1(177.86,33.29) ; v1(215.45,29.99) 215.09,29.99 v1(214.81,29.71) 214.65,29.54 U4511.4
USBP0+: length 245.6
  TOP w0.127: U22.3 18.22,27.96 v1(17.96,28.21)
  IN3 w0.114: v3(135.15,113.11) 135.39,112.87 135.39,112.65 135.59,112.44 138.72,112.44 139.18,111.99 144.43,111.99 145.88,110.54 147.35,110.54 149.41,108.48 149.85,108.48 150.96,107.37 150.96,106.76 153.02,104.69 153.5,104.69 154.52,103.68 155.28,103.68 158.93,100.03 158.93,92.73 158.45,92.25 158.45,90.34 157.82,89.71 157.82,87.55 156.8,86.53 156.8,80.66 153.73,77.59 153.73,67.46 153.96,67.23 153.96,42.16 151.21,39.42 151.21,38.09 149.06,35.94 122.64,35.94 122.13,36.44 108.17,36.44 106.9,35.17 88.99,35.17 81.39,27.58 77.56,27.58 67.6,17.62 59.12,17.62 58.53,17.04 55.17,17.04 54.18,18.03 50.25,18.03 46.82,21.46 37.42,21.46 29.29,29.59 18.63,29.59 18.17,29.12 18.17,28.42 v1(17.96,28.21)
  BOTTOM w0.127: v3(135.15,113.11) 135.15,112.87 U35.AB10
USBP0+_C: length 13.2
  TOP w0.127: R386.2 21.27,15.4 20.76,15.9 20.76,16.28 21.24,16.76 21.62,16.76 21.77,16.61 v1(21.77,16.4) ; v1(18.09,22.88) 18.22,23.01 U22.10
  IN1 w0.089: v1(18.09,22.88) 18.69,22.28 19.66,22.28 20.66,21.29 20.66,16.83 20.91,16.58 21.6,16.58 v1(21.77,16.4)
USBP0+_R: length 9.3
  TOP w0.127: CN16.3 14.42,14.57 14.73,14.88 15.14,14.88 15.37,14.65 15.37,14.07 16.09,13.35 18.21,13.35 18.32,13.24 U24.7 19.74,13.24 19.96,13.03 20.67,13.03 20.95,13.3 20.95,13.92 R386.1
USBP0-: length 245.5
  TOP w0.127: U22.2 18.72,28.09 v1(18.6,28.21)
  IN3 w0.114: v3(135.86,113.11) 135.62,112.87 135.62,112.75 135.69,112.67 138.81,112.67 139.27,112.22 144.53,112.22 145.98,110.76 147.45,110.76 149.5,108.71 149.94,108.71 151.19,107.46 151.19,106.85 153.12,104.92 153.6,104.92 154.62,103.91 155.38,103.91 159.16,100.12 159.16,92.64 158.68,92.15 158.68,90.25 158.04,89.61 158.04,87.45 157.03,86.44 157.03,80.57 153.96,77.5 153.96,67.55 154.18,67.32 154.18,42.06 151.44,39.32 151.44,37.99 149.15,35.71 122.54,35.71 122.03,36.21 108.26,36.21 106.99,34.94 89.08,34.94 81.49,27.35 77.65,27.35 67.7,17.39 59.21,17.39 58.63,16.81 55.08,16.81 54.09,17.8 50.15,17.8 46.72,21.23 37.33,21.23 29.2,29.36 18.73,29.36 18.4,29.03 18.4,28.42 v1(18.6,28.21)
  BOTTOM w0.127: v3(135.86,113.11) 135.86,112.81 U35.AB9
USBP0-_C: length 13.1
  TOP w0.127: v1(21.77,17.29) 21.49,17.01 21.13,17.01 20.5,16.38 20.5,15.52 20.38,15.4 R385.2 ; v1(18.85,22.88) 18.72,23.01 U22.11
  IN1 w0.089: v1(21.77,17.29) 21.77,17.09 21.46,16.77 20.99,16.77 20.85,16.91 20.85,21.37 19.74,22.47 18.77,22.47 18.67,22.57 18.67,22.7 v1(18.85,22.88)
USBP0-_R: length 9.3
  TOP w0.127: CN16.2 14.42,15.42 14.71,15.13 15.25,15.13 15.63,14.75 15.63,14.17 16.19,13.61 16.69,13.61 16.73,13.64 U24.4 17.46,13.64 17.49,13.61 18.47,13.61 18.52,13.55 19.8,13.55 20.06,13.28 20.57,13.28 20.69,13.41 20.69,13.92 R385.1
USBP1+: length 235.4
  TOP w0.127: v1(24.31,32.79) 24.16,32.63 24.16,32.25 23.89,31.99 22.75,31.99 22.51,31.74 22.27,31.74 R348.2
  IN3 w0.114: v1(24.31,32.79) 24.16,32.79 23.82,32.44 23.82,32.27 25.3,30.78 33.37,30.78 41.53,22.63 48.7,22.63 52.13,19.2 57.46,19.2 58.3,18.36 67.29,18.36 77.63,28.7 81.37,28.7 88.57,35.9 106.48,35.9 107.75,37.17 122.55,37.17 123.02,36.7 148.55,36.7 150.3,38.44 150.3,39.77 153.23,42.7 153.23,64.93 152.84,65.32 152.84,81.31 155.07,83.54 155.07,86.46 156.42,87.8 156.42,89.34 157.08,90 157.08,93.86 157.54,94.32 157.54,99.01 153.91,102.64 153.47,102.64 152.18,103.93 151.47,103.93 150.2,105.21 150.2,107.01 149.62,107.59 149.15,107.59 148.06,108.68 146.72,108.68 144.35,111.04 138.91,111.04 138.56,111.4 138.21,111.4 v3(137.74,111.87)
  BOTTOM w0.127: U35.AD7 137.74,111.77 v3(137.74,111.87)
USBP1+_R: length 7.6
  TOP w0.127: R348.1 20.88,31.52 20.56,31.83 20.12,31.83 19.69,31.4 U21.7 18.62,31.4 18.52,31.51 14.86,31.51 14.42,31.07 CN13.3
USBP1-: length 235.4
  TOP w0.127: v1(23.56,32.8) 23.91,32.46 23.91,32.36 23.79,32.24 22.65,32.24 22.4,32 22.19,32 22.04,32.15 R342.2
  IN3 w0.114: v3(138.41,111.87) 139.01,111.27 144.45,111.27 146.81,108.91 148.16,108.91 149.25,107.82 149.71,107.82 150.42,107.11 150.42,105.3 151.57,104.16 152.27,104.16 153.57,102.86 154.01,102.86 157.77,99.11 157.77,94.23 157.31,93.77 157.31,89.9 156.65,89.24 156.65,87.71 155.3,86.36 155.3,83.45 153.07,81.21 153.07,65.42 153.46,65.02 153.46,42.61 150.53,39.68 150.53,38.35 148.65,36.47 122.92,36.47 122.45,36.94 107.84,36.94 106.57,35.67 88.66,35.67 81.46,28.47 77.72,28.47 67.39,18.13 58.2,18.13 57.37,18.97 52.03,18.97 48.6,22.4 41.43,22.4 33.28,30.55 25.21,30.55 23.59,32.17 23.59,32.77 v1(23.56,32.8)
  BOTTOM w0.127: v3(138.41,111.87) 138.09,111.54 U35.AD6
USBP1-_R: length 7.6
  TOP w0.127: CN13.2 15.46,31.76 16.65,31.76 16.69,31.8 U21.4 18.6,31.8 18.72,31.68 19.61,31.68 20.02,32.09 20.56,32.09 20.88,32.4 R342.1
USBP2+: length 159.4
  IN1 w0.089: v1(212.91,19.96) 212.91,19.67 213.29,19.29 213.62,19.29 214.05,19.72 214.05,22.39 215.92,24.25 215.92,28.18 216.59,28.85 216.59,46.3 213.3,49.59 213.3,50.43 212.72,51.01 212.72,51.98 210.43,54.27 196.49,54.27 195.88,54.88 191.95,54.88 191.75,55.09 185.87,55.09 185.63,55.33 182.6,55.33 182.48,55.46 177.3,55.46 173.78,58.98 173.36,58.98 169.68,62.66 169.68,63.07 165,67.75 165,67.76 164.65,68.11 164.65,70 162.85,71.8 162.85,72.55 162.52,72.88 162.52,74.54 162.05,75.01 162.05,75.63 160.47,77.21 160.47,81.53 160.04,81.96 160.04,89.39 160.46,89.81 160.46,104.79 160.08,105.18 158.43,105.18 157.66,105.94 154.87,105.94 153.73,107.08 152.57,107.08 152.16,107.49 144.63,107.49 144.28,107.14 140.57,107.14 140.01,107.7 139.51,108.2 139,108.2 138.91,108.11 138.91,107.59 138.78,107.46 138.59,107.46 138.46,107.59 v3(138.46,107.94)
  BOTTOM w0.076: v3(138.46,107.94) 138.39,108.02 138.39,108.58 138.57,108.77 138.83,108.77 138.99,108.6 139.38,108.6 139.51,108.47 U35.AJ3
  BOTTOM w0.127: v1(212.91,19.96) 212.48,19.53 211.89,19.53 211.77,19.65 CN2020.7
USBP2-: length 159.4
  IN1 w0.089: v1(212.91,19.1) 213.7,19.1 214.24,19.64 214.24,22.31 216.11,24.18 216.11,28.1 216.78,28.77 216.78,46.38 213.49,49.67 213.49,50.51 212.91,51.09 212.91,52.05 210.5,54.46 196.57,54.46 195.95,55.07 192.03,55.07 191.83,55.28 185.95,55.28 185.71,55.52 182.68,55.52 182.56,55.65 177.38,55.65 173.86,59.17 173.44,59.17 169.87,62.74 169.87,63.15 165.19,67.83 165.19,67.84 164.84,68.19 164.84,70.08 163.04,71.88 163.04,72.63 162.71,72.96 162.71,74.62 162.24,75.09 162.24,75.71 160.66,77.29 160.66,81.6 160.23,82.04 160.23,89.31 160.65,89.73 160.65,104.87 160.16,105.37 158.5,105.37 157.74,106.13 154.95,106.13 153.81,107.27 152.65,107.27 152.23,107.68 144.55,107.68 144.2,107.33 140.65,107.33 140.15,107.84 139.59,108.39 138.17,108.39 v3(137.72,107.94)
  BOTTOM w0.076: v3(137.72,107.94) 137.78,108 137.78,108.53 137.98,108.73 138.3,108.73 138.5,108.93 U35.AH3
  BOTTOM w0.127: v1(212.91,19.1) 212.73,19.27 211.89,19.27 211.77,19.15 CN2020.8
USBP3+: length 167.7
  IN1 w0.089: v1(213.8,16.91) 213.8,17.67 215.32,19.2 215.32,22.23 216.78,23.69 216.78,27.52 218.78,29.51 218.78,47.93 215.22,51.48 214.42,51.48 210.42,55.48 197.47,55.48 197.06,55.89 192.23,55.89 192.16,55.96 186.19,55.96 185.98,56.18 183.04,56.18 182.75,56.47 177.81,56.47 176.4,57.88 176.4,58.16 175.27,59.29 174.74,59.29 174.2,59.83 173.81,59.83 171.34,62.31 171.34,62.74 165.5,68.57 165.5,70.43 163.72,72.21 163.72,72.97 163.39,73.3 163.39,74.95 163,75.35 163,75.89 161.32,77.57 161.32,89.26 161.73,89.67 161.73,104.76 160.41,106.08 159.06,106.08 153.65,111.49 153.38,111.49 152,112.87 146.8,112.87 146.22,112.29 138.88,112.29 138.48,112.69 136.03,112.69 135.78,112.44 135.78,112.2 v3(135.6,112.02)
  BOTTOM w0.127: v3(135.6,112.02) 135.48,111.9 U35.AD10 ; v1(213.8,16.91) 213.65,17.06 213.65,17.45 213.29,17.8 212.05,17.8 211.89,17.65 CN2020.11
USBP3-: length 167.7
  IN1 w0.089: v3(136.26,112.02) 136.11,112.02 135.97,112.16 135.97,112.36 136.11,112.5 138.4,112.5 138.8,112.1 146.3,112.1 146.88,112.68 151.92,112.68 153.3,111.3 153.57,111.3 158.98,105.89 160.33,105.89 161.54,104.68 161.54,89.75 161.13,89.34 161.13,77.49 162.81,75.81 162.81,75.27 163.2,74.87 163.2,73.22 163.53,72.89 163.53,72.13 165.31,70.35 165.31,68.49 171.14,62.66 171.14,62.23 173.74,59.64 174.12,59.64 174.66,59.1 175.19,59.1 176.21,58.08 176.21,57.8 177.73,56.28 182.67,56.28 182.96,55.99 185.9,55.99 186.12,55.77 192.08,55.77 192.15,55.7 196.98,55.7 197.39,55.29 210.34,55.29 214.34,51.29 215.14,51.29 218.59,47.85 218.59,29.59 216.59,27.59 216.59,23.77 215.13,22.31 215.13,19.28 213.61,17.75 213.61,17.3 213.21,16.91 v1(212.93,16.91)
  BOTTOM w0.127: U35.AD9 136.13,111.89 v3(136.26,112.02) ; v1(212.93,16.91) 213.19,16.91 213.39,17.11 213.39,17.34 213.19,17.55 212.15,17.55 212.02,17.42 212.02,17.27 211.9,17.15 CN2020.12
USBP4+: length 141.4
  IN1 w0.089: v1(158.04,137.05) 157.71,137.38 157.71,141.29 157.92,141.5 157.92,145.36 157.59,145.69 157.59,155.39 159.57,157.37 159.57,162.71 162.11,165.25 162.11,171.22 164.78,173.88 177.73,173.88 182.24,178.39 187.46,178.39 189.3,180.23 191.45,180.23 193.92,182.71 193.92,188.15 195.43,189.66 195.43,190.6 194.97,191.06 194.46,191.06 v1(194.24,191.28)
  BOTTOM w0.076: 143.69,110.43 143.67,110.43 143.63,110.48 143.43,110.48 142.08,109.13 142.08,108.41 141.51,107.84 140.63,107.84 140.45,108.02 140.2,108.27 U35.AJ2
  BOTTOM w0.127: v1(194.24,191.28) 194.06,191.1 193.4,191.1 193.1,191.41 192.11,191.41 192.01,191.5 CN10.3 ; 143.69,110.43 150.94,110.43 151.27,110.76 157.81,110.76 158.07,110.51 160.69,110.51 163.1,112.92 163.1,118.11 158.55,122.65 158.55,126.62 154.62,130.55 154.62,131.85 157.84,135.07 157.84,136.85 v1(158.04,137.05)
USBP4-: length 141.4
  IN1 w0.089: v1(157.03,137.05) 157.41,137.05 157.52,137.17 157.52,141.37 157.73,141.58 157.73,145.28 157.4,145.61 157.4,155.47 159.38,157.45 159.38,162.79 161.92,165.33 161.92,171.29 164.7,174.07 177.65,174.07 182.16,178.58 187.38,178.58 189.22,180.42 191.37,180.42 193.73,182.79 193.73,188.23 195.24,189.74 195.24,190.52 194.89,190.87 194.46,190.87 v1(194.24,190.65)
  BOTTOM w0.076: 143.69,110.69 143.67,110.69 143.63,110.64 143.36,110.64 141.92,109.2 141.92,108.48 141.45,108.01 140.7,108.01 140.62,108.08 140.62,108.2 140.69,108.27 U35.AJ1
  BOTTOM w0.127: CN10.5 191.95,191 192.11,191.15 192.99,191.15 193.3,190.85 194.04,190.85 v1(194.24,190.65) ; v1(157.03,137.05) 157.23,137.26 157.46,137.26 157.59,137.13 157.59,135.18 154.36,131.95 154.36,130.45 158.3,126.51 158.3,122.55 162.85,118 162.85,113.02 160.58,110.76 158.17,110.76 157.92,111.02 151.16,111.02 150.83,110.69 143.69,110.69
USBP5+: length 108.8
  IN1 w0.089: v1(97.97,131.85) 97.97,131.9 98.37,132.29 98.53,132.29 98.66,132.16 105.78,132.16 106.99,130.96 106.99,130.63 110.29,127.32 110.29,125.81 110.61,125.5 110.61,124.4 112.37,122.64 118.47,122.64 118.81,122.3 118.81,120.92 119.12,120.61 119.48,120.61 120.48,119.62 121.24,119.62 123.29,117.56 125.07,117.56 125.71,116.92 126.87,116.92 128.33,115.46 128.33,114.19 129.27,113.25 132.68,113.25 134.58,111.35 136.72,111.35 136.81,111.44 137.16,111.44 137.37,111.23 137.37,111.04 137.27,110.94 v3(137.13,110.94)
  BOTTOM w0.127: R4.1 119.94,177.82 118.93,177.82 117.91,176.8 117.91,175.66 113.98,171.72 113.98,169.84 110.67,166.54 110.67,164.56 109.53,163.41 109.53,162.83 109.02,162.33 109.02,161.49 108.13,160.6 108.13,159.79 107.4,159.05 107.4,157.78 106.61,156.99 106.61,153.46 103.94,150.79 103.94,150.03 103.18,149.27 103.18,147.85 99.37,144.04 99.37,135.66 98.51,134.79 98.51,132.38 v1(97.97,131.85) ; v3(137.13,110.94) 137.13,110.71 U35.AF7
USBP5-: length 108.8
  IN1 w0.089: v3(137.76,110.8) 137.56,111 137.56,111.31 137.24,111.63 136.73,111.63 136.65,111.54 134.66,111.54 132.76,113.44 129.35,113.44 128.52,114.27 128.52,115.54 126.95,117.11 125.79,117.11 125.15,117.75 123.37,117.75 121.32,119.81 120.55,119.81 119.56,120.8 119.2,120.8 119,121 119,122.38 118.55,122.83 112.45,122.83 110.8,124.48 110.8,125.57 110.48,125.89 110.48,127.4 107.18,130.71 107.18,131.04 105.86,132.35 98.74,132.35 98.61,132.48 v1(97.97,132.48)
  BOTTOM w0.127: R3.1 120.19,178.45 119.82,178.07 118.82,178.07 117.66,176.91 117.66,175.77 113.72,171.83 113.72,169.95 110.42,166.64 110.42,164.66 109.28,163.52 109.28,162.94 108.77,162.43 108.77,161.59 107.88,160.7 107.88,159.89 107.14,159.15 107.14,157.88 106.36,157.1 106.36,153.56 103.69,150.9 103.69,150.13 102.93,149.37 102.93,147.95 99.12,144.14 99.12,135.76 98.25,134.9 98.25,132.76 v1(97.97,132.48) ; v3(137.76,110.8) 137.97,110.8 138.09,110.69 U35.AF6
USBP6+: length 149.6
  IN1 w0.089: v1(128.45,172.89) 128.56,172.99 128.56,173.2 128.42,173.34 126,173.34 124.01,171.34 122.32,171.34 113.43,162.45 113.43,161.91 112.83,161.31 112.83,157.63 112.43,157.22 112.43,156.32 111.12,155.01 111.12,151.99 107.37,148.24 107.37,143.55 108.47,142.45 113.45,142.45 117.5,146.5 123.64,146.5 127.63,142.51 133.28,142.51 135.83,139.96 147.15,139.96 147.96,139.15 151,139.15 153.42,136.73 154.62,136.73 154.72,136.82 154.72,136.95 v1(154.49,137.18)
  BOTTOM w0.076: 143.69,111.2 143.68,111.2 143.64,111.15 143.31,111.15 141.52,109.37 141.4,109.37 141.17,109.14 140.71,109.14 140.61,109.19 140.09,109.19 U35.AH2
  BOTTOM w0.127: R2.1 128.17,172.89 v1(128.45,172.89) ; 143.69,111.2 150.25,111.2 150.93,111.88 150.93,112.14 151.44,112.64 154.49,112.64 155.1,112.03 158.04,112.03 158.43,111.65 160.35,111.65 162.08,113.38 162.08,117.69 157.54,122.23 157.54,126.15 153.35,130.34 153.35,136.65 153.75,137.05 154.36,137.05 v1(154.49,137.18)
USBP6+_R: length 2.8
  BOTTOM w0.127: R2.2 127.29,174.19 127.09,174.39 126.32,174.39 126.19,174.52 125.98,174.52 CN5.14
USBP6-: length 149.5
  IN1 w0.089: v1(154.49,136.32) 154.27,136.54 153.34,136.54 150.92,138.96 147.88,138.96 147.07,139.77 135.75,139.77 133.2,142.32 127.55,142.32 123.56,146.31 117.58,146.31 113.53,142.26 108.39,142.26 107.18,143.47 107.18,148.32 110.93,152.06 110.93,155.09 112.24,156.39 112.24,157.3 112.64,157.71 112.64,161.39 113.24,161.99 113.24,162.53 122.24,171.53 123.93,171.53 125.92,173.53 128.5,173.53 128.66,173.37 v1(128.96,173.37)
  BOTTOM w0.076: 143.69,110.94 143.68,110.94 143.64,110.99 143.38,110.99 141.59,109.2 141.47,109.2 141.24,108.97 140.86,108.97 140.8,108.91 140.8,108.78 140.71,108.69 140.5,108.69 140.44,108.75 140.44,108.88 U35.AH1
  BOTTOM w0.127: v1(154.49,136.32) 154.49,136.54 154.23,136.8 153.85,136.8 153.6,136.54 153.6,130.45 157.79,126.26 157.79,122.34 162.34,117.79 162.34,113.28 160.46,111.4 158.32,111.4 157.94,111.78 155,111.78 154.39,112.39 151.55,112.39 151.19,112.03 151.19,111.78 150.36,110.94 143.69,110.94 ; R1.1 v1(128.96,173.37)
USBP6-_R: length 2.8
  BOTTOM w0.127: CN5.13 126.17,175.04 126.17,174.9 126.42,174.64 127.19,174.64 127.42,174.41 R1.2
USBP7+: length 177.8
  TOP w0.127: v1(65.33,105.46) 65.33,105.51 65.13,105.71 60.72,105.71 57.79,102.79 54.09,102.79 51.6,100.3 49.87,100.3 49.1,101.06 49.1,102.68 48.64,103.14 47.99,103.14 47.53,102.68 47.53,99.27 46.83,98.57 45.84,98.57 45.14,99.27 45.14,101.13 44.61,101.67 43.85,101.67 43.31,101.13 43.31,96.83 42.71,96.24 41.87,96.24 41.27,96.83 41.27,107.17 39.3,109.13 39.3,112.31 38.28,113.33 35.13,113.33 34.22,112.41 27.74,112.41 25.58,114.57 19.61,114.57 19.47,114.43 L69.1 18.74,114.19 R819.1
  IN3 w0.114: v3(135.88,110.94) 135.96,110.94 136.11,111.09 136.11,111.23 135.97,111.37 134.4,111.37 132.35,113.43 128.89,113.43 127.98,114.35 123.79,114.35 121.75,116.38 112.74,116.38 112.1,117.01 107.28,117.01 106.39,117.9 105.24,117.9 104.61,118.54 100.04,118.54 98.82,119.76 96.62,119.76 96.04,119.17 89.24,119.17 87.2,117.14 87.2,112.73 86.82,112.34 86.27,112.34 85.88,112.73 85.88,116.11 85.51,116.48 84.99,116.48 84.61,116.11 84.61,110.8 84.23,110.41 83.68,110.41 83.29,110.8 83.29,113.82 83.02,114.09 82.65,114.09 82.38,113.82 82.38,110.51 81.62,109.75 75.75,109.75 72.35,106.34 67.27,106.34 66.86,105.94 65.72,105.94 65.33,105.56 v1(65.33,105.46)
  BOTTOM w0.127: U35.AF9 135.88,110.65 v3(135.88,110.94)
USBP7-: length 177.8
  TOP w0.127: v1(65.33,106.17) 65.13,105.96 60.61,105.96 57.69,103.04 53.98,103.04 51.49,100.55 49.97,100.55 49.36,101.17 49.36,102.79 48.75,103.4 47.89,103.4 47.28,102.79 47.28,99.38 46.72,98.83 45.95,98.83 45.4,99.38 45.4,101.24 44.71,101.92 43.74,101.92 43.06,101.24 43.06,96.94 42.61,96.49 41.97,96.49 41.52,96.94 41.52,107.27 39.55,109.24 39.55,112.41 38.39,113.58 35.03,113.58 34.11,112.67 27.85,112.67 25.69,114.83 19.61,114.83 19.47,114.98 L69.4 18.74,115.21 R818.1
  IN3 w0.114: v1(65.33,106.17) 66.76,106.17 67.17,106.57 72.25,106.57 75.65,109.98 81.52,109.98 82.15,110.6 82.15,113.92 82.55,114.32 83.12,114.32 83.52,113.92 83.52,110.89 83.77,110.64 84.13,110.64 84.38,110.89 84.38,116.2 84.89,116.71 85.61,116.71 86.11,116.2 86.11,112.82 86.36,112.57 86.72,112.57 86.98,112.82 86.98,117.23 89.14,119.4 95.94,119.4 96.53,119.98 98.91,119.98 100.13,118.76 104.7,118.76 105.34,118.13 106.48,118.13 107.37,117.24 112.2,117.24 112.83,116.61 121.85,116.61 123.88,114.57 128.07,114.57 128.99,113.66 132.44,113.66 134.5,111.6 136.07,111.6 136.34,111.33 136.34,111.11 v3(136.51,110.94)
  BOTTOM w0.127: v3(136.51,110.94) 136.51,110.68 U35.AF8
USBP8+: length 148.3
  IN3 w0.114: v1(149.68,111.91) 149.68,111.6 151,110.27 151,109.3 151.49,108.81 152.36,108.81 156.08,105.09 156.08,104.61 160.18,100.51 160.18,90.62 158.93,89.38 158.93,87.2 157.88,86.15 157.88,80.25 154.69,77.06 154.69,68.14 154.92,67.91 154.92,54.78 155.38,54.32 155.38,49.26 155.1,48.98 155.1,40.72 153.96,39.58 153.96,38.79 149.4,34.23 122.49,34.23 121.25,35.48 113.44,35.48 112.67,34.72 111.01,34.72 110.66,35.07 v1(110.66,35.71)
  BOTTOM w0.076: U35.AG2 140.44,109.87 141.45,109.87 143.24,111.66 143.64,111.66 143.68,111.71 143.69,111.71
  BOTTOM w0.127: v1(110.66,35.71) 111.03,35.34 111.03,34.39 109.81,33.17 109.81,29.84 110.19,29.46 110.19,27.72 R11298.2 ; v1(149.68,111.91) 149.24,112.34 147.94,112.34 147.3,111.71 143.69,111.71
USBP8+_PI3: length 1.4
  BOTTOM w0.127: R11290.1 110.12,26.02 U1006.1
USBP8+_R: length 14.2
  IN3 w0.114: v1(109.91,20.16) 110.2,19.86 110.2,19.29 111.03,18.46 114.18,18.46 v1(114.48,18.15)
  BOTTOM w0.127: v1(109.91,20.16) 110.19,20.44 110.19,22.19 110,22.39 R11302.1 ; v1(114.48,18.15) 114.2,18.43 113.09,18.43 112.66,18.01 EC52.2 112.15,18.43 111.82,18.43 111.59,18.2 111.59,17.05 111.75,16.89 CN95.2
USBP8+_R_COM: length 9.9
  TOP w0.127: v1(109.68,28.68) 110.14,28.22 110.14,21.21 v1(109.68,20.75)
  BOTTOM w0.127: R11300.2 v1(109.68,20.75) ; R11298.1 v1(109.68,28.68)
USBP8+_R_PI3: length 1.4
  BOTTOM w0.127: U1006.7 110.12,23.6 R11302.2
USBP8-: length 148.3
  IN3 w0.114: v1(149.04,111.91) 149.04,111.67 149.18,111.53 149.41,111.53 150.77,110.18 150.77,109.21 151.4,108.58 152.26,108.58 155.85,104.99 155.85,104.51 159.95,100.41 159.95,90.72 158.71,89.47 158.71,87.29 157.65,86.24 157.65,80.34 154.46,77.15 154.46,68.05 154.69,67.82 154.69,54.68 155.15,54.22 155.15,49.35 154.87,49.07 154.87,40.82 153.73,39.68 153.73,38.88 149.31,34.46 122.59,34.46 121.34,35.71 113.34,35.71 112.58,34.94 111.11,34.94 110.89,35.16 110.89,35.31 111.28,35.71 v1(111.56,35.71)
  BOTTOM w0.076: 143.69,111.45 143.68,111.45 143.64,111.5 143.31,111.5 141.52,109.71 141.19,109.71 141.13,109.65 141.13,109.39 141.04,109.3 140.81,109.3 140.65,109.35 140.53,109.35 140.46,109.42 140.46,109.64 140.53,109.71 140.7,109.71 U35.AG1
  BOTTOM w0.127: v1(149.04,111.91) 148.86,112.08 148.04,112.08 147.41,111.45 143.69,111.45 ; v1(111.56,35.71) 111.28,35.43 111.28,34.28 110.06,33.07 110.06,29.94 110.45,29.56 110.45,27.38 110.61,27.21 R11299.2
USBP8-_PI3: length 1.4
  BOTTOM w0.127: U1006.2 110.52,26.02 R11291.1
USBP8-_R: length 14.2
  IN3 w0.114: v1(110.73,20.16) 110.43,19.86 110.43,19.38 111.12,18.69 114.2,18.69 v1(114.48,18.97)
  BOTTOM w0.127: v1(114.48,18.97) 114.2,18.69 113.09,18.69 112.66,19.11 EC53.2 112.03,18.69 111.72,18.69 111.33,18.31 111.33,17.02 111.25,16.94 CN95.3 ; v1(110.73,20.16) 110.45,20.44 110.45,21.88 R11303.1
USBP8-_R_COM: length 9.9
  TOP w0.127: v1(110.95,20.75) 110.39,21.31 110.39,28.12 v1(110.95,28.68)
  BOTTOM w0.127: R11301.2 v1(110.95,20.75) ; R11299.1 v1(110.95,28.68)
USBP8-_R_PI3: length 1.4
  BOTTOM w0.127: R11303.2 110.52,23.6 U1006.6
USBPWR0: length 5.3
  TOP w0.127: C496.2 24.43,28.99 v1(24.49,29.05)
  TOP w0.203: C502.2 16.68,15.27 16.71,15.24 U24.2
  TOP w0.254: 23.54,25.92 24.26,26.64 24.26,27.71 24.43,27.87 C496.2
  TOP w0.381: v1(15.55,15.77) 16.05,15.27 C502.2
  vias: v2(20.25,23.9) v2(20.25,23.13) v2(20.96,23.62) v2(21.67,23.9)
USBPWR1: length 1.7
  TOP w0.203: U21.2 16.67,33.4 16.57,33.3 C462.2
  TOP w0.508: C462.2 15.51,33.3 15.5,33.29 v1(15.47,33.29)
  vias: v1(15.73,35.2) v1(21.27,39.14)
USBPWRD2:
  vias: v1(210.24,26.31)
V_BLIGHT:
  vias: v1(115.12,164.61)
V_POA_Q: length 16
  TOP w0.508: 113.09,31.39 112.33,31.39 R11296.2 111.95,30.14 C3000.2 v1(111.93,29.28) 111.93,28.63 v1(111.97,28.59)
  BOTTOM w0.508: R2855.1 115.8,18.14 115.53,18.4 C3002.2 115.53,24.5 111.97,28.06 v1(111.97,28.59)
V_POA_R: length 7.7
  BOTTOM w0.305: 112.61,14.72 112.25,15.08 CN95.1
  BOTTOM w0.508: 112.61,14.72 114.83,14.72 115.8,15.69 R2855.2 116.52,17.11 v1(116.77,17.36)
VA: length 88.4
  TOP w0.305: v1(155.76,187.9) 155.4,187.55 PR168.1
  IN1 w0.305: v1(155.76,187.9) 155.96,187.9 156.52,187.34 157.94,187.34 158.65,188.06 164.72,188.06 167.54,185.24 168.37,185.24 168.51,185.11 175.32,185.11 176.71,183.71 176.71,183.2 178.11,181.81 178.11,180.99 179.28,179.83 187.81,179.83 188.98,181 191.07,181 192.97,182.9 192.97,192.04 193.35,192.42 194.87,192.42 195.69,191.61 196.75,191.61 196.81,191.66 199.07,191.66 199.9,192.5 226.42,192.5 v1(227.13,191.79)
  vias: v1(229.98,188.82)
VA1: length 8.1
  BOTTOM w0.508: 214.41,192.15 PC133.1 209.48,192.15 209.27,191.94 209.15,191.94
  BOTTOM w0.762: PR5.2 208.25,190.22 208.25,191.4 208.79,191.94 209.15,191.94
  vias: v1(220.38,189.99)
VA2: length 71.5
  TOP w0.305: v1(159.06,187.55) 158.76,187.55 158.54,187.33 PR166.1
  IN3 w0.305: v1(210.11,186.58) 209.63,187.07 205.77,187.07 205.54,186.84 197.72,186.84 187.05,176.17 178.24,176.17 177.37,175.31 163.73,175.31 161.8,177.24 v1(161.17,177.24)
  BOTTOM w0.152: PR210.1 208.76,184.68 210.95,184.68 211.23,184.96
  BOTTOM w0.305: v1(161.17,177.24) 160.99,177.06 160.15,177.06 158.37,178.84 158.37,184.27 159.06,184.96 v1(159.06,187.55)
  vias: v1(211.11,187.52)
VCORE_PHASE: length 5.9
  IN3 w0.508: v2(141.1,161.28) 141.1,161.26 141.66,160.7 141.66,157.45 141.18,156.97 v2(141.18,155.8)
  vias: v1(141.31,151.07) v2(140.82,151.58)
VCORE_SENSE: length 73.6
  TOP w0.127: v1(149.43,174.44) 149.43,174.69 149.23,174.9 PR33.2 ; v1(129.22,134.92) 129.22,135.42 R96.2
  IN3 w0.114: v1(149.43,174.44) 149.43,174.29 149.98,173.74 149.98,171.41 150.42,170.96 150.42,167.38 145.55,162.5 145.55,152.6 146.11,152.04 146.11,143.77 139.53,137.19 131.49,137.19 v1(129.22,134.92) 128.76,134.46 127.27,134.46 122.47,129.66 122.47,122.08 122.74,121.81 122.74,121.53 v3(123.04,121.23)
  BOTTOM w0.127: U35.E32 122.81,120.99 v3(123.04,121.23)
VCORE_VBST:
  vias: v1(140.44,161.97)
VCORE_VCC:
  vias: v1(136.61,161.16) v1(137.32,161.03)
VCORESS_SENSE: length 73.1
  TOP w0.127: R98.1 128.2,135.3 v1(128.58,134.92) ; PR38.2 149.1,173.88 v1(149.43,173.55)
  IN3 w0.114: v1(149.43,173.55) 149.61,173.38 149.61,171.25 150.06,170.81 150.06,167.53 145.18,162.66 145.18,152.44 145.74,151.89 145.74,143.92 139.38,137.56 131.34,137.56 129.18,135.4 129.06,135.4 v1(128.58,134.92) 128.49,134.83 127.12,134.83 122.1,129.81 122.1,121.93 122.37,121.66 122.37,121.49 v3(122.18,121.3)
  BOTTOM w0.127: U35.E33 122.01,121.3 v3(122.18,121.3)
VDD33/18: length 5.4
  TOP w0.203: U15.27 36.5,68.98 36.25,68.73
  TOP w0.254: 36.25,68.73 35.24,67.71 C4598.2 34.74,67.59 34.22,67.08 C4597.2 33.52,66.41 v1(33.74,66.19)
VGA_MBCLK: length 4.2
  TOP w0.102: R582.2 139.39,115.84 139.32,115.77 139.15,115.77 139.12,115.74 136.84,115.74 v3(136.45,115.35)
  BOTTOM w0.127: U35.R9 136.13,115.66 v3(136.45,115.35)
VGA_MBDATA: length 10.2
  BOTTOM w0.127: U35.W2 140.51,113.92 141.27,113.92 142.56,115.22 143.58,115.22 143.59,115.23 144.89,115.23 145.04,115.39 146.36,115.39 v1(146.51,115.23) 146.86,114.89 148.2,114.89 148.65,115.34 R585.2
VGA_VCCSENSE: length 46.7
  IN1 w0.457: v1(173.82,89.25) 173.82,90.04 172.83,91.03 172.83,103.07 174.55,104.79 174.55,105.31 175.78,106.53 183.66,106.53 184.84,107.72 184.84,108.1 187.58,110.84 187.58,114.83 187.25,115.16 187.25,117.07 187.51,117.33 187.51,118.76 186.65,119.63 186.65,120.2 187.18,120.74 v1(187.23,120.74)
  BOTTOM w0.406: PR163.1 v1(175.19,88.41) 174.35,89.25 v1(173.82,89.25) ; v1(187.23,120.74) 187.23,120.75 U3002.L4
VGA_VSSSENSE: length 47.5
  IN1 w0.457: v1(187.23,121.54) 186.98,121.54 185.93,120.5 185.93,119.33 186.8,118.47 186.8,117.62 186.54,117.37 186.54,114.86 186.87,114.53 186.87,111.13 184.13,108.39 184.13,108.01 183.37,107.25 175.48,107.25 173.84,105.6 173.84,105.08 172.12,103.36 172.12,90.73 173.06,89.79 173.06,89.01 173.75,88.31 v1(173.79,88.31)
  BOTTOM w0.406: v1(173.79,88.31) 174.17,87.93 PR162.1 ; v1(187.23,121.54) 187.63,121.93 U3002.L5
VGPU_EN: length 117.5
  TOP w0.127: v1(155.86,70.02) 156.5,70.02 157.28,69.23 161.04,69.23 161.73,68.55 161.73,67.01 163.51,65.23 173.48,65.23 174.16,64.55 181.08,64.55 v1(182.17,63.46) 183.35,62.28 v1(183.35,61.96)
  IN1 w0.089: v1(183.35,61.96) 183.64,62.25 187.38,62.25 188.14,61.49 188.14,60.85 189.01,59.99 191.8,59.99 193.61,58.18 202.11,58.18 207.27,63.34 v1(207.68,63.34) ; v1(155.86,70.02) 156.86,71.02 156.86,75.2 156.37,75.69 156.37,86.13 154.89,87.61 154.89,93.12 155.95,94.17 155.95,95.46 152.2,99.21 151.36,99.21 150.88,99.69 149.31,99.69 148.71,100.29 v1(147.63,100.29) 146.45,100.29 145.84,100.89 140.74,100.89 139.76,101.87 139.12,101.87 138.23,102.76 138.23,104.79 137.85,105.18 137.09,105.18 136.33,105.94 136.33,106.62 v1(135.85,107.11)
  BOTTOM w0.127: U35.AN8 136.15,106.8 v1(135.85,107.11) ; PR253.1 206.91,64.1 v1(207.68,63.34) ; R220.1 147.69,100.22 v1(147.63,100.29) 147.07,100.29 R196.1
VL: length 94.6
  TOP w0.203: PU6010.13 49.56,38.73
  TOP w0.508: PR144.1 51.26,106.05 51.24,106.02 PR146.1 v1(50.01,106.02) ; v1(48.7,37.23) 49.02,37.55 PC6219.2 49.02,38.19 49.56,38.73
  IN1 w0.508: v1(48.7,37.23) 48.7,39.39 48.06,40.02 48.06,45.94 49.18,47.06 49.18,47.57 48.7,48.04 40.75,48.04 38.84,49.96 38.84,52.16 37.5,53.49 37.5,56.68 36.86,57.32 36.86,61.15 37.55,61.84 37.57,61.84 38.77,63.04 40.57,63.04 42.42,64.89 43.49,64.89 46.7,68.11 46.7,70.61 48.1,72.01 48.1,73.96 48.82,74.68 48.82,75.97 45.27,79.52 v1(45.27,90.19)
  BOTTOM w0.508: v1(50.01,106.02) v1(50.01,105.01) 50.01,100.64 48.95,99.59 48.95,93.49 45.65,90.19 v1(45.27,90.19)
VMA_CLK0: length 38.9
  TOP w0.127: v3(197.73,161.82) VRAM3004.J12
  IN1 w0.089: v3(197.73,161.82) 198.01,161.53 198.2,161.53 198.35,161.69 200.81,161.69 201.26,162.14 201.26,162.62 201.77,163.13 202.18,163.13 v1(202.47,163.42)
  IN3 w0.089: v3(197.73,161.82) 197.94,161.6 199.77,161.6 200.83,160.54 200.83,155.12 199.01,153.3 198.17,153.3 189.65,144.79 185.32,144.79 184.66,144.13 184.66,143.44 v3(184.74,143.36)
  BOTTOM w0.127: v3(197.73,161.82) VRAM3004.J12 ; R4526.1 202.53,163.48 v1(202.47,163.42) ; U3002.R30 v3(184.74,143.36)
VMA_CLK0#: length 38.9
  TOP w0.127: v3(197.73,161.02) VRAM3004.J11
  IN1 w0.089: v1(202.47,162.76) 202.27,162.96 201.84,162.96 201.43,162.55 201.43,162.07 200.88,161.52 198.42,161.52 198.27,161.37 198.08,161.37 v3(197.73,161.01)
  IN3 w0.089: v1(183.92,143.38) 184.5,143.96 184.5,144.2 185.25,144.95 189.59,144.95 198.1,153.47 198.94,153.47 200.66,155.19 200.66,160.48 199.7,161.44 198.15,161.44 v3(197.73,161.01)
  BOTTOM w0.127: v3(197.73,161.02) VRAM3004.J11 ; v1(183.92,143.38) 184.28,143.74 U3002.R31 ; v1(202.47,162.76) 202.53,162.7 R4526.2
VMA_CLK1: length 35.9
  TOP w0.127: v1(171.29,161) 171.28,161 VRAM3001.J12
  IN1 w0.089: v1(171.29,161) 171.08,161.21 168.08,161.21 166.99,160.12 166.63,160.12 v1(166.3,159.79)
  IN3 w0.089: v1(171.29,161) 171.72,161.44 173.1,161.44 173.31,161.22 173.31,155.57 173.56,155.32 173.78,155.32 173.96,155.14 173.96,154.88 173.78,154.7 173.38,154.7 173.06,154.37 173.06,153.92 173.38,153.59 173.78,153.59 173.96,153.41 173.96,153.15 173.78,152.97 173.37,152.97 173.06,152.65 173.06,152.21 173.37,151.89 173.78,151.89 173.96,151.71 173.96,151.45 173.78,151.27 173.37,151.27 173.06,150.95 173.06,150.5 173.37,150.19 173.78,150.19 173.96,150.01 173.96,149.75 173.78,149.57 173.48,149.57 173.18,149.27 173.18,148.64 173.57,148.25 174.33,148.25 175.09,147.5 175.09,146.74 175.88,145.94 176.71,145.94 177.27,145.38 177.27,143.97 177.58,143.66 177.76,143.66 v3(178.06,143.36)
  BOTTOM w0.127: v3(178.06,143.36) 178.09,143.36 U3002.AB31 ; VRAM3001.J12 171.28,161 v1(171.29,161) ; v1(166.3,159.79) 166.04,159.52 R4527.1
VMA_CLK1#: length 35.9
  TOP w0.127: VRAM3001.J11 171.29,161.79 v1(171.29,161.79)
  IN1 w0.089: v1(171.29,161.79) 170.87,161.37 168.01,161.37 166.92,160.28 166.44,160.28 v1(166.3,160.42)
  IN3 w0.089: v1(178.06,144.17) 178.06,144.05 177.83,143.82 177.65,143.82 177.44,144.04 177.44,145.45 176.78,146.11 175.95,146.11 175.25,146.81 175.25,147.57 174.4,148.42 173.64,148.42 173.35,148.71 173.35,149.2 173.55,149.4 173.85,149.4 174.13,149.68 174.13,150.07 173.85,150.35 173.44,150.35 173.22,150.57 173.22,150.88 173.44,151.1 173.85,151.1 174.13,151.38 174.13,151.78 173.85,152.05 173.44,152.05 173.22,152.27 173.22,152.58 173.44,152.8 173.85,152.8 174.13,153.08 174.13,153.48 173.85,153.76 173.45,153.76 173.22,153.98 173.22,154.3 173.45,154.53 173.85,154.53 174.13,154.81 174.13,155.2 173.85,155.48 173.63,155.48 173.48,155.64 173.48,161.29 173.17,161.6 171.47,161.6 v1(171.29,161.79)
  BOTTOM w0.127: v1(178.06,144.17) 178.06,144.17 U3002.AC31 ; v1(166.3,160.42) 166.18,160.3 R4527.2 ; VRAM3001.J11 171.29,161.79 v1(171.29,161.79)
VMA_DQ0: length 16.9
  IN1 w0.114: v1(188.08,140.85) 187.31,141.61 187.31,144.29 187.56,144.54 187.56,148.79 191.37,152.59 v3(191.37,154.58)
  BOTTOM w0.152: v3(191.37,154.58) 191.37,154.65 VRAM3000.A4 ; U3002.L28 188.02,140.85 v1(188.08,140.85)
VMA_DQ1: length 15.5
  IN1 w0.114: v3(186.39,141.68) 186.83,142.12 186.83,149.02 189.71,151.89 v3(189.71,154.58)
  BOTTOM w0.152: U3002.M29 186.42,141.68 v3(186.39,141.68) ; v3(189.71,154.58) 189.71,154.59 VRAM3000.A2
VMA_DQ2: length 17
  IN1 w0.114: v3(191.37,155.41) 191.83,154.95 191.83,152.55 187.88,148.6 187.88,144.54 187.57,144.24 187.57,142.12 v1(188.01,141.68)
  BOTTOM w0.152: v3(191.37,155.41) 191.37,155.45 VRAM3000.B4 ; U3002.L29 188.01,141.7 v1(188.01,141.68)
VMA_DQ3: length 17.5
  IN1 w0.114: v1(186.41,140.83) 187.07,141.48 187.07,144.45 187.24,144.62 187.24,148.98 190.12,151.85 190.12,154.97 v3(189.71,155.38)
  BOTTOM w0.152: v3(189.71,155.38) 189.71,155.39 VRAM3000.B2 ; v1(186.41,140.83) 186.41,140.83 U3002.M28
VMA_DQ4: length 19
  IN1 w0.114: v1(185.56,144.12) 185.29,144.39 185.29,145.84 184.97,146.15 184.97,149.31 186.61,150.95 186.61,155.33 188.25,156.97 188.96,156.97 189.37,157.38 190.18,157.38 190.62,157.82 v3(191.28,157.82)
  BOTTOM w0.152: U3002.N31 185.6,144.12 v1(185.56,144.12) ; v3(191.28,157.82) 191.33,157.82 VRAM3000.E4
VMA_DQ5: length 21.5
  IN1 w0.114: v1(185.54,142.49) 185.15,142.88 185.15,143.76 184.84,144.06 184.84,145.16 183.99,146.01 183.63,146.01 183.06,146.58 183.06,147.85 186.3,151.08 186.3,156.1 187.97,157.78 v3(189.71,157.78)
  BOTTOM w0.152: VRAM3000.E2 189.71,157.79 v3(189.71,157.78) ; v1(185.54,142.49) 185.52,142.49 U3002.P29
VMA_DQ6: length 24.2
  IN1 w0.114: v1(183.96,142.52) 183.49,142.99 183.49,144.38 182.43,145.44 182.43,149.24 185.48,152.29 185.48,156.61 188.31,159.44 v3(191.29,159.44)
  BOTTOM w0.152: U3002.R29 183.96,142.46 v1(183.96,142.52) ; v3(191.29,159.44) 191.31,159.44 VRAM3000.F4
VMA_DQ7: length 23.3
  IN1 w0.114: v3(185.58,141.68) 185.58,141.71 184.34,142.95 184.34,145.21 183.86,145.7 183.5,145.7 182.75,146.45 182.75,147.98 185.98,151.21 185.98,156.35 188.23,158.6 189.68,158.6 v3(189.71,158.58)
  BOTTOM w0.152: VRAM3000.F2 189.71,158.59 v3(189.71,158.58) ; U3002.P28 185.57,141.68 v3(185.58,141.68)
VMA_DQ8: length 17.5
  TOP w0.152: v3(196.91,154.59) VRAM3004.U11
  IN1 w0.114: v3(196.91,154.59) 196.33,154.59 190.18,148.44 190.18,146.54 189.61,145.97 189.61,141.78 v1(189.72,141.66)
  BOTTOM w0.152: U3002.J28 189.72,141.63 v1(189.72,141.66)
VMA_DQ9: length 17.2
  TOP w0.152: v3(198.53,154.62) VRAM3004.U13
  IN1 w0.114: v3(198.53,154.62) 197.41,153.49 197.07,153.49 191.39,147.81 191.39,146.85 190.26,145.72 190.26,144.47 190.12,144.34 190.12,143.43 190.58,142.97 v1(190.58,142.5)
  BOTTOM w0.152: v1(190.58,142.5) 190.58,142.5 190.18,142.09 U3002.H29
VMA_DQ10: length 17.5
  TOP w0.152: v3(196.91,155.39) VRAM3004.T11
  IN1 w0.114: v1(188.91,142.51) 189.29,142.9 189.29,146.1 189.79,146.6 189.79,148.51 196.68,155.39 v3(196.91,155.39)
  BOTTOM w0.152: v1(188.91,142.51) 188.91,142.51 U3002.J29
VMA_DQ11: length 19.1
  TOP w0.152: v3(198.53,155.42) VRAM3004.T13
  IN1 w0.114: v3(198.53,155.42) 198.16,155.04 197.57,155.04 197.31,154.78 197.31,154.18 190.49,147.36 190.49,146.41 189.92,145.83 189.92,144.43 189.87,144.37 189.87,143.2 190.16,142.91 190.16,142.08 v1(190.56,141.69)
  BOTTOM w0.152: U3002.H28 190.56,141.67 v1(190.56,141.69)
VMA_DQ12: length 21.4
  TOP w0.152: v3(197.74,157.83) 197.71,157.83 VRAM3004.N11
  IN1 w0.114: v1(191.42,142.45) 191.84,142.86 191.84,145.38 192.77,146.31 192.77,146.84 193.82,147.89 194.17,147.89 199.79,153.51 199.79,156.29 198.67,157.41 198.16,157.41 v3(197.74,157.83)
  BOTTOM w0.152: v1(191.42,142.45) 191.34,142.45 U3002.G29
VMA_DQ13: length 19.8
  TOP w0.152: VRAM3004.N13 199.33,157.82 v3(199.39,157.82)
  IN1 w0.114: v3(199.39,157.82) 199.81,157.4 200.44,157.4 201.31,156.52 201.31,154.13 194.52,147.34 194.52,146.43 v3(192.24,144.14)
  BOTTOM w0.152: U3002.E31 192.24,144.13 v3(192.24,144.14)
VMA_DQ14: length 20.5
  TOP w0.152: VRAM3004.M11 197.71,158.63 v3(197.74,158.63)
  IN1 w0.114: v3(197.74,158.63) 198.16,158.22 198.72,158.22 198.94,158 198.94,157.62 199.97,156.59 200.62,156.59 201,156.2 201,154.27 194.2,147.47 194.2,146.89 192.25,144.94 v1(192.25,144.94)
  BOTTOM w0.152: U3002.E32 192.25,144.92 v1(192.25,144.94)
VMA_DQ15: length 21.7
  TOP w0.152: v3(199.38,158.62) 199.33,158.62 VRAM3004.M13
  IN1 w0.114: v3(199.38,158.62) 199.8,158.2 200.4,158.2 201.63,156.97 201.63,154 194.84,147.21 194.84,146.03 192.67,143.87 192.67,143.74 v3(192.24,143.3)
  BOTTOM w0.152: U3002.F30 192.19,143.3 v3(192.24,143.3)
VMA_DQ16: length 37.5
  IN3 w0.114: v1(196.53,146.98) 198.84,146.98 205.61,153.76 205.61,166.45 204.65,167.41 204.15,167.41 203.2,168.35 202.06,168.35 201.22,169.18 198.7,169.18 v3(197.73,168.22)
  BOTTOM w0.152: v1(196.53,146.98) 196.32,147.19 195.08,147.19 194.33,146.44 U3002.C34 ; v3(197.73,168.22) VRAM3000.U11
