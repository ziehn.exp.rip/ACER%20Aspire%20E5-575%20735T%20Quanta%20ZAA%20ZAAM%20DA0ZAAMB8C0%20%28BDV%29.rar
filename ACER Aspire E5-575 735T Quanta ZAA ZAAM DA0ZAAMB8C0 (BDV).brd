# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A5: length 59.8
  IN3 w0.191: v1(112.68,98.16) 112.68,98.98 112.5,99.16 112.25,99.16 112.04,98.95 112.04,97.83 111.38,97.17 111.38,91.41 109.66,89.68 109.66,78.39 110.33,77.71 110.33,68.85 111.13,68.05 111.5,68.05 112.06,67.5 112.06,62.95 112.83,62.18 112.83,60.36 113.8,59.39 113.8,58.59 113.09,57.88 113.09,54.45 113.24,54.3 113.82,54.3 113.97,54.45 113.97,55.11 114.13,55.26 114.51,55.26 114.69,55.44 114.69,55.85 114.51,56.03 114.13,56.03 113.99,56.17 v1(113.99,56.8)
  BOTTOM w0.076: 113.25,101.47 113.25,101.71 113.71,102.17 U35.AY48
  BOTTOM w0.102: v1(112.68,98.16) 112.68,98.6 113.25,99.18 113.25,101.47
  BOTTOM w0.203: v1(113.99,56.8) 113.97,56.78 JDIM2.126
M_B_A6: length 58.7
  IN3 w0.191: v1(113.31,60.98) 113.31,60.55 113.46,60.4 113.66,60.4 113.81,60.55 113.81,62.63 113,63.44 113,67.89 111.94,68.94 111.94,69.29 112.27,69.62 113.21,69.62 113.36,69.77 113.36,70.19 113.17,70.38 112.4,70.38 112.25,70.53 112.25,70.8 112.4,70.95 113.17,70.95 113.34,71.12 113.34,71.35 113.17,71.52 112.43,71.52 112.28,71.67 112.28,71.94 112.43,72.09 113.17,72.09 113.34,72.26 113.34,72.5 113.17,72.66 112.4,72.66 112.25,72.82 112.25,73.08 112.4,73.23 113.17,73.23 113.34,73.4 113.34,73.64 113.17,73.81 112.43,73.81 112.28,73.96 112.28,74.3 112.58,74.6 112.58,74.81 112.31,75.08 112.31,75.8 111.27,76.84 111.27,78.1 110.6,78.78 110.6,89.38 111.05,89.83 111.05,90.19 111.95,91.08 111.95,96.42 112.1,96.57 112.33,96.57 v1(112.68,96.22)
  BOTTOM w0.076: 113.63,100.38 113.63,100.58 113.98,100.93 113.98,101.19 113.94,101.28 113.94,101.29 113.94,101.51 U35.BA48
  BOTTOM w0.102: 113.63,100.38 113.63,99.02 113.27,98.66 113.27,96.82 v1(112.68,96.22)
  BOTTOM w0.203: JDIM2.127 114.22,62.64 114.69,62.17 114.69,60.88 114.15,60.34 113.47,60.34 113.31,60.5 v1(113.31,60.98)
M_B_A7: length 61.5
  IN3 w0.076: v3(112.99,105.88) 112.99,105.72 112.61,105.33 112.61,103.5 112.71,103.4 112.71,102.89
  IN3 w0.191: v1(112.47,58.07) 112.36,58.18 112.36,58.92 112.49,59.05 112.78,59.05 112.94,59.2 112.94,59.59 112.78,59.74 112.5,59.74 112.36,59.88 112.36,61.99 111.59,62.76 111.59,63.67 111.44,63.82 110.93,63.82 110.78,63.98 110.78,64.38 110.93,64.54 111.46,64.54 111.59,64.66 111.59,65.95 111.28,66.27 111.28,66.57 111.59,66.88 111.59,67.3 111.31,67.58 110.93,67.58 109.86,68.65 109.86,77.52 109.19,78.19 109.19,90.37 109.34,90.52 110.05,90.52 111.09,91.56 111.09,97.33 111.76,98.01 111.76,99.69 111.91,99.84 112.68,99.84 112.86,100.02 112.86,100.78 112.65,100.98 111.97,100.98 111.82,101.14 111.82,101.59 111.97,101.75 112.55,101.75 112.71,101.9 112.71,102.89
  BOTTOM w0.127: U35.AP48 v3(112.99,105.88)
  BOTTOM w0.203: JDIM2.122 112.97,57.57 113.24,57.83 113.24,58.24 112.62,58.85 112.43,58.85 112.17,58.59 112.17,58.37 v1(112.47,58.07)
M_B_A8: length 56.9
  IN3 w0.191: v1(112.68,97.52) 112.16,97.52 111.67,97.03 111.67,91.3 110.58,90.21 110.58,90.03 110.13,89.58 110.13,78.58 110.8,77.91 110.8,76.13 110.97,75.96 111.49,75.96 111.66,75.79 111.66,75.57 111.49,75.39 110.97,75.39 110.8,75.23 110.8,74.99 110.97,74.82 111.66,74.82 111.82,74.67 111.82,74.4 111.66,74.25 110.97,74.25 110.8,74.08 110.8,73.85 110.97,73.68 111.66,73.68 111.82,73.53 111.82,73.26 111.66,73.11 110.97,73.11 110.8,72.94 110.8,72.7 110.97,72.54 111.69,72.54 111.84,72.38 111.84,72.12 111.69,71.96 110.95,71.96 110.8,71.82 110.8,71.53 110.95,71.39 111.66,71.39 111.82,71.24 111.82,70.97 111.66,70.82 110.95,70.82 110.8,70.68 110.8,70.39 110.95,70.25 111.66,70.25 111.82,70.1 111.82,69.83 111.66,69.68 110.97,69.68 110.8,69.51 110.8,69.04 111.32,68.52 111.7,68.52 112.53,67.69 112.53,63.22 113.31,62.43 v1(113.31,62.25)
  BOTTOM w0.102: U35.BB48 113.44,100.82 113.44,99.1 113.08,98.74 113.08,97.91 112.68,97.51 v1(112.68,97.52)
  BOTTOM w0.203: JDIM2.125 113.72,62.66 114.36,62.03 114.36,61 114.17,60.82 113.95,60.82 113.77,61 113.77,61.84 113.36,62.25 v1(113.31,62.25)
M_B_A9: length 56.8
  IN3 w0.076: 111.68,102.72 111.68,105.69 111.79,105.8 v1(112.09,105.8)
  IN3 w0.191: v1(110.95,59.7) 111.23,59.7 111.42,59.89 111.42,61.55 111.18,61.79 110.88,61.79 110.55,62.12 110.55,62.47 109.56,63.46 109.56,64.18 109.84,64.46 109.84,66.96 109.55,67.25 109.2,67.25 108.92,67.53 108.92,77.13 108.25,77.8 108.25,90.62 108.84,91.21 109.56,91.21 109.87,91.52 109.87,97.98 109.53,98.32 109.53,98.72 109.73,98.93 110.28,98.93 111.04,99.69 111.04,102.08 111.68,102.72
  BOTTOM w0.203: v1(110.95,59.7) 111.68,59.7 112.72,60.74 JDIM2.121 ; U35.AP50 v1(112.09,105.8)
M_B_A10: length 60.2
  IN3 w0.191: v1(115.73,94.05) 115.88,93.9 115.88,91.84 116.64,91.08 116.95,91.08 117.63,90.39 117.63,83.64 121.54,79.72 121.54,74.62 121.06,74.13 121.06,64.5 120.55,63.99 120.55,60.09 119.88,59.42 119.88,55.48 120.15,55.21 121.16,55.21 121.49,55.54 v1(121.49,56.82)
  BOTTOM w0.076: U35.AW46 114.94,102.85 115.13,102.66 115.23,102.46 115.23,102.05 115.47,101.81 115.47,99.84 114.81,99.18 114.81,98.83
  BOTTOM w0.102: v1(115.73,94.05) 114.42,95.36 114.42,98.11 114.81,98.5 114.81,98.83
  BOTTOM w0.203: JDIM2.146 120.97,56.27 119.79,57.46 119.79,57.72 119.99,57.93 120.2,57.93 121.31,56.82 v1(121.49,56.82)
M_B_A11: length 62
  IN3 w0.076: v3(112.99,106.5) 112.58,106.09 112.58,105.7 112.44,105.56 112.44,103.65 112.38,103.59 112.38,103.07
  IN3 w0.191: 112.38,103.07 112.38,102.81 111.32,101.76 111.32,99.04 110.96,98.68 110.43,98.68 110.16,98.41 110.16,91.19 109.82,90.85 108.95,90.85 108.72,90.62 108.72,78 109.39,77.32 109.39,68.46 110.31,67.54 110.31,63.38 111.89,61.79 111.89,57.37 111.55,57.03 111.55,54.22 111.75,54.02 112.27,54.02 112.47,54.22 v1(112.47,56.8)
  BOTTOM w0.127: U35.AN48 v3(112.99,106.5)
  BOTTOM w0.203: JDIM2.120 v1(112.47,56.8)
M_B_A12: length 61
  IN3 w0.076: 111.31,103.14 111.5,103.34 111.5,106.32 111.64,106.45 v3(112.09,106.45)
  IN3 w0.191: 111.31,103.14 111.2,103.04 111.2,102.63 110.96,102.39 110.18,102.39 110.04,102.25 110.04,101.87 110.76,101.15 110.76,99.8 110.24,99.28 109.25,99.28 108.95,98.98 108.95,98.75 109.15,98.55 109.15,98.18 108.94,97.97 108.94,91.76 107.78,90.59 107.78,77.27 107.95,77.1 108.29,77.1 108.45,76.93 108.45,76.69 108.29,76.53 107.95,76.53 107.78,76.36 107.78,76.12 107.95,75.96 108.29,75.96 108.45,75.79 108.45,75.55 108.29,75.38 107.95,75.38 107.78,75.22 107.78,74.98 107.95,74.81 108.29,74.81 108.45,74.65 108.45,74.41 108.29,74.24 107.95,74.24 107.78,74.07 107.78,73.84 107.95,73.67 108.29,73.67 108.45,73.5 108.45,73.27 108.29,73.1 107.95,73.1 107.78,72.93 107.78,72.69 107.95,72.53 108.29,72.53 108.45,72.36 108.45,72.12 108.23,71.9 108.03,71.9 107.83,71.7 107.83,71.27 108.45,70.64 108.45,66.25 108.74,65.97 108.74,64.69 109.02,64.41 109.02,63.95 108.74,63.67 108.74,63.35 108.99,63.11 109.25,63.11 110.05,62.3 110.05,61.9 110.34,61.61 110.34,60.98 110.49,60.83 110.76,60.83 v1(110.95,61.02)
  BOTTOM w0.203: JDIM2.119 112.22,62.63 112.1,62.5 111.72,62.5 111.56,62.35 111.56,62.02 111.72,61.87 111.92,61.87 112.07,61.72 112.07,61.51 111.58,61.02 v1(110.95,61.02) ; v3(112.09,106.45) U35.AN50
M_B_A13: length 57
  IN3 w0.076: v1(116.92,95.07) 117.55,95.07 117.92,94.71 117.92,92.86 120.45,90.33
  IN3 w0.191: 120.45,90.33 120.45,84.81 124.36,80.89 124.36,78.87 125.94,77.3 125.94,70.28 125.03,69.37 125.03,64.42 123.65,63.04 123.65,61.2 122.9,60.45 122.9,59.12 123.13,58.88 124.29,58.88 124.45,58.73 124.45,58.47 124.29,58.32 v1(123.68,58.32)
  BOTTOM w0.076: U35.BA43 116.95,101.84 116.95,101.62 117.01,101.47 117.01,101.36 116.96,101.22 116.96,100.97 116.96,100.96 116.96,100.84 117.12,100.67 117.12,100.31 116.9,100.09
  BOTTOM w0.102: v1(116.92,95.07) 116.51,95.48 116.51,98.2 116.13,98.58 116.13,99.08 116.49,99.43 116.49,99.68 116.9,100.09
  BOTTOM w0.203: v1(123.68,58.32) 124.21,58.86 124.53,58.86 124.76,58.62 124.76,58.31 124.42,57.96 124.42,57.03 123.97,56.59 JDIM2.158
M_B_ACT#: length 58.9
  IN3 w0.076: 109.06,102.93 109.06,103.27 108.97,103.36 108.97,105.56 109.35,105.94 109.74,105.94 v1(110.26,106.46)
  IN3 w0.191: 109.06,102.93 109.06,100.39 108.03,99.36 108.03,94.92 107.8,94.69 107.8,92.02 106.37,90.58 106.37,63.31 107.19,62.49 107.19,61.42 107.55,61.06 108.21,61.06 108.64,60.62 108.64,59.58 110.17,58.06 110.17,55.65 110.33,55.49 110.89,55.49 111.08,55.67 v1(111.08,56.8)
  BOTTOM w0.165: v1(110.26,106.46) U35.AN53
  BOTTOM w0.203: JDIM2.114 110.97,56.7 v1(111.08,56.8)
M_B_ALERT#: length 66.4
  IN3 w0.076: 115.14,93.04 115.14,98.72 115.94,99.52 115.94,103.08 115.37,103.65 115.37,105.55 116.16,106.34 116.16,106.79 v1(115.78,107.17)
  IN3 w0.191: 115.14,93.04 115.14,91.74 116.34,90.55 116.34,83.1 118.12,81.32 118.12,78.25 118.44,77.92 118.44,76.4 119.5,75.34 119.5,73.54 119.73,73.31 119.73,60.43 119.06,59.76 119.06,56.03 117.02,53.99 117.02,53.23 116.09,52.3 115.26,52.3 v1(114.28,53.28)
  BOTTOM w0.203: JDIM2.116 111.47,54.41 112.6,53.28 v1(114.28,53.28) ; v1(115.78,107.17) U35.AN43
M_B_BA#0: length 58.7
  IN3 w0.076: v1(115.73,97.86) 116.52,97.07 116.52,92.37 116.8,92.09 117.28,92.09 117.4,91.97
  IN3 w0.191: v1(121.49,58.09) 121.63,58.09 122.01,57.71 122.01,55.42 122.16,55.26 122.43,55.26 122.58,55.42 122.58,58.08 121.96,58.71 121.96,63.35 122.95,64.34 122.95,68.92 123.59,69.55 123.59,75.86 122.95,76.5 122.95,80.31 119.04,84.22 119.04,90.33 117.4,91.97
  BOTTOM w0.076: 115.44,98.72 115.44,99.11 115.96,99.63 115.96,100.98 U35.BB44
  BOTTOM w0.102: 115.44,98.72 115.44,98.15 v1(115.73,97.86)
  BOTTOM w0.203: v1(121.49,58.09) 121.73,57.86 122.03,57.86 122.22,58.04 122.5,58.04 122.74,57.8 122.74,57.35 122.59,57.2 122.13,57.2 121.97,57.04 JDIM2.150
M_B_BA#1: length 59.7
  IN3 w0.076: 117.1,91.84 116.77,91.84 116.35,92.26 116.35,96.41 116.17,96.59 v1(115.73,96.59)
  IN3 w0.191: v1(121.49,60.86) 121.49,63.54 122.48,64.54 122.48,68.52 122,69.01 122,69.34 122.26,69.6 122.95,69.6 123.12,69.76 123.12,70 122.95,70.17 122.17,70.17 122,70.34 122,70.57 122.17,70.74 122.95,70.74 123.12,70.91 123.12,71.14 122.95,71.31 122.17,71.31 122,71.48 122,71.72 122.17,71.88 122.97,71.88 123.12,72.04 123.12,72.3 122.97,72.45 122.17,72.45 122,72.62 122,72.92 122.11,73.03 122.97,73.03 123.12,73.18 123.12,73.47 122.97,73.62 122.38,73.62 122.23,73.78 122.23,73.97 122.38,74.12 122.95,74.12 123.12,74.29 123.12,74.52 122.95,74.69 122.64,74.69 122.48,74.84 122.48,75.11 122.64,75.26 122.95,75.26 123.12,75.43 123.12,75.67 122.95,75.83 122.64,75.83 122.48,75.99 122.48,80.11 118.57,84.03 118.57,90.37 117.1,91.84
  BOTTOM w0.076: 115.25,98.95 115.25,99.15 115.8,99.7 115.8,101.47 U35.BA44
  BOTTOM w0.102: v1(115.73,96.59) 115.12,97.2 115.12,97.81 115.25,97.94 115.25,98.95
  BOTTOM w0.203: v1(121.49,60.86) 121.09,60.86 120.57,60.34 120.33,60.34 120,60.67 120,60.91 120.72,61.63 JDIM2.145
M_B_BG#0: length 60.6
  IN3 w0.076: v3(111.12,105.83) 110.67,105.38 110.67,103.52 110.55,103.4
  IN3 w0.191: v1(109.38,59.66) 109.38,59.51 110.81,58.08 111.08,58.08 111.35,58.36 111.35,58.62 110.41,59.56 109.86,60.11 109.86,61.41 109.53,61.74 109.15,61.74 108.64,62.25 108.64,62.79 108.26,63.17 108.26,65.78 107.98,66.06 107.98,70.45 107.31,71.12 107.31,90.57 108.64,91.9 108.64,99.06 109.14,99.56 110.01,99.56 110.39,99.94 110.39,101.01 109.68,101.72 109.68,102.53 110.55,103.4
  BOTTOM w0.203: v1(109.38,59.66) 109.99,59.66 110.45,60.12 110.45,61.16 111.22,61.94 JDIM2.115 ; U35.AP52 v3(111.12,105.83)
M_B_BG#1: length 60.7
  IN3 w0.076: 109.78,103.4 109.78,105.73 110,105.94 110.29,105.94 110.84,106.48 v3(111.12,106.48)
  IN3 w0.191: v1(109.38,60.98) 108.95,60.98 108.16,61.77 108.16,62.61 107.67,63.09 107.25,63.09 107.05,63.3 107.05,63.62 107.2,63.77 107.66,63.77 107.79,63.9 107.79,64.23 107.66,64.36 106.99,64.36 106.84,64.51 106.84,64.84 107.14,65.15 107.14,65.45 106.84,65.76 106.84,66.25 107.01,66.42 107.37,66.42 107.51,66.56 107.51,66.82 107.35,66.99 107.01,66.99 106.84,67.16 106.84,67.39 107.01,67.56 107.35,67.56 107.51,67.73 107.51,67.97 107.35,68.13 107.01,68.13 106.84,68.3 106.84,68.54 107.01,68.7 107.35,68.7 107.51,68.87 107.51,69.11 107.35,69.28 107.01,69.28 106.84,69.44 106.84,69.68 107.01,69.85 107.35,69.85 107.51,70.02 107.51,70.25 107.35,70.42 107.01,70.42 106.84,70.59 106.84,90.55 108.21,91.92 108.21,94.46 108.33,94.58 108.33,99.15 109.02,99.84 109.78,99.84 110.06,100.12 110.06,100.87 109.82,101.11 109.53,101.11 109.4,101.24 109.4,103.02 109.78,103.4
  BOTTOM w0.203: v1(109.38,60.98) 109.63,60.73 109.92,60.73 110.09,60.89 110.09,61.79 110.24,61.95 110.8,61.95 110.9,62.05 110.9,62.4 110.72,62.58 JDIM2.113 ; U35.AN52 v3(111.12,106.48)
M_B_CAS#: length 61
  IN3 w0.191: v1(116.92,93.8) 117.09,93.8 117.55,93.34 117.55,92.87 119.98,90.44 119.98,84.61 123.89,80.7 123.89,78.68 124.63,77.95 124.63,77.66 124.87,77.41 125.02,77.41 125.47,76.97 125.47,70.48 124.56,69.57 124.56,64.61 123.18,63.23 123.18,61.39 122.43,60.65 122.43,58.9 123.07,58.26 123.07,55.32 123.25,55.14 125.25,55.14 125.43,55.32 125.43,56 125.28,56.15 123.88,56.15 123.68,56.36 v1(123.68,57.05)
  BOTTOM w0.076: 115.88,98.7 115.88,99.08 116.3,99.5 116.3,100.66 116.5,100.85 116.5,101.23 116.45,101.34 116.45,101.46 116.51,101.68 116.51,101.82 116.46,101.98 116.46,102.16 116.54,102.32 116.54,102.42 U35.AY43
  BOTTOM w0.102: 115.88,98.7 115.88,98.57 116.32,98.12 116.32,94.4 v1(116.92,93.8)
  BOTTOM w0.203: JDIM2.156 123.47,56.85 v1(123.68,57.05)
M_B_CB0: length 6
  TOP w0.127: v1(106.36,57.38) 105.72,56.75 v1(105.72,55.65) 105.09,55.01 R10931.2
  BOTTOM w0.127: JDIM2.92 105.47,56.43 105.44,56.46 105.44,56.9 105.92,57.38 v1(106.36,57.38)
M_B_CB1: length 3.9
  TOP w0.127: R10936.2 104.59,60.72 v1(104.32,60.98)
  BOTTOM w0.127: v1(104.32,60.98) 105.22,61.88 JDIM2.91
M_B_CB2: length 4.2
  TOP w0.127: v1(107.65,62.25) 108.79,63.38 R10933.2
  BOTTOM w0.127: JDIM2.101 107.72,62.32 v1(107.65,62.25)
M_B_CB3: length 4.1
  TOP w0.127: R10939.2 111.05,63.01 110.29,62.25 v1(109.38,62.25)
  BOTTOM w0.127: JDIM2.105 108.72,62.67 109.15,62.25 v1(109.38,62.25)
M_B_CB4: length 2.2
  TOP w0.127: v1(104.37,56.75) 104.59,56.53 R10941.2
  BOTTOM w0.127: v1(104.37,56.75) 104.47,56.65 JDIM2.88
M_B_CB5: length 5.1
  TOP w0.127: R10922.2 104.59,59.08 105.09,59.58 105.09,60.73 104.83,60.98 104.83,61.74 v1(104.32,62.25)
  BOTTOM w0.127: v1(104.32,62.25) 104.22,62.35 JDIM2.87
M_B_CB6: length 6
  TOP w0.127: v1(107.65,56.8) 107.65,56.3 v1(107.3,55.95) 105.34,53.99 R10942.2
  BOTTOM w0.127: JDIM2.100 107.47,56.62 v1(107.65,56.8)
M_B_CB7: length 5.3
  TOP w0.127: v1(107.65,58.07) 108.14,58.56 v1(108.36,58.56) 109.77,58.56 R10925.2
  BOTTOM w0.127: JDIM2.104 108.47,57.24 v1(107.65,58.07)
M_B_CKE0: length 55.5
  IN3 w0.076: 108.73,103.14 108.73,103.56 108.81,103.64 108.81,106.12 v3(108.45,106.47)
  IN3 w0.191: v1(107.65,60.36) 107.93,60.08 107.93,59.86 107.75,59.68 107.37,59.68 105.67,61.39 105.67,90.56 106.85,91.74 106.85,98.69 107.78,99.61 107.78,100.88 108.73,101.84 108.73,103.14
  BOTTOM w0.203: JDIM2.109 109.72,62.61 109.91,62.42 109.91,62.13 109.37,61.59 108.49,61.59 107.65,60.75 v1(107.65,60.36) ; v3(108.45,106.47) U35.AN56
M_B_CKE1: length 55.3
  IN3 w0.076: v3(108.41,105.19) 108.01,104.78 108.01,104.29
  IN3 w0.191: v1(109.38,57.41) 107.84,58.95 107.44,58.95 105.2,61.19 105.2,90.56 106.38,91.74 106.38,98.72 107.4,99.74 107.4,101.14 107.78,101.52 107.78,104.06 108.01,104.29
  BOTTOM w0.076: v3(108.41,105.19) 108.41,105.43 108.82,105.84 109.49,105.84 U35.AP55
  BOTTOM w0.203: JDIM2.110 109.97,56.81 v1(109.38,57.41)
M_B_CLK0: length 59.6
  IN3 w0.076: v3(114.81,106.48) 115.21,106.08 115.21,106 115.06,105.85 114.67,105.85 114.3,105.48 114.3,103.32 114.27,103.29 114.27,103.27
  IN3 w0.114: 114.27,103.27 114.27,102.91 115.07,102.11 115.07,101.89 114.75,101.57 114.75,100.92 115.07,100.6 115.27,100.6 115.4,100.48 115.4,99.97 115.25,99.81 114.66,99.81 114.39,99.55 114.39,98.74 114.66,98.48 114.66,98.15 114.29,97.78 114.29,97.21 114.64,96.86 114.64,91.43 115.32,90.75 115.32,82.4 116.65,81.07 116.93,81.07 117.08,80.92 117.08,80.58 116.95,80.45 116.34,80.45 116.08,80.19 116.08,79.63 116.34,79.37 116.92,79.37 117.05,79.24 117.05,78.87 116.92,78.75 116.34,78.75 116.08,78.49 116.08,77.93 116.34,77.67 117.25,77.67 117.4,77.52 117.4,77.2 117.25,77.05 116.72,77.05 116.49,76.82 116.49,76.37 117.34,75.52 117.67,75.52 118.49,74.7 118.49,72.6 118.83,72.26 118.83,69.7 118.49,69.36 118.49,66.3 118.78,66.02 118.78,63.94 118.19,63.36 118.19,62.05 v1(118.91,61.33)
  BOTTOM w0.127: U35.AP45 v3(114.81,106.48) ; v1(118.91,61.33) 118.55,61.69 117.2,61.69 116.84,62.05 116.84,62.5 116.72,62.62 JDIM2.137
M_B_CLK0#: length 59.7
  IN3 w0.076: 114.5,103.27 114.5,103.29 114.47,103.32 114.47,105.41 114.74,105.68 115.12,105.68 115.38,105.93 115.38,106.1 v1(115.78,106.5)
  IN3 w0.114: v1(118.91,62.6) 118.91,62.11 118.78,61.97 118.6,61.97 118.42,62.15 118.42,63.27 119,63.85 119,66.11 118.72,66.4 118.72,69.27 119.06,69.61 119.06,72.35 118.72,72.69 118.72,74.8 117.77,75.75 117.44,75.75 116.72,76.47 116.72,76.72 116.81,76.82 117.35,76.82 117.63,77.1 117.63,77.61 117.35,77.9 116.44,77.9 116.31,78.02 116.31,78.39 116.44,78.52 117.02,78.52 117.28,78.78 117.28,79.34 117.02,79.6 116.44,79.6 116.31,79.73 116.31,80.09 116.44,80.22 117.05,80.22 117.31,80.48 117.31,81.01 117.02,81.3 116.74,81.3 115.55,82.49 115.55,90.84 114.86,91.53 114.86,96.96 114.52,97.3 114.52,97.68 114.89,98.05 114.89,98.57 114.62,98.84 114.62,99.45 114.75,99.58 115.34,99.58 115.63,99.87 115.63,100.57 115.37,100.83 115.16,100.83 114.98,101.02 114.98,101.48 115.3,101.8 115.3,102.2 114.5,103 114.5,103.27
  BOTTOM w0.127: v1(115.78,106.5) U35.AN45 ; JDIM2.139 117.22,62.58 117.1,62.45 117.1,62.15 117.31,61.95 118.77,61.95 118.91,62.09 v1(118.91,62.6)
M_B_CLK1: length 58.8
  IN3 w0.076: v1(113.93,105.83) 113.61,105.83 113.54,105.76 113.54,103.45 113.85,103.14 113.85,102.38 113.88,102.34 113.88,102.33
  IN3 w0.114: v1(117.83,59.34) 118.27,58.9 118.27,58.77 118.19,58.69 117.12,58.69 117.02,58.79 117.02,59.74 117.53,60.25 117.53,63.8 117.76,64.03 117.76,64.92 117.53,65.15 117.53,66.42 117.86,66.75 117.86,67.63 117.53,67.96 117.53,68.37 117.86,68.7 117.86,69.69 118.19,70.02 118.19,71.7 117.86,72.03 117.86,74.12 115.6,76.38 115.6,77.1 115.07,77.64 115.07,78.05 115.46,78.44 115.46,81.08 114.7,81.85 114.7,90.3 114.36,90.64 114.36,94.04 113.8,94.6 113.8,98.88 113.47,99.21 113.47,100.35 114.13,101.01 114.13,101.54 113.88,101.78 113.88,102.33
  BOTTOM w0.127: JDIM2.138 116.97,56.36 117.07,56.46 117.07,57.01 116.64,57.45 116.64,58.55 117.1,59 117.71,59 117.83,59.12 v1(117.83,59.34) ; U35.AP46 v1(113.93,105.83)
M_B_CLK1#: length 58.7
  IN3 w0.076: v3(113.93,106.48) 113.38,105.92 113.38,103.38 113.68,103.08 113.68,102.38 113.65,102.34 113.65,102.33
  IN3 w0.114: 113.65,102.33 113.65,101.69 113.9,101.44 113.9,101.1 113.24,100.44 113.24,99.11 113.57,98.78 113.57,94.51 114.13,93.95 114.13,90.55 114.47,90.2 114.47,81.75 115.23,80.99 115.23,78.54 114.84,78.14 114.84,77.54 115.37,77.01 115.37,76.29 117.63,74.02 117.63,71.93 117.96,71.6 117.96,70.12 117.63,69.79 117.63,68.8 117.3,68.47 117.3,67.87 117.63,67.54 117.63,66.84 117.3,66.51 117.3,65.05 117.53,64.82 117.53,64.12 117.3,63.89 117.3,60.35 116.8,59.84 116.8,58.69 117.02,58.47 117.73,58.47 117.83,58.36 v1(117.83,58.07)
  BOTTOM w0.127: JDIM2.140 117.47,56.34 117.33,56.48 117.33,57.12 116.9,57.55 116.9,58.44 117.2,58.74 117.68,58.74 117.83,58.6 v1(117.83,58.07) ; U35.AN46 v3(113.93,106.48)
M_B_CS#0: length 56.3
  IN3 w0.076: 122.48,90.33 122.48,90.35 121.75,91.08 120.67,91.08 118.89,92.85 118.89,96.96 116.98,98.87 v1(116.75,98.87)
  IN3 w0.191: 122.48,90.33 122.56,90.24 122.56,85.68 126.64,81.6 126.64,81.09 128.05,79.68 128.05,69.41 127.7,69.06 127.7,63.53 126.49,62.32 126.49,59.27 126.17,58.95 125.23,58.95 124.59,59.58 v1(123.68,59.58)
  BOTTOM w0.076: U35.BB42 117.49,100.98 117.49,100.18 117.29,99.98 117.29,99.7 117.15,99.56
  BOTTOM w0.102: 117.15,99.56 116.75,99.17 v1(116.75,98.87)
  BOTTOM w0.203: JDIM2.149 121.72,61.53 v1(123.68,59.58)
M_B_CS#1: length 57.9
  IN3 w0.076: v1(116.92,96.34) 117.63,97.05 117.89,97.05 118.04,96.9 118.04,96.44 117.99,96.39 117.44,96.39 117.33,96.28 117.33,96.07 117.41,95.99 118.11,95.99 118.17,95.93 118.17,95.76 118.11,95.7 117.46,95.7 117.37,95.61 117.37,95.4 117.46,95.31 117.99,95.31 118.16,95.14 118.16,92.85 120.44,90.57 120.94,90.57 121.15,90.36
  IN3 w0.191: v1(124.82,62.05) 124.44,62.05 124.35,62.15 124.35,62.75 125.24,63.65 125.82,63.65 126.11,63.93 126.11,64.28 125.73,64.66 125.73,69.08 126.64,69.99 126.64,77.59 125.95,78.27 125.95,78.48 126.4,78.93 126.4,79.13 126.25,79.28 126.05,79.28 125.6,78.83 125.4,78.83 125.06,79.16 125.06,81.18 121.15,85.09 121.15,90.36
  BOTTOM w0.076: U35.AY42 117.66,102.12 117.66,101.63 117.81,101.26 117.82,101.23 117.82,100.05 117.62,99.85 117.62,99.24
  BOTTOM w0.102: v1(116.92,96.34) 117.62,97.04 117.62,99.24
  BOTTOM w0.203: v1(124.82,62.05) 125.06,62.05 125.24,61.87 125.24,61.63 125.06,61.45 124.6,61.45 124.44,61.28 124.22,61.28 123.92,61.59 123.92,61.8 124.06,61.95 124.18,61.95 124.34,62.11 124.34,62.35 124.19,62.5 123.88,62.5 123.72,62.66 JDIM2.157
M_B_DQ0: length 83.9
  IN3 w0.114: v1(104.41,110.71) 103.3,111.82 102.32,111.82 101.67,112.47 101.67,113 99.9,114.78 92.03,114.78 80.5,103.25 80.5,87.62 83.37,84.75 83.37,84.45 83.22,84.3 82.88,84.3 82.73,84.15 82.73,83.92 82.85,83.8 83.22,83.8 83.37,83.65 83.37,82.32 82.61,81.55 82.61,79.92 82.72,79.81 83.1,79.81 83.25,79.66 83.25,79.43 83.13,79.31 82.72,79.31 82.61,79.2 82.61,61.05 83.53,60.13 83.53,59.1 83.64,58.98 v1(84.14,58.98)
  BOTTOM w0.127: v1(84.14,58.98) 83.91,58.98 83.47,58.55 JDIM2.4 ; v1(104.41,110.71) U35.AF65
M_B_DQ1: length 82.2
  IN3 w0.114: v1(105.06,110.71) 103.64,112.14 102.29,112.14 101.9,112.53 101.9,113.06 99.98,114.98 91.78,114.98 80.18,103.39 80.18,87.48 82.23,85.44 82.23,60.98 83.18,60.02 83.18,58.68 v1(84.15,57.71)
  BOTTOM w0.127: v1(84.15,57.71) 84.64,57.23 84.64,56.66 84.47,56.5 JDIM2.8 ; v1(105.06,110.71) U35.AF64
M_B_DQ2: length 82.9
  IN3 w0.114: v1(103.76,108.88) 102.57,108.88 100.06,111.4 100.06,111.81 98.84,113.02 92.54,113.02 89.97,110.46 89.97,109.65 87.94,107.61 87.94,107.12 82.66,101.83 82.66,88.82 85.93,85.55 85.93,82.46 85.46,82 85.46,76.12 85.58,76.01 85.84,76.01 85.93,75.92 85.93,75.63 85.81,75.51 85.58,75.51 85.46,75.4 85.46,75.13 85.58,75.02 85.81,75.02 85.93,74.9 85.93,74.64 85.81,74.52 85.58,74.52 85.46,74.41 85.46,74.14 85.58,74.03 85.81,74.03 85.93,73.91 85.93,73.62 85.84,73.53 85.58,73.53 85.46,73.42 85.46,73.15 85.58,73.04 85.81,73.04 85.93,72.92 85.93,72.65 85.81,72.54 85.58,72.54 85.46,72.43 85.46,72.16 85.58,72.04 85.81,72.04 85.93,71.93 85.93,71.66 85.81,71.55 85.58,71.55 85.46,71.44 85.46,71.17 85.58,71.05 85.81,71.05 85.93,70.94 85.93,70.67 85.81,70.56 85.58,70.56 85.46,70.44 85.46,70.18 85.58,70.06 85.79,70.06 85.93,69.92 85.93,69.71 85.79,69.57 85.58,69.57 85.46,69.45 85.46,69.15 85.93,68.68 85.93,64.02 86.18,63.77 86.18,61.28 86.5,60.96 86.5,59.5 86.95,59.05 v1(86.95,58.69)
  BOTTOM w0.127: U35.AK65 v1(103.76,108.88) ; v1(86.95,58.69) 86.6,58.69 86.16,58.25 86.16,57.17 86.47,56.86 JDIM2.16
M_B_DQ3: length 83.7
  IN3 w0.114: v1(86.95,60.98) 86.49,61.44 86.49,64.08 86.25,64.33 86.25,77.15 86.84,77.74 86.84,78.4 86.72,78.52 86.1,78.52 85.98,78.64 85.98,78.89 86.1,79.01 86.68,79.01 86.84,79.17 86.84,79.45 86.72,79.56 86.1,79.56 85.98,79.68 85.98,79.94 86.1,80.06 86.68,80.06 86.84,80.21 86.84,80.49 86.68,80.64 86.11,80.64 85.98,80.76 85.98,81.02 86.11,81.14 87.46,81.14 87.59,81.27 87.59,81.49 87.45,81.63 86.04,81.63 85.9,81.78 85.9,81.98 86.04,82.13 86.78,82.13 86.93,82.27 86.93,82.48 86.78,82.62 86.36,82.62 86.25,82.74 86.25,85.68 82.97,88.95 82.97,101.7 88.19,106.92 88.19,107.53 90.2,109.54 90.2,110.32 92.7,112.82 98.69,112.82 99.78,111.74 99.78,111.3 102.62,108.45 104.73,108.45 105.06,108.12 v3(105.06,108.04)
  BOTTOM w0.127: U35.AK64 v3(105.06,108.04) ; v1(86.95,60.98) 87.46,61.49 87.46,62.4 87.72,62.67 JDIM2.21
M_B_DQ4: length 83.2
  IN3 w0.114: v1(83.67,60.94) 83.19,60.94 82.92,61.2 82.92,74.72 83.03,74.82 83.56,74.82 83.69,74.95 83.69,75.32 83.6,75.41 83.04,75.41 82.92,75.52 82.92,75.79 83.04,75.9 83.57,75.9 83.69,76.02 83.69,76.28 83.57,76.4 83.04,76.4 82.92,76.51 82.92,76.78 83.04,76.89 83.57,76.89 83.69,77.01 83.69,77.27 83.57,77.39 83.04,77.39 82.92,77.5 82.92,77.77 83.04,77.88 83.6,77.88 83.69,77.97 83.69,78.26 83.57,78.38 83.04,78.38 82.92,78.49 82.92,78.76 83.04,78.87 83.57,78.87 83.69,78.99 83.69,79.74 83.06,80.37 83.06,81.37 83.69,82 83.69,84.88 80.82,87.75 80.82,103.11 92.28,114.57 99.81,114.57 101.44,112.94 101.44,112.41 102.33,111.53 102.95,111.53 v1(103.76,110.71)
  BOTTOM w0.127: JDIM2.7 84.22,61.49 v1(83.67,60.94) ; v1(103.76,110.71) U35.AF66
M_B_DQ5: length 82.4
  IN3 w0.114: v1(103.11,110.71) 102.68,111.14 102.29,111.14 101.15,112.29 101.15,112.95 99.73,114.37 92.42,114.37 92.13,114.08 92.13,113.96 87.67,109.51 87.67,108.91 86.8,108.04 86.63,108.04 86.52,108.15 86.31,108.15 86.17,108.01 86.17,107.8 86.28,107.69 86.28,107.52 86.1,107.34 85.93,107.34 85.82,107.45 85.61,107.45 85.47,107.31 85.47,107.1 85.58,106.99 85.58,106.82 85.39,106.64 85.23,106.64 85.12,106.75 84.91,106.75 84.77,106.61 84.77,106.4 84.88,106.28 84.88,106.12 84.69,105.93 84.53,105.93 84.42,106.05 84.21,106.05 84.07,105.91 84.07,105.7 84.18,105.58 84.18,105.42 83.99,105.23 83.83,105.23 83.72,105.35 83.51,105.35 83.36,105.21 83.36,105 83.48,104.88 83.48,104.72 83.29,104.53 83.13,104.53 83.01,104.65 82.81,104.65 82.66,104.5 82.66,104.3 82.78,104.18 82.78,104.02 82.59,103.83 82.43,103.83 82.31,103.95 82.11,103.95 81.96,103.8 81.96,103.6 82.08,103.48 82.08,103.32 81.89,103.13 81.73,103.13 81.61,103.25 81.41,103.25 81.26,103.1 81.26,102.9 81.38,102.78 81.38,102.62 81.13,102.37 81.13,87.89 84,85.02 84,72.53 83.89,72.41 83.36,72.41 83.24,72.3 83.24,72.01 83.33,71.92 83.91,71.92 84,71.83 84,71.54 83.89,71.42 83.36,71.42 83.24,71.31 83.24,71.04 83.36,70.93 83.89,70.93 84,70.81 84,70.55 83.89,70.43 83.36,70.43 83.24,70.32 83.24,70.05 83.36,69.94 83.89,69.94 84,69.82 84,69.56 83.89,69.44 83.36,69.44 83.24,69.33 83.24,63.7 83.36,63.59 83.59,63.59 83.68,63.5 83.68,63.18 83.59,63.1 83.36,63.1 83.24,62.98 83.24,62.64 v1(83.67,62.21)
  BOTTOM w0.127: JDIM2.3 83.22,62.66 v1(83.67,62.21) ; v1(103.11,110.71) U35.AF67
M_B_DQ6: length 81.1
  IN3 w0.114: v1(86.95,62.25) 86.95,64.13 86.56,64.52 86.56,66.1 86.77,66.31 87.03,66.31 87.15,66.44 87.15,66.71 87.01,66.85 86.68,66.85 86.56,66.96 86.56,67.23 86.68,67.34 87.04,67.34 87.15,67.46 87.15,67.72 87.04,67.84 86.68,67.84 86.56,67.95 86.56,68.22 86.68,68.33 87.04,68.33 87.15,68.45 87.15,68.71 87.04,68.83 86.68,68.83 86.56,68.94 86.56,69.21 86.68,69.32 87.04,69.32 87.15,69.44 87.15,69.7 87.04,69.82 86.68,69.82 86.56,69.93 86.56,70.2 86.68,70.31 87.04,70.31 87.15,70.43 87.15,70.7 87.04,70.81 86.68,70.81 86.56,70.92 86.56,71.19 86.68,71.3 87.04,71.3 87.15,71.42 87.15,71.69 87.04,71.8 86.68,71.8 86.56,71.91 86.56,72.18 86.68,72.3 87.04,72.3 87.15,72.41 87.15,72.68 87.04,72.79 86.68,72.79 86.56,72.91 86.56,73.17 86.68,73.29 87.04,73.29 87.15,73.4 87.15,73.67 87.04,73.78 86.68,73.78 86.56,73.9 86.56,74.16 86.68,74.28 87.04,74.28 87.15,74.39 87.15,74.66 87.04,74.77 86.68,74.77 86.56,74.89 86.56,75.15 86.68,75.27 87.04,75.27 87.15,75.38 87.15,75.65 87.04,75.76 86.68,75.76 86.56,75.88 86.56,76.14 86.68,76.26 86.96,76.26 87.15,76.45 87.15,76.73 86.95,76.93 86.95,77.39 87.15,77.59 87.15,80.32 87.91,81.07 87.91,82.41 87.69,82.63 87.23,82.63 86.56,83.3 86.56,85.81 83.29,89.08 83.29,101.52 88.45,106.67 88.45,107.41 90.51,109.47 90.51,110.29 92.83,112.62 98.56,112.62 99.55,111.63 99.55,111.17 102.75,107.97 v1(103.11,107.97)
  BOTTOM w0.127: U35.AK67 v1(103.11,107.97) ; JDIM2.17 86.72,62.48 v1(86.95,62.25)
M_B_DQ7: length 81.9
  IN3 w0.114: v1(103.76,107.97) 103.33,107.54 101.96,107.54 101.15,108.35 101.15,109.16 99.29,111.02 99.29,111.53 98.41,112.41 92.94,112.41 90.79,110.26 90.79,109.37 88.8,107.39 88.8,106.58 83.61,101.39 83.61,89.51 86.88,86.24 86.88,83.43 87.36,82.95 87.97,82.95 88.23,82.7 88.23,80.94 87.47,80.19 87.47,56.52 87.08,56.13 86.34,56.13 86.16,56.31 86.16,56.64 v1(86.95,57.42)
  BOTTOM w0.127: JDIM2.20 87.47,56.9 v1(86.95,57.42) ; U35.AK66 v1(103.76,107.97)
M_B_DQ8: length 71.5
  IN3 w0.114: v1(88.7,62.28) 88.42,62.56 88.42,72.2 89.14,72.92 89.14,73.26 89.03,73.37 88.72,73.37 88.6,73.49 88.6,73.75 88.72,73.87 89.08,73.87 89.17,73.96 89.17,74.27 89.08,74.36 88.72,74.36 88.6,74.48 88.6,74.74 88.72,74.86 89.05,74.86 89.17,74.97 89.17,75.24 89.05,75.35 88.72,75.35 88.6,75.47 88.6,75.73 88.72,75.85 89.05,75.85 89.17,75.96 89.17,76.23 89.05,76.34 88.72,76.34 88.6,76.46 88.6,76.73 88.72,76.84 89.05,76.84 89.17,76.95 89.17,77.22 89.05,77.33 88.72,77.33 88.6,77.45 88.6,77.72 88.72,77.83 89.05,77.83 89.17,77.94 89.17,78.21 89.05,78.33 88.72,78.33 88.6,78.44 88.6,78.71 88.72,78.82 89.05,78.82 89.17,78.94 89.17,79.25 89.05,79.37 88.72,79.37 88.6,79.48 88.6,79.75 88.72,79.86 89.08,79.86 89.17,79.95 89.17,85.28 84.55,89.9 84.55,99.51 89.11,104.07 89.11,105.51 89.44,105.84 89.44,107.26 91.34,109.16 91.34,110.11 92.4,111.17 95.64,111.17 95.92,111.45 95.92,111.63 96.07,111.78 97.77,111.78 v1(98.23,111.32)
  BOTTOM w0.076: U35.AF70 100.12,111.27 99.59,111.27 99.14,111.72 98.62,111.72 v1(98.23,111.32)
  BOTTOM w0.127: JDIM2.25 88.72,62.31 v1(88.7,62.28)
M_B_DQ9: length 73.7
  IN3 w0.114: v1(88.7,60.99) 89.14,61.43 89.14,62.76 88.74,63.15 88.74,63.39 88.88,63.53 89.02,63.53 89.14,63.65 89.14,63.89 89,64.03 88.86,64.03 88.74,64.14 88.74,64.41 88.86,64.52 89,64.52 89.14,64.66 89.14,64.9 89.02,65.02 88.86,65.02 88.74,65.13 88.74,65.4 88.86,65.51 89,65.51 89.14,65.65 89.14,65.87 89,66.01 88.86,66.01 88.74,66.12 88.74,66.39 88.86,66.51 89.02,66.51 89.14,66.62 89.14,66.89 89.02,67 88.86,67 88.74,67.11 88.74,67.38 88.86,67.5 89.02,67.5 89.14,67.61 89.14,67.88 89.02,67.99 88.86,67.99 88.74,68.11 88.74,68.37 88.86,68.49 89.02,68.49 89.14,68.6 89.14,68.87 89.02,68.98 88.86,68.98 88.74,69.1 88.74,69.36 88.86,69.48 89.02,69.48 89.14,69.59 89.14,69.86 89.02,69.97 88.86,69.97 88.74,70.09 88.74,70.35 88.86,70.47 89.02,70.47 89.14,70.58 89.14,70.85 89.02,70.96 88.86,70.96 88.74,71.08 88.74,71.34 88.86,71.46 89.02,71.46 89.14,71.57 89.14,72.46 89.48,72.81 89.48,85.41 84.87,90.03 84.87,99.38 89.69,104.2 89.69,107.13 91.62,109.06 91.62,109.87 92.65,110.9 95.9,110.9 v1(96.32,111.32)
  BOTTOM w0.076: v1(96.32,111.32) 96.81,111.81 97.19,111.81 97.44,112.06 99.41,112.06 99.81,111.66 100.5,111.66 101.38,110.77 101.82,110.77 U35.AF68
  BOTTOM w0.127: JDIM2.29 89.72,61.83 88.88,60.99 v1(88.7,60.99)
M_B_DQ10: length 70.8
  IN3 w0.114: v1(97.46,110.14) 97.01,109.7 97.01,107.7 96.83,107.51 95.05,107.51 94.52,106.98 94.52,106.06 94.35,105.89 93.57,105.89 92.77,105.08 92.77,103.88 86.96,98.08 86.96,90.92 91.95,85.93 91.95,85.61 91.84,85.49 91.69,85.49 91.58,85.38 91.58,85.11 91.69,85 91.84,85 91.95,84.88 91.95,84.62 91.84,84.5 91.69,84.5 91.58,84.39 91.58,84.12 91.69,84.01 91.84,84.01 91.95,83.89 91.95,83.63 91.84,83.51 91.69,83.51 91.58,83.4 91.58,83.13 91.69,83.02 91.84,83.02 91.95,82.9 91.95,82.64 91.84,82.52 91.69,82.52 91.58,82.41 91.58,82.14 91.69,82.03 91.84,82.03 91.95,81.91 91.95,81.65 91.84,81.53 91.69,81.53 91.58,81.42 91.58,81.15 91.69,81.04 91.84,81.04 91.95,80.92 91.95,80.66 91.84,80.54 91.69,80.54 91.58,80.43 91.58,80.16 91.69,80.05 91.84,80.05 91.95,79.93 91.95,79.66 91.84,79.55 91.69,79.55 91.58,79.44 91.58,79.17 91.69,79.06 91.84,79.06 91.95,78.94 91.95,78.67 91.84,78.56 91.69,78.56 91.58,78.45 91.58,78.18 91.69,78.06 91.84,78.06 91.95,77.95 91.95,77.68 91.84,77.57 91.69,77.57 91.58,77.46 91.58,77.19 91.69,77.07 91.84,77.07 91.95,76.96 91.95,76.69 91.84,76.58 91.69,76.58 91.58,76.46 91.58,76.2 91.69,76.08 91.84,76.08 91.95,75.97 91.95,75.7 91.84,75.59 91.69,75.59 91.58,75.47 91.58,75.21 91.69,75.09 91.84,75.09 91.95,74.98 91.95,74.71 91.84,74.6 91.69,74.6 91.58,74.48 91.58,74.22 91.69,74.1 91.84,74.1 91.95,73.99 91.95,73.72 91.84,73.61 91.69,73.61 91.58,73.49 91.58,73.23 91.69,73.11 91.84,73.11 91.95,73 91.95,72.73 91.84,72.62 91.69,72.62 91.58,72.5 91.58,72.24 91.69,72.12 91.84,72.12 91.95,72.01 91.95,71.74 91.84,71.63 91.69,71.63 91.58,71.51 91.58,71.24 91.69,71.13 91.84,71.13 91.95,71.02 91.95,70.75 91.84,70.64 91.69,70.64 91.58,70.52 91.58,70.25 91.69,70.14 91.84,70.14 91.95,70.03 91.95,69.71 91.84,69.59 91.69,69.59 91.58,69.48 91.58,69.21 91.69,69.1 91.84,69.1 91.95,68.98 91.95,68.72 91.84,68.6 91.69,68.6 91.58,68.49 91.58,68.22 91.69,68.11 91.86,68.11 91.95,68.02 91.95,67.73 91.84,67.61 91.69,67.61 91.58,67.5 91.58,67.23 91.69,67.12 91.84,67.12 91.95,67 91.95,66.66 91.86,66.57 91.69,66.57 91.58,66.46 91.58,66.19 91.69,66.08 91.84,66.08 91.95,65.96 91.95,65.62 91.86,65.53 91.69,65.53 91.58,65.42 91.58,65.15 91.69,65.03 91.84,65.03 91.95,64.92 91.95,62.38 91.83,62.25 v1(91.6,62.25)
  BOTTOM w0.076: U35.AH71 100.07,109.34 99.49,109.34 99.41,109.42 98.86,109.42 98.75,109.53 98.07,109.53 v1(97.46,110.14)
  BOTTOM w0.127: v1(91.6,62.25) 91.72,62.38 JDIM2.37
M_B_DQ11: length 73.3
  IN3 w0.114: v1(98.73,110.14) 98.73,110.14 100.39,108.48 100.39,106.57 100.2,106.38 100.2,105.09 99.59,104.48 94.26,104.48 87.6,97.81 87.6,91.18 92.59,86.19 92.59,57.3 93.21,56.68 93.21,56.47 92.99,56.25 92.73,56.25 v1(91.59,57.39)
  BOTTOM w0.076: v1(98.73,110.14) 99.12,109.75 99.62,109.75 99.7,109.68 100.31,109.68 100.43,109.62 100.59,109.62 100.75,109.69 100.94,109.69 101.17,109.58 101.57,109.58 101.91,109.23 U35.AH68
  BOTTOM w0.127: JDIM2.38 91.97,56.34 92.05,56.41 92.05,56.93 v1(91.59,57.39)
M_B_DQ12: length 70.8
  IN3 w0.114: v1(88.61,56.77) 88.36,56.77 88.09,57.04 88.09,79.93 88.85,80.68 88.85,85.15 84.23,89.77 84.23,100.85 88.69,105.31 88.69,105.55 89.16,106.01 89.16,107.36 91.05,109.25 91.05,110.21 92.37,111.53 92.72,111.53 93.22,112.03 98.15,112.03 v1(98.86,111.32)
  BOTTOM w0.076: v1(98.86,111.32) 99.19,111.32 99.51,111.01 99.74,111.01 U35.AF71
  BOTTOM w0.127: JDIM2.24 88.47,56.64 v1(88.61,56.77)
M_B_DQ13: length 72.8
  IN3 w0.114: v1(96.96,111.32) 96.27,110.64 92.77,110.64 91.89,109.76 91.89,108.97 90.02,107.11 90.02,106.14 90.46,105.71 90.46,105.3 90.02,104.87 90.02,104.08 88.51,102.57 88.51,102.18 85.18,98.86 85.18,90.16 89.8,85.54 89.8,72.23 89.69,72.12 89.57,72.12 89.45,72 89.45,71.74 89.57,71.62 89.69,71.62 89.8,71.51 89.8,71.19 89.69,71.08 89.57,71.08 89.45,70.96 89.45,70.7 89.57,70.58 89.69,70.58 89.8,70.47 89.8,70.17 89.71,70.09 89.57,70.09 89.45,69.97 89.45,69.7 89.57,69.59 89.71,69.59 89.8,69.5 89.8,69.11 89.47,68.78 89.47,61.31 89.19,61.03 89.19,60.21 88.6,59.62 88.6,58.06 v1(88.61,58.04)
  BOTTOM w0.076: U35.AF69 101.38,110.46 100.35,111.49 99.66,111.49 99.27,111.88 97.52,111.88 v1(96.96,111.32)
  BOTTOM w0.127: JDIM2.28 89.47,57.44 88.87,58.04 v1(88.61,58.04)
M_B_DQ14: length 71.8
  IN3 w0.114: v1(96.82,110.14) 96.7,110.02 96.7,108.1 96.54,107.94 93.88,107.94 93.64,107.7 93.64,106.56 92.26,105.18 92.26,104.72 92.44,104.54 92.44,104 92.16,103.73 91.73,103.73 91.55,103.55 91.55,103.11 86.65,98.21 86.65,90.79 91.43,86 91.43,85.68 91.26,85.51 91.26,68.5 90.94,68.18 90.94,67.91 91.26,67.58 91.26,64.86 91.01,64.61 91.01,64.42 91.13,64.31 91.52,64.31 91.64,64.19 91.64,63.93 91.52,63.81 91.07,63.81 90.93,63.67 90.93,63.44 91.06,63.32 91.51,63.32 91.64,63.19 91.64,62.93 91.51,62.81 91.17,62.81 91.01,62.66 91.01,60.79 90.67,60.44 90.67,59.43 90.77,59.33 90.98,59.33 91.24,59.59 91.24,59.96 91.12,60.09 91.12,60.27 91.6,60.75 v1(91.6,60.95)
  BOTTOM w0.076: v1(96.82,110.14) 97.61,109.35 98.65,109.35 98.74,109.26 99.32,109.26 99.4,109.18 99.81,109.18 100.02,108.97 100.29,108.97 100.43,109.03 100.63,109.03 U35.AH70
  BOTTOM w0.127: v1(91.6,60.95) 91.94,60.95 92.72,61.74 JDIM2.41
M_B_DQ15: length 72.7
  IN3 w0.114: v1(91.59,58.66) 91.17,58.24 90.96,58.24 90.79,58.41 90.79,58.62 92.27,60.1 92.27,86.06 87.28,91.05 87.28,97.95 93.15,103.81 93.15,105.07 93.64,105.56 99.5,105.56 99.75,105.81 99.75,106.57 99.88,106.7 99.88,107.59 99.15,108.32 99.15,109.08 98.09,110.14 v1(98.09,110.14)
  BOTTOM w0.076: v1(98.09,110.14) 98.53,109.71 98.88,109.71 99,109.59 99.5,109.59 99.57,109.51 100.27,109.51 100.4,109.45 100.61,109.45 100.78,109.52 100.9,109.52 101.14,109.41 101.31,109.41 U35.AH69
  BOTTOM w0.127: JDIM2.42 92.97,57.7 92.02,58.66 v1(91.59,58.66)
M_B_DQ16: length 62.2
  IN3 w0.114: v1(94.06,62.31) 94.06,63.77 94.49,64.21 94.49,68.3 94.98,68.79 94.98,70.58 94.47,71.09 94.47,72.01 94.98,72.52 94.98,72.86 94.85,72.99 94.57,72.99 94.42,73.14 94.42,73.46 94.57,73.61 94.82,73.61 94.98,73.76 94.98,74.08 94.82,74.23 94.57,74.23 94.42,74.39 94.42,74.7 94.57,74.86 94.82,74.86 94.98,75.01 94.98,75.33 94.82,75.48 94.57,75.48 94.42,75.63 94.42,75.95 94.57,76.1 94.82,76.1 94.98,76.25 94.98,76.57 94.82,76.72 94.57,76.72 94.42,76.88 94.42,77.19 94.57,77.35 94.82,77.35 94.98,77.5 94.98,77.82 94.82,77.97 94.57,77.97 94.42,78.12 94.42,78.44 94.57,78.59 94.82,78.59 94.98,78.74 94.98,79.06 94.82,79.21 94.57,79.21 94.42,79.36 94.42,79.68 94.57,79.83 94.82,79.83 94.98,79.99 94.98,81.88 94.23,82.63 94.23,86.33 88.86,91.7 88.86,97.17 93.3,101.62 98.39,101.62 100.66,103.89 101.19,103.89 102.46,105.16 v3(102.97,105.16)
  BOTTOM w0.127: JDIM2.45 93.72,62.64 v1(94.06,62.31) ; v3(102.97,105.16) U35.AT66
M_B_DQ17: length 61.7
  IN3 w0.114: v1(94.06,61.02) 94.54,61.51 94.54,63.81 94.81,64.08 94.81,67.61 95.29,68.09 95.29,82.41 94.87,82.83 94.7,82.83 94.54,82.98 94.54,83.3 94.7,83.45 95.14,83.45 95.29,83.61 95.29,83.92 95.14,84.08 94.7,84.08 94.54,84.23 94.54,84.55 94.7,84.7 95.14,84.7 95.29,84.85 95.29,85.17 95.14,85.32 94.7,85.32 94.54,85.47 94.54,86.46 89.17,91.83 89.17,96.98 93.17,100.98 98.23,100.98 100.81,103.56 101.37,103.56 102.33,104.53 v3(102.91,104.53)
  BOTTOM w0.127: JDIM2.49 94.72,61.68 v1(94.06,61.02) ; U35.AU66 v3(102.91,104.53)
M_B_DQ18: length 65
  IN3 w0.076: 104.53,103.78 104.53,104.04 104.22,104.34 104.22,105.42 v3(103.84,105.8)
  IN3 w0.114: v1(97.47,58.6) 96.71,57.84 96.29,57.84 96.09,58.04 96.09,58.46 97.76,60.13 97.76,64.46 97.55,64.66 97.55,65.4 97.83,65.68 97.83,70.43 98.53,71.14 98.53,77.27 98.69,77.42 99.26,77.42 99.41,77.57 99.41,77.77 99.26,77.92 98.65,77.92 98.53,78.03 98.53,78.3 98.65,78.41 99.26,78.41 99.41,78.56 99.41,78.76 99.26,78.91 98.65,78.91 98.53,79.02 98.53,84.9 98.83,85.2 99.24,85.2 99.41,85.36 99.41,85.63 99.27,85.77 98.72,85.77 98.61,85.88 98.61,86.15 98.72,86.26 99.27,86.26 99.41,86.4 99.41,86.62 99.27,86.76 98.72,86.76 98.61,86.87 98.61,87.14 98.72,87.25 99.29,87.25 99.41,87.37 99.41,87.63 99.29,87.75 98.72,87.75 98.61,87.86 98.61,88.13 98.72,88.24 99.12,88.24 99.41,88.54 99.41,91.45 101.07,93.11 101.07,98.75 101.96,99.64 101.96,100.65 102.93,101.62 103.43,101.62 104.53,102.71 104.53,103.78
  BOTTOM w0.127: JDIM2.58 96.97,57.03 96.83,57.17 96.83,58.17 97.27,58.6 v1(97.47,58.6) ; U35.AP65 v3(103.84,105.8)
M_B_DQ19: length 65.6
  IN3 w0.076: v3(103.84,106.45) 104.39,105.9 104.39,104.41 104.74,104.05 104.74,103.86
  IN3 w0.114: v1(97.47,57.33) 97.79,57.02 98.02,57.02 98.23,57.23 98.23,57.42 98.09,57.57 98.09,64.58 97.87,64.79 97.87,65.2 98.15,65.47 98.15,70.3 98.85,71 98.85,71 98.85,76.14 99.73,77.02 99.73,79.32 99.61,79.43 98.96,79.43 98.85,79.54 98.85,79.81 98.96,79.92 99.61,79.92 99.73,80.04 99.73,80.33 99.64,80.42 98.96,80.42 98.85,80.53 98.85,80.8 98.96,80.92 99.64,80.92 99.73,81 99.73,81.3 99.61,81.41 98.94,81.41 98.85,81.5 98.85,81.79 98.96,81.91 99.64,81.91 99.73,82 99.73,82.29 99.61,82.4 98.96,82.4 98.85,82.52 98.85,82.78 98.96,82.9 99.61,82.9 99.73,83.01 99.73,83.28 99.61,83.39 98.96,83.39 98.85,83.51 98.85,83.77 98.96,83.89 99.61,83.89 99.73,84 99.73,84.27 99.61,84.38 98.96,84.38 98.85,84.5 98.85,84.76 98.96,84.88 99.61,84.88 99.73,84.99 99.73,91.32 101.4,92.99 101.4,98.7 102.29,99.59 102.29,100.6 103.05,101.37 103.56,101.37 104.74,102.55 104.74,103.86
  BOTTOM w0.127: v1(97.47,57.33) 97.92,56.88 97.92,56.47 97.97,56.41 JDIM2.62 ; v3(103.84,106.45) U35.AN65
M_B_DQ20: length 64.3
  IN3 w0.114: v1(94,56.8) 93.21,57.58 93.21,86.45 88.22,91.44 88.22,97.56 94.52,103.86 99.95,103.86 100.93,104.83 100.93,105.77 101.72,106.56 102.38,106.56 v3(102.91,107.09)
  BOTTOM w0.127: v1(94,56.8) 93.97,56.77 JDIM2.46 ; U35.AN66 v3(102.91,107.09)
M_B_DQ21: length 63.6
  IN3 w0.114: v1(94,58.07) 93.75,58.31 93.7,58.31 93.53,58.49 93.53,86.58 88.54,91.57 88.54,97.42 94.51,103.4 95.81,103.4 95.97,103.55 100.04,103.55 v3(102.97,106.48)
  BOTTOM w0.127: U35.AP66 v3(102.97,106.48) ; JDIM2.50 94.97,57.37 94.28,58.07 v1(94,58.07)
M_B_DQ22: length 63.7
  IN3 w0.076: v3(103.84,104.5) 103.84,104.47 104.31,103.99 104.31,103.65
  IN3 w0.114: v1(96.8,61.05) 97.43,61.68 97.43,64.34 97.24,64.53 97.24,65.42 97.08,65.58 97.08,65.89 97.2,66.01 97.4,66.01 97.51,66.12 97.51,66.39 97.4,66.5 97.2,66.5 97.08,66.62 97.08,66.89 97.2,67 97.4,67 97.51,67.11 97.51,67.38 97.4,67.49 97.2,67.49 97.08,67.61 97.08,67.88 97.2,67.99 97.4,67.99 97.51,68.1 97.51,68.37 97.4,68.49 97.2,68.49 97.08,68.6 97.08,68.87 97.2,68.98 97.4,68.98 97.51,69.1 97.51,69.36 97.4,69.48 97.2,69.48 97.08,69.59 97.08,70.14 98.19,71.24 98.19,74 98.08,74.11 97.83,74.11 97.72,74.23 97.72,74.5 97.83,74.61 98.08,74.61 98.19,74.72 98.19,74.99 98.08,75.11 97.83,75.11 97.72,75.22 97.72,75.49 97.83,75.6 98.08,75.6 98.19,75.72 98.19,75.98 98.08,76.1 97.83,76.1 97.72,76.21 97.72,76.48 97.83,76.59 98.08,76.59 98.19,76.71 98.19,76.97 98.08,77.09 97.83,77.09 97.72,77.2 97.72,77.47 97.83,77.58 98.08,77.58 98.19,77.7 98.19,77.96 98.08,78.08 97.83,78.08 97.72,78.19 97.72,78.46 97.83,78.57 98.08,78.57 98.19,78.69 98.19,78.95 98.08,79.07 97.83,79.07 97.72,79.18 97.72,79.45 97.83,79.56 98.08,79.56 98.19,79.68 98.19,79.94 98.08,80.06 97.83,80.06 97.72,80.17 97.72,80.44 97.83,80.55 98.08,80.55 98.19,80.67 98.19,80.93 98.08,81.05 97.83,81.05 97.72,81.16 97.72,81.43 97.83,81.54 98.08,81.54 98.19,81.66 98.19,81.93 98.08,82.04 97.83,82.04 97.72,82.15 97.72,82.42 97.83,82.54 98.08,82.54 98.19,82.65 98.19,82.92 98.08,83.03 97.83,83.03 97.72,83.14 97.72,83.41 97.83,83.53 98.08,83.53 98.19,83.64 98.19,83.91 98.08,84.02 97.83,84.02 97.72,84.14 97.72,84.4 97.83,84.52 98.08,84.52 98.19,84.63 98.19,84.9 98.08,85.01 97.83,85.01 97.72,85.13 97.72,85.39 97.83,85.51 98.08,85.51 98.19,85.62 98.19,85.89 98.08,86 97.83,86 97.72,86.12 97.72,86.38 97.83,86.5 98.08,86.5 98.19,86.61 98.19,86.88 98.08,86.99 97.83,86.99 97.72,87.11 97.72,87.37 97.83,87.49 98.08,87.49 98.19,87.6 98.19,88.27 98.51,88.59 98.85,88.59 99.09,88.83 99.09,91.58 100.18,92.67 100.18,98.62 101.02,99.46 101.02,100.76 101.38,101.11 102.06,101.11 102.83,101.87 103.31,101.87 104.31,102.88 104.31,103.65
  BOTTOM w0.127: JDIM2.63 98.22,62.12 97.15,61.05 v1(96.8,61.05) ; U35.AT65 v3(103.84,104.5)
M_B_DQ23: length 62.7
  IN3 w0.114: v3(103.92,103.85) 104.04,103.72 104.04,103.01 103.29,102.25 102.04,102.25 100.71,100.93 100.71,99.66 99.85,98.8 99.85,92.81 98.76,91.71 98.76,89.33 97.4,87.97 97.4,87.69 97.25,87.54 96.87,87.54 96.75,87.42 96.75,87.15 96.87,87.04 97.25,87.04 97.4,86.89 97.4,86.7 97.25,86.54 96.87,86.54 96.75,86.43 96.75,86.16 96.87,86.05 97.25,86.05 97.4,85.9 97.4,85.71 97.25,85.55 96.87,85.55 96.75,85.44 96.75,85.17 96.87,85.06 97.25,85.06 97.4,84.91 97.4,84.72 97.25,84.56 96.87,84.56 96.75,84.45 96.75,84.18 96.87,84.07 97.25,84.07 97.4,83.92 97.4,83.73 97.25,83.57 96.87,83.57 96.75,83.46 96.75,83.19 96.87,83.08 97.25,83.08 97.4,82.93 97.4,82.73 97.25,82.58 96.87,82.58 96.75,82.47 96.75,82.2 96.87,82.09 97.25,82.09 97.4,81.93 97.4,81.74 97.25,81.59 96.87,81.59 96.75,81.48 96.75,81.21 96.87,81.1 97.25,81.1 97.4,80.94 97.4,80.75 97.25,80.6 96.87,80.6 96.75,80.49 96.75,80.22 96.87,80.11 97.25,80.11 97.4,79.95 97.4,79.76 97.25,79.61 96.87,79.61 96.75,79.5 96.75,79.23 96.87,79.12 97.25,79.12 97.4,78.96 97.4,78.77 97.25,78.62 96.87,78.62 96.75,78.51 96.75,78.24 96.87,78.12 97.25,78.12 97.4,77.97 97.4,77.78 97.25,77.63 96.87,77.63 96.75,77.52 96.75,77.25 96.87,77.13 97.25,77.13 97.4,76.98 97.4,76.79 97.25,76.64 96.87,76.64 96.75,76.52 96.75,76.26 96.87,76.14 97.25,76.14 97.4,75.99 97.4,75.8 97.25,75.65 96.87,75.65 96.75,75.53 96.75,75.27 96.87,75.15 97.25,75.15 97.4,75 97.4,74.12 97.21,73.93 97.21,73.6 97.36,73.45 97.76,73.45 97.87,73.33 97.87,73.07 97.76,72.95 97.31,72.95 97.16,72.81 97.16,72.6 97.31,72.46 97.76,72.46 97.87,72.34 97.87,72.08 97.76,71.96 97.47,71.96 96.77,71.26 96.77,67.01 96.28,66.53 96.28,63.35 96.8,62.83 v1(96.8,62.32)
  BOTTOM w0.127: v1(96.8,62.32) 97.03,62.32 97.22,62.51 JDIM2.59 ; U35.AU65 v3(103.92,103.85)
M_B_DQ24: length 54.5
  IN3 w0.076: 105.05,101.86 105.26,102.07 105.26,104 105.69,104.44 v3(105.69,104.56)
  IN3 w0.114: v1(100.41,60.85) 100.01,60.85 99.43,61.43 99.43,67.52 100.11,68.2 100.11,75.62 100.98,76.5 100.98,83.85 101.46,84.32 101.46,84.75 101.29,84.92 101.15,84.92 101.01,85.06 101.01,85.27 101.15,85.41 101.32,85.41 101.46,85.55 101.46,85.77 101.32,85.91 101.15,85.91 101.01,86.05 101.01,86.26 101.15,86.4 101.32,86.4 101.46,86.54 101.46,86.76 101.32,86.9 101.15,86.9 101.01,87.04 101.01,87.25 101.15,87.39 101.34,87.39 101.46,87.51 101.46,87.78 101.34,87.89 101.15,87.89 101.01,88.03 101.01,88.25 101.15,88.39 101.32,88.39 101.46,88.52 101.46,88.74 101.32,88.88 101.15,88.88 101.01,89.02 101.01,89.24 101.15,89.38 101.32,89.38 101.46,89.52 101.46,89.73 101.32,89.87 101.15,89.87 101.01,90.01 101.01,90.23 101.15,90.37 101.34,90.37 101.46,90.48 101.46,91.27 103.18,92.99 103.18,98.83 103.94,99.59 103.94,100.75 105.05,101.86
  BOTTOM w0.127: v1(100.41,60.85) 99.9,60.85 99.22,61.53 JDIM2.67 ; U35.AT61 v3(105.69,104.56)
M_B_DQ25: length 53.7
  IN3 w0.076: 105.43,101.93 105.43,103.01 105.69,103.28 v3(105.69,103.89)
  IN3 w0.114: v1(100.41,62.12) 99.88,62.12 99.75,62.25 99.75,62.62 99.86,62.73 100.27,62.73 100.43,62.89 100.43,63.07 100.27,63.23 99.86,63.23 99.75,63.34 99.75,63.61 99.86,63.72 100.27,63.72 100.43,63.88 100.43,64.06 100.27,64.22 99.86,64.22 99.75,64.33 99.75,67.39 100.43,68.06 100.43,75.49 101.77,76.84 101.77,77.2 101.58,77.39 101.42,77.39 101.3,77.51 101.3,77.78 101.42,77.89 101.63,77.89 101.77,78.03 101.77,78.24 101.63,78.38 101.42,78.38 101.3,78.5 101.3,78.77 101.42,78.88 101.66,78.88 101.77,78.99 101.77,79.26 101.66,79.38 101.42,79.38 101.3,79.49 101.3,79.76 101.42,79.87 101.66,79.87 101.77,79.98 101.77,80.25 101.66,80.37 101.42,80.37 101.3,80.48 101.3,80.75 101.42,80.86 101.66,80.86 101.77,80.98 101.77,81.24 101.66,81.36 101.42,81.36 101.3,81.47 101.3,81.74 101.42,81.85 101.66,81.85 101.77,81.97 101.77,82.23 101.66,82.35 101.42,82.35 101.3,82.46 101.3,82.73 101.42,82.84 101.66,82.84 101.77,82.96 101.77,83.22 101.66,83.34 101.42,83.34 101.3,83.45 101.3,83.72 101.42,83.83 101.66,83.83 101.77,83.95 101.77,91.14 103.56,92.92 103.56,98.7 104.2,99.33 104.2,100.7 105.43,101.93
  BOTTOM w0.127: JDIM2.71 100.22,62.31 v1(100.41,62.12) ; U35.AU61 v3(105.69,103.89)
M_B_DQ26: length 56.9
  IN3 w0.076: 107.26,103.77 107.26,104.04 107,104.3 107,105.44 v3(106.62,105.83)
  IN3 w0.114: 107.26,103.77 107.26,101.85 106.23,100.82 106.23,99.46 105.6,98.83 105.6,91.84 103.87,90.11 103.87,75.28 103.75,75.17 103.47,75.17 103.36,75.06 103.36,74.79 103.47,74.67 103.75,74.67 103.87,74.56 103.87,74.29 103.75,74.18 103.47,74.18 103.36,74.07 103.36,73.8 103.47,73.68 103.75,73.68 103.87,73.57 103.87,73.28 103.78,73.19 103.47,73.19 103.36,73.07 103.36,72.81 103.47,72.69 103.75,72.69 103.87,72.58 103.87,72.31 103.75,72.2 103.47,72.2 103.36,72.08 103.36,71.82 103.47,71.7 103.75,71.7 103.87,71.59 103.87,71.32 103.75,71.21 103.47,71.21 103.36,71.09 103.36,70.83 103.47,70.71 103.75,70.71 103.87,70.6 103.87,70.33 103.75,70.22 103.47,70.22 103.36,70.1 103.36,69.84 103.47,69.72 103.75,69.72 103.87,69.61 103.87,69.34 103.75,69.23 103.47,69.23 103.36,69.11 103.36,68.85 103.47,68.73 103.78,68.73 103.87,68.64 103.87,68.32 103.78,68.24 103.47,68.24 103.36,68.12 103.36,67.86 103.47,67.74 103.78,67.74 103.87,67.65 103.87,67.38 103.61,67.12 103.61,66.82 103.87,66.57 103.87,66.32 103.36,65.81 103.36,64.41 103.24,64.29 102.67,64.29 102.52,64.15 102.52,63.94 102.67,63.8 103.23,63.8 103.37,63.65 103.37,63.45 103.23,63.3 102.67,63.3 102.52,63.16 102.52,62.95 102.67,62.81 103.24,62.81 103.36,62.69 103.36,62.38 103.23,62.25 v1(102.93,62.25)
  BOTTOM w0.127: JDIM2.83 103.22,62.55 v1(102.93,62.25) ; U35.AP60 v3(106.62,105.83)
M_B_DQ27: length 57.4
  IN3 w0.076: v3(106.62,106.48) 107.17,105.93 107.17,104.39 107.49,104.07 107.49,103.69
  IN3 w0.114: v1(102.97,58.65) 103.94,58.65 104.07,58.78 104.07,59.05 103.92,59.2 102.93,59.2 102.8,59.33 102.8,59.56 102.95,59.71 104.04,59.71 104.19,59.86 104.19,60.07 103.69,60.57 103.69,65.69 104.19,66.19 104.19,89.98 105.89,91.68 105.89,98.83 106.48,99.42 106.48,100.68 107.49,101.68 107.49,103.69
  BOTTOM w0.127: v3(106.62,106.48) U35.AN60 ; v1(102.97,58.65) 102.33,58.01 102.33,56.5 102.47,56.36 JDIM2.80
M_B_DQ28: length 56.6
  IN3 w0.076: v3(105.68,106.5) 105.58,106.5 105.15,106.07 105.15,104.39 104.93,104.18 104.93,102.35 104.67,102.09
  IN3 w0.114: v1(98.75,58.15) 98.75,59.09 98.77,59.11 98.77,67.76 99.47,68.46 99.47,68.69 99.27,68.89 99.1,68.89 98.96,69.03 98.96,69.25 99.1,69.39 99.32,69.39 99.47,69.54 99.47,69.73 99.32,69.88 99.1,69.88 98.96,70.02 98.96,70.24 99.1,70.38 99.32,70.38 99.47,70.53 99.47,75.88 100.35,76.76 100.35,91.06 101.99,92.7 101.99,98.65 103.49,100.15 103.49,100.91 104.67,102.09
  BOTTOM w0.127: U35.AN61 v3(105.68,106.5) ; JDIM2.70 99.97,56.34 99.42,56.9 99.42,57.81 99.08,58.15 v1(98.75,58.15)
M_B_DQ29: length 55.7
  IN3 w0.076: v1(105.69,105.86) 105.44,105.86 105.31,105.73 105.31,104.31 105.1,104.09 105.1,102.21 104.9,102.01
  IN3 w0.114: v1(98.77,56.88) 99.2,56.45 99.54,56.45 99.82,56.73 99.82,57.07 99.19,57.7 99.19,58.82 99.11,58.9 99.11,67.65 99.79,68.33 99.79,75.75 100.67,76.63 100.67,90.93 102.29,92.55 102.29,98.44 103.71,99.87 103.71,100.83 104.9,102.01
  BOTTOM w0.127: JDIM2.66 98.97,56.67 v1(98.77,56.88) ; U35.AP61 v1(105.69,105.86)
M_B_DQ30: length 56.4
  IN3 w0.076: 107,103.41 107,104.04 106.62,104.43 v3(106.62,104.52)
  IN3 w0.114: 107,103.41 107,101.99 105.97,100.96 105.97,99.49 105.34,98.86 105.34,92.03 103.55,90.24 103.55,76.09 103.04,75.58 103.04,70.72 102.93,70.6 102.37,70.6 102.26,70.49 102.26,70.22 102.37,70.11 102.93,70.11 103.04,70 103.04,69.73 102.93,69.61 102.37,69.61 102.26,69.5 102.26,69.23 102.37,69.12 102.93,69.12 103.04,69 103.04,68.74 102.93,68.62 102.37,68.62 102.26,68.51 102.26,68.24 102.37,68.13 102.93,68.13 103.04,68.01 103.04,67.75 102.93,67.63 102.37,67.63 102.26,67.52 102.26,67.25 102.37,67.14 102.93,67.14 103.04,67.02 103.04,66.76 102.93,66.64 102.37,66.64 102.26,66.53 102.26,66.26 102.37,66.15 102.93,66.15 103.04,66.03 103.04,65.67 102.67,65.3 102.47,65.3 102.2,65.03 102.2,61.19 102.42,60.98 v1(102.93,60.98)
  BOTTOM w0.127: JDIM2.79 102.22,61.68 v1(102.93,60.98) ; U35.AT60 v3(106.62,104.52)
