# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INT_HDMITX2N_C_R: length 3.8
  TOP w0.127: U18.30 22.11,49.03 22.23,48.91 22.53,48.91 23.04,49.42 23.42,49.42 v1(23.93,49.93) 24.06,49.8 C408.2
INT_HDMITX2P: length 138.3
  TOP w0.127: v1(26.6,48.91) 26.35,49.17 25.97,49.17 C411.1
  IN3 w0.114: v1(110.29,120.67) 110.09,120.87 110.09,121.6 108.07,123.63 101.69,123.63 100.74,124.58 83.53,124.58 70.19,111.25 61.33,111.25 39.99,89.9 39.99,77.86 39.27,77.15 39.27,76.38 40.11,75.53 40.11,72.33 37.24,69.46 36.61,69.46 33.74,66.59 33.74,66.03 33.11,65.4 32.55,65.4 31.04,63.89 31.04,63.11 29.68,61.74 29.2,61.74 25.71,58.26 25.71,53.99 25.36,53.64 25.36,49.46 25.74,49.07 26.45,49.07 v1(26.6,48.91)
  BOTTOM w0.127: v1(110.29,120.67) 109.96,120.34 U35.F55
INT_HDMITX2P_C: length 10.2
  TOP w0.127: U18.12 15.38,48.53 15.12,48.79 14.67,48.79 R315.1 v1(13.81,48.65)
  IN3 w0.114: CN12.1 10.37,46 11.04,45.33 12.25,45.33 12.98,46.06 12.98,48.72 13.25,48.99 13.65,48.99 13.81,48.83 v1(13.81,48.65)
INT_HDMITX2P_C_R: length 3.8
  TOP w0.127: U18.29 22.11,48.53 22.23,48.65 22.63,48.65 23.15,49.17 23.42,49.17 v1(23.93,48.66) 24.06,48.79 C411.2
INTRUDER#: length 5.8
  TOP w0.127: v1(132.21,105.83) 132.15,105.83 131.76,105.43 131.76,104.39 131.45,104.08 131.45,103.47 131.25,103.27 130.1,103.27 R249.1
  BOTTOM w0.127: U35.AP16 v1(132.21,105.83)
IOAC_LAN_WAKE#: length 209.9
  TOP w0.127: R715.2 45.78,76.35 v1(46.03,76.09)
  IN1 w0.089: v1(173.89,38.25) 173.89,38.27 173.49,38.67 172.82,38.67 171.63,37.48 171.63,37.19 170.64,36.19 170.18,36.19 168.68,34.69 164.93,34.69 163.43,33.19 161.38,33.19 160.65,32.47 159.75,32.47 157.66,30.38 157.66,29.86 157.07,29.27 113.88,29.27 113.58,29.57 80.91,29.57 67.75,16.4 64.48,16.4 64.15,16.08 61.69,16.08 61.04,16.73 59.19,16.73 58.6,16.15 55.65,16.15 47.2,24.61 46.12,24.61 43.44,27.29 43.44,32.38 41.9,33.91 41.9,36.53 v1(40.82,37.61)
  IN3 w0.114: v1(46.03,76.09) 46.54,76.6 48.19,76.6 50.48,74.31 50.48,70.89 43.99,64.41 42.73,64.41 39.57,61.25 39.57,54.25 38.79,53.47 38.79,49.68 38.54,49.42 38.54,39.26 40.19,37.61 v1(40.82,37.61)
  BOTTOM w0.127: U45.87 172.65,37.8 172.67,37.82 173.47,37.82 v1(173.89,38.25)
IOAC_RST#: length 405.9
  TOP w0.127: v1(166.68,75.33) 167.67,76.32 170.64,76.32 172.83,78.51 173.71,78.51 v1(174.17,78.04) ; v1(35.96,63.03) 35.74,63.25 v1(35.74,63.69) R11260.1
  IN1 w0.089: v1(202.11,180.11) 202.62,179.6 202.62,176.8 203.05,176.37 203.05,172.18 204.54,170.69 205.19,170.69 206.5,169.38 206.5,159.55 208.22,157.83 219.69,157.83 223.49,154.03 224.55,154.03 226.73,151.85 226.73,123.21 226.61,123.08 226.61,121.64 227.36,120.89 227.36,114.81 219.62,107.08 216.59,107.08 213.13,103.62 195.09,103.62 194.17,102.71 186.9,102.71 186.4,102.2 180.29,102.2 178.28,100.19 178.28,95.86 176.49,94.06 176.49,87.1 175.11,85.73 175.11,78.98 v1(174.17,78.04) ; v1(35.96,63.03) 35.87,63.03 33.53,60.69 33.53,52.48 34.87,51.14 34.87,42.3 41.33,35.84 41.33,33.67 42.87,32.14 42.87,27.05 45.88,24.04 46.96,24.04 55.42,15.58 56.75,15.58 57.4,14.92 67.09,14.92 81.16,28.99 108.46,28.99 109.69,27.76 115.54,27.76 116.47,28.7 157.3,28.7 160.11,31.5 160.5,31.5 161.4,32.4 163.45,32.4 164.94,33.89 168.69,33.89 170.39,35.6 170.85,35.6 172.18,36.93 173.41,36.93 173.79,37.31 v1(173.79,37.37)
  IN3 w0.114: v1(166.68,75.33) 165.72,74.37 165.72,68.55 166.9,67.37 166.9,66.54 169.51,63.93 169.51,61.4 170.74,60.17 170.74,53.51 172.01,52.23 172.01,49.68 172.71,48.98 172.71,44.03 174.78,41.96 174.78,38.36 v1(173.79,37.37)
  BOTTOM w0.127: v1(173.79,37.37) 173.35,36.93 172.67,36.93 172.6,37 U45.85 ; R680.1 v1(202.11,180.11)
IOAC_WLAN_WAKE#: length 189.7
  TOP w0.127: v1(182.94,176.8) 182.94,178.96 v1(180.96,180.94) v1(180.14,180.94) 179.88,180.68 R244.2 R243.1
  IN1 w0.089: v1(182.94,176.8) 182.43,176.3 181.57,176.3 178.29,173.02 165.61,173.02 163,170.41 163,167.91 v1(163.38,167.53) ; v1(185.6,35.58) 186.31,36.29 186.31,38.42 185.35,39.39 185.35,42.58 183.51,44.43 183.51,44.81 181.94,46.37 180.5,46.37 179.41,47.47 178.02,47.47 177.25,48.24 177.25,50.22 173.17,54.3 173.17,54.63 v1(172.45,55.35)
  IN2 w0.114: v1(164.39,147.47) 164.39,146.58 166.3,144.67 166.3,140.86 167.95,139.21 167.95,133.12 166.87,132.04 165.52,132.04 165.29,131.8 165.29,130.2 163.91,128.82 163.91,118.36 168.71,113.56 168.71,109.62 171.89,106.45 171.89,104.16 172.24,103.8 172.24,97.18 169.58,94.52 169.58,89.78 167.82,88.03 167.82,84.6 169.14,83.28 169.14,81.99 168.71,81.55 168.71,76.02 169.48,75.25 169.48,72.32 169.47,72.31 169.47,61.94 171.89,59.53 171.89,55.91 v1(172.45,55.35)
  BOTTOM w0.127: v1(163.38,167.53) 163.84,167.08 163.84,166.59 163.06,165.82 163.06,157.94 165.97,155.04 165.97,151.01 164.65,149.69 164.65,148 164.39,147.74 v1(164.39,147.47) ; v1(180.14,180.94) 179.79,180.94 179.52,180.68 Q23.6 ; v1(185.6,35.58) 185.78,35.4 U45.16
IRQ_SERIRQ: length 108
  TOP w0.127: v1(169.91,72.92) 169.5,73.32 166.15,73.32 164.78,74.7 163.2,74.7 162.77,75.13 159.95,75.13 v1(159.51,75.57) 159.37,75.71 157.19,75.71 v1(156.43,74.95)
  IN1 w0.089: v1(186.06,39.39) 185.65,39.8 185.65,42.55 183.7,44.51 183.7,44.89 181.91,46.68 180.47,46.68 179.48,47.67 178.14,47.67 177.45,48.36 177.45,50.29 173.41,54.33 173.41,55.04 v1(172.45,56) ; v1(156.43,74.95) 156.17,75.2 156.17,86.06 154.7,87.53 154.7,93.2 155.76,94.25 155.76,95.27 155.17,95.85 154.29,95.85 153.24,96.9 150.38,96.9 148.18,99.09 v1(147.63,99.09)
  IN2 w0.114: v1(172.45,56) 172.43,56.01 172.43,59.3 169.7,62.03 169.7,67.73 169.91,67.93 v1(169.91,72.92)
  BOTTOM w0.076: 137.06,99.87 136.16,100.77 135.8,100.77 135.48,101.1 135.12,101.1 134.96,101.26 134.96,101.89 134.63,102.22 U35.AY11
  BOTTOM w0.127: U44.27 170.73,70.87 171,71.14 171,72.16 170.26,72.89 169.93,72.89 v1(169.91,72.92) ; U45.5 186.47,39.8 v1(186.06,39.39) ; v1(147.63,99.09) 147.12,99.09 R629.2 146.5,99.71 143.69,99.71 143.44,99.46 138.79,99.46 138.39,99.87 137.06,99.87
ISEN1_B: length 11.5
  TOP w0.203: v1(143.21,172.05) 143.21,172.38 142.68,172.92 141.23,172.92 140.6,173.54 PU1.9
  TOP w0.305: PC18.1 143.19,172.03 v1(143.21,172.05)
  IN1 w0.305: v1(141.79,167.66) 141.97,167.84 141.97,170.45 143.21,171.7 v1(143.21,172.05)
  BOTTOM w0.305: v1(143.21,172.05) 143.19,172.03 PC18.1 ; v1(141.79,167.66) 141.7,167.57 PR19.1
ISEN2_B: length 10
  TOP w0.203: v1(144.15,172) 142.86,173.3 141.46,173.3 141,173.75 PU1.10
  TOP w0.305: PR6301.1 PC17.1 144.2,171.95 v1(144.15,172)
  BOTTOM w0.305: PR189.1 v1(143.9,170.58) 143.9,171.75 v1(144.15,172) 144.12,172 143.23,172.89 PR18.2
ISL95857_COMP_A: length 5.4
  TOP w0.203: PU1.16 143.35,177.12 v1(143.64,176.83) 144.35,176.13 PR199.1
  BOTTOM w0.381: v1(143.64,176.83) 143.54,176.93 142.45,176.93 142.23,177.15 PC24.2
ISL95857_COMP_B: length 4.6
  TOP w0.203: PU1.4 138.6,173.29 v1(137.37,172.05) 136.91,171.6 PC21.2
  BOTTOM w0.305: PC21.2 136.91,171.6 v1(137.37,172.05)
  vias: v1(136.73,172.1)
ISL95857_COMP_C: length 7.3
  TOP w0.203: v1(140.62,181.12) 140.32,181.12 139.8,180.61 PU1.24
  TOP w0.381: PR216.1 142.42,182.14 141.41,181.12 v1(140.62,181.12)
  BOTTOM w0.381: v1(140.62,181.12) 139.91,181.12 139.43,180.64 v1(139.43,180.27) PC37.2
ISL95857_FB_A: length 6.5
  TOP w0.203: PR36.1 143.78,177.52 PU1.17
  TOP w0.254: PR34.1 147.17,176.14 146.6,176.72 PR201.1 145.94,176.45 144.76,176.45 144.35,176.86 PR36.1
ISL95857_FB_B: length 5.5
  TOP w0.203: PR24.1 137.9,171.9 v1(138.09,172.08) v1(138.74,172.74) 139,173 PU1.5
  TOP w0.305: PR24.1 137.99,171.29 138.93,171.29 PR23.1
  BOTTOM w0.305: v1(138.09,172.08) 137.9,171.9 PR24.1
ISL95857_FB_C: length 6.2
  TOP w0.203: v1(140.66,181.76) 140.48,181.76 139.4,180.69 PU1.25
  TOP w0.381: v1(140.66,181.76) 141.33,182.43 PR44.1
  BOTTOM w0.381: v1(140.66,181.76) 141.15,182.26 PR217.1 PR45.1
ISL95857_FCCM_A: length 1.8
  TOP w0.203: v1(141.74,180.08) 141.74,179.88 141.29,179.43 PU1.21
  BOTTOM w0.203: PR42.1 141.65,180.17 v1(141.74,180.08)
ISL95857_FCCM_B: length 5
  TOP w0.203: PU1.11 142.12,175.12 142.25,174.99 142.25,174.31 v1(142.45,174.11)
  BOTTOM w0.127: v1(142.45,174.11) 142.4,174.06 v1(141.74,174.06)
  BOTTOM w0.203: v1(142.45,174.11) 143.29,174.11 143.95,173.45 143.95,173.06 PR26.2
ISL95857_FCCM_C: length 2.2
  TOP w0.203: PU1.29 137.8,180.31 137.93,180.44 v1(137.93,180.72) 137.73,180.91 PR46.1
ISL95857_IMON_A: length 5.8
  TOP w0.203: PC23.1 144.02,174.95 143.74,175.23 v1(143.72,175.23) 143.62,175.23 142.53,176.32 PU1.14
  BOTTOM w0.305: PR202.1 141.85,176.18 v1(142.28,175.75) 142.8,175.23 v1(143.72,175.23)
ISL95857_IMON_B: length 3.2
  TOP w0.203: v1(137.32,173.4) 137.8,173.88 PU1.2
  BOTTOM w0.305: PR198.1 136.51,174.25 PC22.1
  BOTTOM w0.381: v1(137.32,173.4) 137.5,173.58 PR198.1
ISL95857_IMON_C: length 3.1
  TOP w0.203: PU1.23 140.2,180.32 v1(140.39,180.51)
  BOTTOM w0.381: v1(140.39,180.51) PR207.1 PC36.1
ISL95857_ISUMN_A: length 7.5
  TOP w0.203: PU1.20 142.1,178.72 142.5,179.12 142.5,180.99 v1(143.08,181.58) 143.69,182.19 145.21,182.19 PC34.2
  TOP w0.305: PC34.2 145.54,182.52 PR211.1
ISL95857_ISUMN_B: length 4.9
  TOP w0.203: PU1.8 140.2,173.31 140.93,172.59 141.26,172.59 141.74,172.1
  TOP w0.305: v1(141.74,172.18) 141.74,172.1 142.13,171.71 142.13,171.39 PC19.1
  BOTTOM w0.305: PR192.2 141.82,172.02 141.74,172.1 v1(141.74,172.18)
ISL95857_ISUMN_C: length 4.8
  TOP w0.203: PU1.28 138.2,180.2 138.41,180.41 138.41,181.02 137.95,181.48 137.95,181.68 v1(137.9,181.73)
  TOP w0.381: PR220.1 137.62,182.37 137.9,182.09 v1(137.9,181.73)
  BOTTOM w0.381: PR220.1 137.62,182.19 137.9,181.91 v1(137.9,181.73)
ISL95857_NTC_A: length 20.5
  TOP w0.203: PU1.15 142.91,176.72 143.21,176.42 v1(143.21,176.35)
  IN1 w0.203: v1(143.21,176.35) 143.21,173.83 143.67,173.37 143.67,168.45 141.59,166.36 139.17,166.36 v1(137.66,164.85)
  BOTTOM w0.203: v1(137.66,164.85) 137.67,164.85 138.11,164.42 138.11,163.44 137.67,163.01 PR235.1
  BOTTOM w0.305: PR236.1 137.63,162.99 PR235.1
ISL95857_NTC_B: length 19.8
  TOP w0.203: v1(128.12,167.53) 130.59,170 135.97,170 136.38,170.4 136.38,171.75 v1(137.33,172.7) 138.2,173.57 PU1.3
  IN1 w0.203: v1(128.12,167.53) 128.12,165.73 v1(127.87,165.48)
  BOTTOM w0.203: PR227.1 126.45,164.05 v1(127.87,165.48)
  BOTTOM w0.305: PR226.1 PR227.1
ISL95857_PROG1: length 2.8
  TOP w0.203: PU1.32 136.08,178.32 135.72,178.68 v1(135.72,178.84)
  BOTTOM w0.203: v1(135.72,178.84) 135.72,178.68 136.21,178.19 PR203.1
ISL95857_PROG2: length 3.1
  TOP w0.127: v1(135.18,180.79) 135.51,180.79 136.11,180.19 PR206.1
  TOP w0.203: PU1.31 136.35,178.72 136.2,178.87 136.2,179.48 PR206.1
ISL95857_PSYS: length 1.4
  TOP w0.203: PR25.1 136.62,173.88 137.27,173.88 137.4,174.01 PU1.1
ISL95857_PWM1_B: length 4.2
  TOP w0.203: PR27.2 v1(143.23,173.83) 143.19,173.87 143.19,174.52 142.18,175.52 PU1.12
ISL95857_PWM2_B: length 5.5
  TOP w0.127: v1(145.85,174.14) 145.59,174.4 144.64,174.4 144.53,174.29 144.53,174.14 PR29.2
  TOP w0.203: PU1.13 142.32,175.92 143.62,174.62 143.62,174.38 144.04,173.96 PR29.2
ISL95857_PWM_A: length 4.6
  TOP w0.203: v1(141.03,180.36) 140.6,179.94 PU1.22
  BOTTOM w0.127: PR43.1 141.65,181.9 141.95,182.2 141.95,182.2 141.99,182.24 142.35,182.24 v1(142.93,182.82)
  BOTTOM w0.203: PR43.1 141.15,181.26 141.15,180.49 v1(141.03,180.36)
ISL95857_PWM_C: length 3.9
  TOP w0.127: v1(135.41,182.11) 135.41,181.45 135.85,181.02 136.07,181.02 PR47.1
  TOP w0.203: PU1.30 137.4,179.92 137.09,180.23 136.63,180.23 136.18,180.69 PR47.1
ISL95857_RTN_A: length 13.3
  TOP w0.203: PU1.18 142.7,177.92 v1(143.27,178.49) 143.97,179.19 PC27.2
  TOP w0.305: v1(144.84,179.88) 144.65,179.88 144.35,179.57 PC27.2 ; v1(147.3,174.77) 147.3,174.39 147.39,174.3 PR38.1 147.39,173.38 147.4,173.37 PC29.2 PR39.1
  IN1 w0.254: v1(147.3,174.77) 147.3,175.69 145.22,177.77 145.22,179.5 v1(144.84,179.88)
ISL95857_RTN_B: length 11.4
  TOP w0.203: PU1.6 139.4,171.98 139.58,171.8 139.58,168.42 139.13,167.97 PC10.2
  TOP w0.305: PR181.2 135.62,166.53 PC12.2 136.62,166.34 v1(137.24,166.34) 137.84,166.34 PR180.1 138.35,166.91 139.13,167.69 PC10.2
ISL95857_RTN_C: length 15.6
  TOP w0.203: PU1.26 139,180.06 139.07,180.13 139.07,180.95 140.37,182.24 140.37,183.74 v1(140.44,183.81)
  TOP w0.305: v1(143.49,187.34) 143.64,187.19 144.09,187.19 PR52.1
  TOP w0.381: v1(140.44,183.81) 140.42,183.84 140.42,184.37 141.59,185.54 v1(141.59,186.16) 141.59,186.28 141.26,186.61 PC45.2
  BOTTOM w0.305: v1(143.49,187.34) 143.25,187.1 PC44.2 142.4,187.13 142.08,187.13 141.86,186.9 PR49.1 141.28,185.69 140.44,184.86 v1(140.44,183.81)
ISL95857_SCLK: length 3.5
  TOP w0.127: PU1.37 136.1,176.32 134.73,174.95 134.15,174.95 PR35.2
ISL95857_SDA: length 3.6
  TOP w0.127: PR40.1 134.25,175.7 134.35,175.8 134.61,175.8 v1(134.79,175.98) 135.1,176.28 135.1,176.65 135.57,177.12 PU1.35
ISL95857_VCC: length 4.5
  TOP w0.203: PU1.34 135.14,177.52 v1(134.99,177.37) 134.8,177.18 PR204.2
  TOP w0.381: v1(133.71,176.35) 133.71,176.89 PR204.2
  BOTTOM w0.381: v1(133.71,176.35) 133.91,176.14 PC32.1
ISL95857_VIN: length 4.5
  TOP w0.203: v1(135.59,178) 135.59,177.95 135.62,177.92 PU1.33
  TOP w0.508: PC35.1 135.45,178 v1(135.59,178)
  BOTTOM w0.127: PR212.1 134.67,176.23 v1(134.85,176.04)
  BOTTOM w0.508: PR212.1 135.01,177.41 v1(135.59,178)
ISL95857_VR_EN: length 6.1
  TOP w0.127: PU1.40 136.23,175.12 135.95,174.84 135.95,174.04 135.36,173.45 135.36,172.94 134.88,172.46 134.37,172.46 133.88,171.97 PR28.2 133.88,171.52 v1(133.33,170.96)
ISL95857_VR_HOT: length 4
  TOP w0.127: PR32.2 134.38,174.26 134.91,174.26 v1(135.17,174.53) 135.34,174.7 135.34,175.2 136.05,175.91 136.68,175.91 PU1.38
ISL95857_VR_READY: length 4.6
  TOP w0.127: PR30.2 134.41,172.75 v1(134.68,173.02) 135.01,173.35 135.01,173.58 135.59,174.16 135.59,174.98 136.14,175.52 PU1.39
ISOLATEB: length 7.4
  TOP w0.108: U15.31 38.1,69.03 37.92,68.85 37.92,68 37.27,67.34 37.27,67.05 ; 37.27,67.05 37.27,65.69 R11262.1 36.25,64.67 36.25,63.66 R11263.2 ; 37.27,67.05 v1(37.29,67.05)
ISUMN_A: length 46.3
  TOP w0.305: v1(146.87,183.94) 146.75,183.94 146.32,183.51 PR211.2 146.44,183.37 147.35,183.37 PR41.2 147.4,184.01 147.56,184.17 PC33.1 148.24,184.58 148.31,184.51 PR208.1 ; v1(144.81,180.68) PC30.2 145.92,180.68 145.95,180.71 PC31.1 147.06,180.14 PR214.1 147.06,178.85 v1(146.64,178.43)
  IN3 w0.203: v1(146.64,178.43) 145.93,177.72 145.93,168.57 142.63,165.27 139.45,165.27 133.81,159.63 133.81,153.36 v1(133.97,153.21)
  BOTTOM w0.203: v1(133.97,153.21) 133.99,153.23 133.99,153.26 134.45,152.8 PR243.2
  BOTTOM w0.305: v1(144.81,180.68) 144.81,181.88 v1(145.86,182.93) v1(146.87,183.94)
ISUMN_B: length 52.1
  TOP w0.305: v1(140.98,172.08) 141.02,172.03 PC20.1 141.06,171.29 PR22.1 141.06,169.93 140.67,169.54 140.67,168.61 PC14.1 140.96,168.39 PR21.1 142.36,168.39 142.58,168.6 142.58,169.99 PC18.2 PC17.2
  IN3 w0.203: v1(115.37,153.64) 115.37,153.84 115.63,154.1 115.63,159.35 117.07,160.8 117.07,162.1 118.34,163.37 119.13,163.37 120.94,165.17 123.15,165.17 127.21,169.23 134.12,169.23 134.96,170.07 138.41,170.07 139.81,171.47 140.37,171.47 v1(140.98,172.08)
  BOTTOM w0.254: PR241.1 115.42,153.04 115.42,153.59 v1(115.37,153.64)
  BOTTOM w0.305: PC134.2 141.09,172.19 v1(140.98,172.08) 141.04,172.01 PR192.1 140.53,170.85 PR182.1 139.9,170.1 PR17.1
ISUMN_C: length 57.2
  TOP w0.305: PR220.2 137.69,183.49 138.74,182.44 PC39.1
  TOP w0.381: PC39.1 138.86,181.93 138.64,181.71 v1(138.59,181.71)
  IN3 w0.203: v1(138.59,181.71) 138.89,182.01 138.89,184.04 139.43,184.58 148.6,184.58 151.59,181.58 151.59,165.35 146.35,160.1 146.35,153.42 v1(146.87,152.9)
  BOTTOM w0.254: PR242.2 147.18,152.59 v1(146.87,152.9)
  BOTTOM w0.381: v1(138.59,181.71) 138.59,181.76 138.86,182.03 PC39.1 PC38.2 138.86,184.18 138.51,184.53 PR48.2 PC43.1 138.49,185.66 v1(138.49,186.56) 138.49,187.2 PR221.1
ISUMP_A: length 11.3
  TOP w0.203: PU1.19 142.19,178.32 142.98,179.12 v1(142.98,179.8) 142.98,180.77 144.07,181.86 145.12,181.86 PC30.1
  TOP w0.305: PR208.2 148.88,183.38 148.7,183.2 PR215.1 148.53,182.48 PR205.2 PC31.2 146.46,181.46 PC30.1
ISUMP_B: length 11.4
  TOP w0.203: PU1.7 139.8,172.42 140.11,172.11 140.12,172.11 v1(140.16,172.16)
  TOP w0.305: v1(140.16,172.16) 140.24,172.08 PC20.2 140.28,171.29 PR22.2 140.28,169.84 140.11,169.67 v1(140.11,169.31)
  BOTTOM w0.305: PR193.2 139.24,170.6 v1(139.79,171.15) 140.16,171.52 v1(140.16,172.16) 140.31,172.3 PC134.1 ; PR20.1 139.56,168.47 PR190.1 140.11,168.89 v1(140.11,169.31)
ISUMP_C: length 8.3
  TOP w0.203: PU1.27 138.6,180.13 138.74,180.27 138.74,181.12 139.62,182 139.62,182.42 PC39.2
  TOP w0.381: PC39.2 PR218.2 139.6,183.44 v1(139.6,184.07)
  BOTTOM w0.127: PC39.2 139.63,182.43 v1(139.63,181.73)
  BOTTOM w0.381: PR222.1 139.71,184.17 v1(139.6,184.07) 139.64,184.03 PR218.2 PC39.2
JTAG_TCK: length 8.6
  BOTTOM w0.127: TP4300.1 162.75,124.67 R4332.2 167.95,125.37 168.31,125.72 169.66,125.72 U3002.AM10
JTAG_TDI: length 8.2
  BOTTOM w0.127: U3002.AM11 169.74,126.65 168.52,126.65 167.62,125.75 164.27,125.75 TP4303.1 163.25,126.26 163.12,126.38 R4331.2
JTAG_TDO: length 5.1
  BOTTOM w0.127: U3002.AP12 168.43,127.84 167.22,126.63 165.93,126.63 165.16,127.4 TP4305.1
JTAG_TMS: length 6.9
  BOTTOM w0.127: R4330.2 163.12,127.4 163.25,127.53 TP4301.1 165.28,126 167.49,126 U3002.AP11
JTAG_TRST#: length 8.8
  BOTTOM w0.127: R4334.2 163,128.42 163.38,128.8 TP4307.1 164.52,128.04 164.52,127.4 165.64,126.28 167.24,126.28 168.37,127.41 168.67,127.41 169.04,127.04 U3002.AN11
KB_BL_LED: length 131.8
  TOP w0.127: v1(179.46,41.8) 179.38,41.88 v1(179.38,43.2) 179.38,44.31 177.73,45.97 177.73,47.79 177.15,48.38 177.15,51.27 177.02,51.39 177.02,56.29 178.3,57.57 178.3,58.17 177.88,58.59 177.88,61.09 179.76,62.96 181.36,62.96 v1(181.95,62.38)
  IN1 w0.089: v1(228.2,120.31) 227.74,119.85 227.74,114.65 219.66,106.57 216.72,106.57 213.38,103.24 195.25,103.24 194.33,102.32 187.06,102.32 186.56,101.82 180.45,101.82 178.66,100.04 178.66,95.7 178.36,95.4 178.36,91.3 176.87,89.8 176.87,86.94 175.62,85.7 175.62,78.83 174.94,78.14 174.94,76.38 176.46,74.86 176.46,68.92 181.95,63.44 v1(181.95,62.38)
  BOTTOM w0.127: v1(228.2,120.31) 227.95,120.06 Q19.2 ; U45.113 179.58,41.93 v1(179.46,41.8)
L_SPK+: length 144
  IN3 w1.016: 196.78,41.8 195.08,41.8 193.15,39.87 190.33,39.87 187.64,37.18 187.64,29.15 185.69,27.2 170.95,27.2 169.02,25.27 161.8,25.27 161.4,24.86 113.26,24.86 111.54,26.59 108.84,26.59 108.75,26.68 94.1,26.68 83.57,16.15 78.03,16.15 77.02,15.13 77.02,10.94
  BOTTOM w0.203: v1(199.57,41.93) 199.63,41.98 U23.42
  BOTTOM w0.508: v1(198.94,41.93) v1(199.57,41.93)
  vias: v1(74.4,10.79) v1(74.71,11.37) v1(75.04,10.79)
L_SPK+_1:
  vias: v1(77.93,11.3) v1(78.34,10.76) v1(78.59,11.35)
L_SPK-: length 144.1
  IN3 w1.016: 196.65,43.58 195.26,43.58 192.68,41 189.86,41 186.49,37.64 186.49,29.61 185.22,28.34 170.49,28.34 169.09,26.94 169.09,26.94 168.55,26.4 161.33,26.4 160.93,25.99 113.81,25.99 112.08,27.72 109.31,27.72 109.22,27.81 93.58,27.81 85.38,19.6 85.38,19.58 83.17,17.37 77.66,17.37 75.89,15.6 75.89,12.97
  BOTTOM w0.203: U23.43 200.36,42.38 v1(200.21,42.54) 200.05,42.69 v1(199.57,42.69)
  BOTTOM w0.508: v1(198.94,42.69) v1(199.57,42.69)
  vias: v1(74.35,12.34) v1(74.99,12.34)
L_SPK-_1:
  vias: v1(77.93,12.59) v1(78.42,12.08) v1(78.59,12.69)
LAN_MCT0: length 1.4
  BOTTOM w0.635: U42.24 v2(22.66,88.4)
  vias: v1(23.5,89.58)
LAN_MCT1: length 2.8
  TOP w0.762: v1(23.88,84.2) 23.56,84.52 R11265.2
  BOTTOM w0.635: U42.21 v2(22.66,85.4)
LAN_MCT2: length 2.7
  TOP w0.762: v1(23.78,81.07) 23.56,81.29 R262.2
  BOTTOM w0.635: U42.18 v2(22.66,82.4)
LAN_MCT3: length 2.8
  TOP w0.762: R269.2 23.56,77.94 v1(23.63,77.87)
  BOTTOM w0.635: U42.15 v2(22.66,79.4)
LAN_MX0+: length 39
  IN1 w0.089: v1(20.5,81.17) 20.5,81.81 21.52,82.82 21.52,99.08 17.84,102.76 17.84,105.18 14.79,108.22 13.75,108.22 13.49,107.97 CN11.1
  BOTTOM w0.127: U42.14 22.86,78.4 22.75,78.29 22.75,78.03 22.63,77.91 22.37,77.91 20.02,80.26 20.02,80.97 20.22,81.17 v1(20.5,81.17)
LAN_MX0-: length 39
  IN1 w0.089: CN11.2 13.6,107.2 13.6,107.7 13.86,107.96 14.68,107.96 17.57,105.07 17.57,102.65 21.25,98.97 21.25,82.93 20.24,81.92 20.24,81.49 19.92,81.17 v1(19.61,81.17)
  BOTTOM w0.127: U42.13 22.79,77.4 22.69,77.5 22.2,77.5 19.61,80.09 v1(19.61,81.17)
LAN_MX1+: length 32
  IN3 w0.114: CN11.3 14.67,105.93 21.3,99.3 21.3,81.56 21.64,81.22 22.15,81.22 v1(22.33,81.4)
  BOTTOM w0.127: v1(22.33,81.4) U42.17
LAN_MX1-: length 32
  IN3 w0.114: v1(22.33,80.4) 22.33,80.78 22.18,80.93 21.52,80.93 21.01,81.44 21.01,99.17 15.52,104.67 15.02,104.67 13.85,103.5 CN11.6
  BOTTOM w0.127: v1(22.33,80.4) U42.16
LAN_MX2+: length 29
  IN1 w0.089: v1(20.38,84.35) 20.38,83.98 20.25,83.85 19.86,83.85 19.23,84.47 19.23,98.44 16.57,101.11 16.57,102.51 14.99,104.08 14,104.08 13.85,104.23 CN11.4
  BOTTOM w0.127: U42.20 22.92,84.4 22.61,84.09 20.63,84.09 v1(20.38,84.35)
LAN_MX2-: length 29
  IN1 w0.089: CN11.5 13.81,103.89 13.89,103.81 14.88,103.81 16.3,102.4 16.3,101 18.97,98.33 18.97,84.36 19.75,83.59 20.25,83.59 v1(20.38,83.46)
  BOTTOM w0.127: U42.19 22.92,83.4 22.63,83.69 20.61,83.69 v1(20.38,83.46)
LAN_MX3+: length 28.6
  BOTTOM w0.127: CN11.7 15.39,101.85 19.39,97.85 19.39,96.77 19.51,96.64 20.9,96.64 21.27,96.28 21.27,95.3 20.9,94.94 19.51,94.94 19.39,94.81 19.39,94.18 19.51,94.05 20.9,94.05 21.27,93.69 21.27,92.71 20.9,92.35 19.51,92.35 19.39,92.22 19.39,89.81 20.4,88.79 v1(20.88,88.79) 20.88,88.41 21.9,87.4 U42.23
LAN_MX3-: length 28.6
  BOTTOM w0.127: U42.22 22.97,86.4 22.84,86.53 22.84,86.84 22.68,86.99 21.73,86.99 20.83,87.89 v1(19.99,87.89) 19.99,88.63 18.98,89.64 18.98,92.39 19.34,92.75 20.73,92.75 20.86,92.88 20.86,93.52 20.73,93.64 19.34,93.64 18.98,94.01 18.98,94.98 19.34,95.35 20.73,95.35 20.86,95.47 20.86,96.11 20.73,96.23 19.34,96.23 18.98,96.6 18.98,97.68 15.22,101.44 14.13,101.44 13.85,101.17 CN11.8
LAN_XTAL2: length 4.6
  TOP w0.127: U15.45 42.56,73.66 v1(42.6,73.71) 43.2,74.31 C4605.2 43.81,74.31 44.41,74.91 Y1.3
LAN_XTALI: length 6.5
  TOP w0.127: Y1.1 45.65,73.81 v1(44.07,73.81) 43.99,73.81 C4606.2 42.81,73.18 42.73,73.26 U15.44
LANE0_N: length 2.2
  TOP w0.127: C331.2 27.2,69.34 27.07,69.34 26.68,68.95 U13.6
LANE0_P: length 2.1
  TOP w0.127: U13.5 26.38,68.55 26.53,68.69 26.79,68.69 27.18,69.08 27.38,69.08 C335.2
LANE1_N: length 3.7
  TOP w0.127: U13.8 26.35,69.75 26.4,69.69 26.6,69.69 26.75,69.85 26.75,70.33 26.59,70.5 26.59,71.13 26.9,71.44 27.28,71.44 C315.2
LANE1_P: length 3.7
  TOP w0.127: U13.7 26.33,69.35 26.42,69.44 26.7,69.44 27.01,69.74 27.01,70.44 26.84,70.6 26.84,71.03 27.01,71.19 27.3,71.19 C329.2
LANPWR#: length 233.4
  TOP w0.127: v1(49.71,71.7) 49.46,71.44 R260.2 R259.1
  IN1 w0.089: v1(173.72,31.82) 172.9,31.01 172.02,31.01 169.55,28.54 163.68,28.54 159.11,23.97 118.78,23.97 118.19,23.38 109.07,23.38 108.49,23.97 103.62,23.97 102.76,24.82 82.85,24.82 75.84,17.81 75.84,15.86 73.97,13.99 71.05,13.99 68.64,11.58 55.63,11.58 55.25,11.96 43.87,11.96 38.08,17.75 35.03,17.75 26.98,25.8 26.98,41.68 25.58,43.07 25.58,54.05 27.16,55.63 27.16,63.39 v1(28.56,64.79)
  BOTTOM w0.127: v1(28.56,64.79) v1(30.39,64.79) 44,64.79 48.44,69.23 48.44,70.43 v1(49.71,71.7) ; v1(173.72,31.82) 173.72,31.62 173.1,31 U45.70
LANVCC: length 26.2
  TOP w1.016: 42.73,82.7 42.73,84.98 39.63,88.08 36.71,88.08 35.36,89.43 34.09,89.43 32.91,88.25 32.91,78.54 33.61,77.85 34.65,77.85
  vias: v1(41.71,77.87) v1(41.71,77.24) v1(41.97,82.09) v1(41.97,81.44) v1(42.93,65.7) v1(43.44,66.21)
LCDVCC:
  vias: v1(111.77,161.08) v1(114.6,160.95) v1(114.61,160.32) v1(115.25,160.93)
LCDVCC_R:
  vias: v1(118.55,166.39) v1(118.9,167.23) v1(119.18,166.39)
LID#: length 387
  TOP w0.127: D23.2 71.9,11.82 71.68,12.04 R11129.1 71.51,12.34 71.25,12.08 v1(71.25,11.7)
  IN1 w0.089: v1(75.49,19.96) 82.42,26.88 107.77,26.88 109.01,25.64 158.58,25.64 163.05,30.11 168.32,30.11 170.62,32.4 170.62,32.79 172.07,34.24 174.95,34.24 176.04,35.34 178.94,35.34 179.15,35.55 184.35,35.55 184.72,35.17 185.96,35.17 186.62,35.83 186.62,41.85 184.03,44.44 184.03,45.87 184.71,46.55 184.71,47.8 184.05,48.46 v1(184.05,48.99) ; v1(39.05,91.08) 39.05,91.84 43.66,96.45 44.09,96.45 57.67,110.04 66.44,110.04 v1(66.86,109.62) ; v1(71.25,11.7) 70.13,11.7 69.04,10.62 65.39,10.62 64.57,9.8 62.54,9.8 61.56,10.78 55.42,10.78 55.15,10.51 53.7,10.51 53.14,11.07 43.94,11.07 38.43,16.57 35.07,16.57 26.22,25.42 26.22,39.84 24.92,41.13 24.92,63.37 27.74,66.19 28,66.19 v1(29.01,67.2)
  IN2 w0.114: v1(66.86,109.62) 67.62,109.62 68.12,110.12 78.25,110.12 88.92,120.8 90.42,120.8 95,125.38 95,129.13 96.27,130.4 101.48,130.4 102.42,131.34 102.42,131.85 105.62,135.05 105.89,135.05 106.1,135.25 106.1,145.47 108.08,147.45 108.08,148.16 110,150.09 v1(110,151.72)
  BOTTOM w0.127: D1.1 111.65,152.89 111.18,152.42 111.18,151.92 R53.2 110.19,151.53 v1(110,151.72) ; v1(75.49,19.96) 75.49,15.95 v1(71.25,11.7) ; v1(29.01,67.2) 28.35,67.86 28.35,73.78 28.89,74.31 30.54,74.31 31.17,74.95 31.17,88.79 32.31,89.94 37.9,89.94 v1(38.19,90.22) v1(39.05,91.08) ; v1(184.05,48.99) 184.11,48.93 R460.2
LID#15: length 21.3
  TOP w0.127: R435.1 71.26,12.8 72.19,12.8 72.46,12.53 R11129.2 72.64,12.16 72.64,10.27 73.73,9.18 78.53,9.18 82.73,4.97 v1(85.35,4.97) 86.29,4.97 86.55,4.71 MR1.2
LINE1-L: length 14.1
  IN3 w0.381: v1(208.97,40.28) 208.97,39.64 208.46,39.14 208.46,37.87 207.24,36.65 207.24,35.63 206.88,35.26 206.88,34.12 206.43,33.67 206.43,30.76 v1(205.51,29.84)
  BOTTOM w0.203: 208.84,40.41 208.47,40.78 U23.22
  BOTTOM w0.381: C552.1 205.51,29.19 v1(205.51,29.84) ; v1(208.97,40.28) 208.84,40.41
LINE1-R: length 17.9
  IN3 w0.381: v1(208.97,41.04) 208.21,41.04 207.7,40.53 207.7,39.9 207.19,39.39 207.19,37.85 205.42,36.08 205.42,34.56 204.15,33.29 204.15,29.65 v1(202.71,28.21)
  BOTTOM w0.203: U23.21 208.83,41.18 v1(208.97,41.04)
  BOTTOM w0.381: C549.1 202.71,28.77 v1(202.71,28.21)
LINE1-VREFO-L: length 8.4
  BOTTOM w0.203: 204.83,37.48 204.83,37.49 204.58,37.74 U23.31
  BOTTOM w0.381: R421.2 v1(204.27,32.53) 204.27,33.6 204.83,34.16 204.83,35.31 205.03,35.52 205.03,37.28 204.83,37.48
LINE1-VREFO-R: length 10.1
  IN3 w0.381: v1(205.06,38.02) 205.06,36.98 204.27,36.19 204.27,35.07 202.37,33.17 v1(202.37,30.75)
  BOTTOM w0.203: v1(205.06,38.02) 204.98,38.1 U23.30
  BOTTOM w0.381: R418.2 202.38,30.74 v1(202.37,30.75)
LM393_PIN2: length 19.9
  TOP w0.254: v1(48.72,106.8) v1(49.89,106.8) PR146.2 51.42,107.46 PU4.2
  BOTTOM w0.127: PR262.2 41.46,114.07 v1(48.72,106.8)
LPC_LAD0: length 270.1
  TOP w0.127: v1(189.32,42.58) 189.74,43 189.74,43.83 189.45,44.13 189.45,50.48 188.64,51.29 188.64,55.3 187.31,56.62 186.69,56.62 186.37,56.95 186.37,58.57 184.55,60.39 184.55,60.39 183.71,61.22 182.55,61.22 182.12,60.8 v1(182.12,60.6) ; v1(194.49,177.06) 194.49,177.07 194.73,177.31 R688.1
  IN1 w0.089: v1(182.12,60.6) 181.69,61.03 180.67,61.03 179.71,61.99 179.71,62.42 179.04,63.09 179.04,64.13 173.82,69.36 173.82,73.4 v1(172.99,74.23) 172.98,74.21 172.74,74.21 172.37,74.58 172.37,75.91 172.06,76.23 172.06,76.71 171.83,76.94 171.83,77.36 171.43,77.76 171.43,80.13 171.63,80.33 171.63,83.25 171.27,83.62 171.27,85.25 170.44,86.07 v1(170.44,86.31) 170.44,87.09 171.06,87.71 172.52,87.71 172.79,87.44 174.35,87.44 174.73,87.83 174.73,95.77 174.43,96.07 174.43,99.41 179,103.98 183.4,103.98 183.88,104.46 193.45,104.46 194.36,105.37 209.18,105.37 213.88,110.08 217.44,110.08 218.71,111.35 221.03,111.35 224.98,115.3 224.98,139.91 224.3,140.59 224.3,141.59 224.98,142.27 224.98,149.89 220.7,154.17 213.12,154.17 211.96,155.34 208.03,155.34 205.66,157.72 204.36,157.72 204.03,158.05 204.03,168.16 203.13,169.06 203.13,169.8 200.78,172.16 200.31,172.16 197.64,174.83 196.14,174.83 195.41,175.56 194.41,175.56 193.71,176.26 193.71,176.72 194.05,177.06 v1(194.49,177.06)
  BOTTOM w0.127: v1(189.32,42.58) 189.31,42.56 189.31,42.3 189.56,42.05 189.56,38.88 188.48,37.8 U45.10 ; v1(172.99,74.23) 172.37,73.6 172.36,73.62 169.43,73.62 169.19,73.38 U44.24 ; R659.2 137.22,94.64 137.22,91.38 138.95,89.64 141.47,89.64 149.24,81.87 165.03,81.87 167.8,84.64 167.8,85.17 168.56,85.92 169.17,85.92 169.35,85.74 170.14,85.74 170.44,86.05 v1(170.44,86.31)
LPC_LAD0_C: length 3.6
  TOP w0.127: R688.2 196.41,177.69 196.91,177.69 v1(197.29,177.31)
  BOTTOM w0.127: CN10.64 197.86,176.25 197.3,176.81 197.3,177.3 v1(197.29,177.31)
LPC_LAD1: length 271.9
  TOP w0.127: v1(194.49,176.04) 194.87,176.42 R690.1 ; v1(183.44,60.57) 184,60.57 186.11,58.46 186.11,56.84 186.58,56.37 187.21,56.37 188.36,55.22 188.36,51.2 189.2,50.36 189.2,43.31 v1(189.3,43.21)
  IN1 w0.089: v1(194.49,176.04) 195.01,176.56 198.09,176.56 201.61,173.05 201.61,171.63 203.35,169.89 203.35,169.15 204.19,168.31 204.79,168.31 204.96,168.14 204.96,158.84 208.21,155.59 212.11,155.59 213.3,154.4 220.77,154.4 225.2,149.98 225.2,115.21 221.12,111.13 218.8,111.13 217.53,109.86 213.97,109.86 209.27,105.16 194.45,105.16 193.54,104.24 183.97,104.24 183.49,103.77 179.09,103.77 176.75,101.42 176.75,96.5 174.95,94.7 174.95,87.74 174.43,87.22 172.7,87.22 172.43,87.49 171.63,87.49 171.44,87.29 171.44,86.7 v1(171.07,86.34) 171.07,85.74 171.48,85.34 171.48,83.71 171.89,83.31 171.89,80.28 171.65,80.04 171.65,77.85 172.05,77.45 172.05,77.03 172.27,76.8 172.27,76.34 172.83,75.79 v1(172.83,75.55) 174.05,74.33 174.05,69.43 179.26,64.22 179.26,63.18 179.93,62.51 179.93,62.08 180.75,61.26 182.05,61.26 182.3,61.01 183.01,61.01 v1(183.44,60.57)
  BOTTOM w0.127: v1(171.07,86.34) 171.04,86.34 170.17,87.21 169.12,87.21 167.29,85.38 167.29,84.85 164.82,82.38 149.46,82.38 141.69,90.15 139.29,90.15 137.72,91.72 137.72,96.04 137.34,96.41 137.08,96.41 R640.2 ; U45.9 188.52,38.2 189.3,38.99 189.3,41.88 188.88,42.31 188.88,42.77 189.3,43.19 v1(189.3,43.21) ; v1(172.83,75.55) 171.72,74.44 171,74.44 169.98,75.46 167.98,75.46 167.7,75.18 167.7,73.81 167.69,73.8 U44.21
LPC_LAD1_C: length 3.1
  TOP w0.127: v1(197.28,176) 197.28,176.17 196.88,176.58 196.18,176.58 R690.2
  BOTTOM w0.127: v1(197.28,176) 197.54,175.75 CN10.66
LPC_LAD2: length 270.2
  TOP w0.127: v1(188.65,43.2) 188.94,43.49 188.94,50.25 188.11,51.09 188.11,55.11 187.1,56.12 186.48,56.12 185.86,56.74 185.86,58.36 184.24,59.97 181.23,59.97 180.85,60.35 v1(180.85,60.6) ; R693.1 194.87,175.53 v1(194.49,175.15)
  IN1 w0.089: v1(180.85,60.6) 180.63,60.82 180.58,60.82 179.49,61.9 179.49,62.33 178.83,63 178.83,64.04 173.59,69.28 173.59,73.06 172.15,74.49 172.15,75.82 171.66,76.32 v1(171.66,76.47) 171.53,76.6 171.53,77.36 171.21,77.67 171.21,80.22 171.38,80.38 171.38,83.2 171.05,83.53 171.05,84.77 v1(169.51,86.31) 169.51,86.91 170.53,87.92 172.61,87.92 172.88,87.66 174.06,87.66 174.52,88.11 174.52,95.65 174.14,96.03 174.14,99.46 174.17,99.46 178.91,104.2 183.31,104.2 183.79,104.67 192.11,104.67 193.03,105.59 209.09,105.59 213.79,110.29 217.35,110.29 218.62,111.56 220.94,111.56 224.76,115.39 224.76,139.82 224.08,140.5 224.08,141.68 224.76,142.36 224.76,149.8 220.62,153.94 213,153.94 211.83,155.11 207.73,155.11 207.57,154.96 206.05,154.96 205.59,155.42 205.59,156.18 203.82,157.96 203.82,168.07 202.92,168.97 202.92,169.71 202.55,170.07 201.56,170.07 200.73,170.9 200.73,171.33 198.62,173.44 198.62,173.54 197.55,174.61 195.54,174.61 195,175.15 v1(194.49,175.15)
  BOTTOM w0.127: v1(188.65,43.2) 188.63,43.17 188.63,42.2 189.05,41.78 189.05,39.09 188.56,38.6 U45.8 ; U44.18 166.19,76.11 166.55,76.47 v1(171.66,76.47) ; R653.2 137.49,95.51 137.49,91.51 139.11,89.9 141.58,89.9 149.35,82.13 164.92,82.13 167.54,84.75 167.54,85.27 168.58,86.31 v1(169.51,86.31)
LPC_LAD2_C: length 2.8
  TOP w0.127: v1(197.29,175.23) 196.84,175.67 196.47,175.67 196.33,175.53 R693.2
  BOTTOM w0.127: v1(197.29,175.23) 197.31,175.25 CN10.68
LPC_LAD3: length 284.4
  TOP w0.127: v1(187.76,42.62) 188.07,42.92 188.07,43.35 188.6,43.89 188.6,50.24 187.85,50.98 187.85,55.01 187,55.86 186.37,55.86 185.6,56.63 185.6,58.17 184.05,59.72 181.1,59.72 180.41,60.41 180.41,61.29 v1(180.9,61.79) ; v1(194.46,173.86) R696.1
  IN1 w0.089: v1(180.9,61.79) 180.55,61.79 180.14,62.2 180.14,62.62 179.48,63.29 179.48,64.31 175.02,68.76 175.02,72.13 174.43,72.73 174.43,74.25 173.26,75.42 173.26,75.69 172.5,76.45 172.5,77.06 v1(172.7,77.26) 172.73,77.26 172.26,77.72 172.26,78.66 173.18,79.57 173.18,83.97 171.76,85.39 v1(171.76,86.36) 172.29,86.89 174.4,86.89 175.16,87.65 175.16,94.61 176.96,96.41 176.96,101.33 179.18,103.55 183.58,103.55 184.06,104.03 193.63,104.03 194.54,104.94 209.35,104.94 214.06,109.65 217.62,109.65 218.89,110.92 221.21,110.92 225.41,115.12 225.41,150.08 220.86,154.63 213.38,154.63 212.16,155.85 208.34,155.85 205.18,159 205.18,168.23 204.88,168.53 204.27,168.53 203.56,169.24 203.56,169.98 201.82,171.72 201.82,173.14 198.18,176.78 196.17,176.78 195.46,177.49 193.99,177.49 193.46,176.96 193.46,174.87 v1(194.46,173.86)
  BOTTOM w0.127: U44.15 164.24,71.37 163.51,72.11 163.51,72.79 162.87,73.43 162.87,75.58 163.49,76.21 165.93,76.21 166.45,76.73 170.74,76.73 171.28,77.26 v1(172.7,77.26) ; U45.7 188.51,39 188.8,39.28 188.8,41.67 187.85,42.62 v1(187.76,42.62) ; v1(171.76,86.36) 171.47,86.65 171.47,87.19 171.2,87.46 169.01,87.46 167.04,85.48 167.04,84.96 164.71,82.63 149.57,82.63 141.79,90.41 139.41,90.41 137.95,91.87 137.95,96.56 R668.2
LPC_LAD3_C: length 3.3
  TOP w0.127: R696.2 196.37,174.64 196.42,174.7 196.88,174.7 197.26,174.31 v1(197.26,174.19)
  BOTTOM w0.127: CN10.70 197.54,174.75 197.26,174.47 v1(197.26,174.19)
LPC_LFRAME#: length 284.3
  TOP w0.127: R699.2 191.45,175.15 v1(192.21,175.91) ; v1(180.63,62.38) 179.9,61.65 179.9,60.2 180.89,59.21 183.84,59.21 185.1,57.96 185.1,56.42 186.16,55.35 186.78,55.35 187.34,54.79 187.34,50.77 188.09,50.02 188.09,44.27 187.31,43.48 187.31,42.39 187.73,41.96 v1(187.79,41.96)
  IN1 w0.089: v1(192.21,175.91) 192.21,176.37 193.81,177.97 197.66,177.97 202.29,173.34 202.29,171.92 204.24,169.96 204.89,169.96 205.65,169.2 205.65,159.2 207.99,156.86 212.02,156.86 213.77,155.11 221.14,155.11 225.88,150.37 225.88,121.29 226.51,120.66 226.51,115.55 221.09,110.13 219.26,110.13 218.24,109.11 214.43,109.11 209.79,104.47 194.74,104.47 193.82,103.56 184.25,103.56 183.76,103.07 179.89,103.07 177.43,100.61 177.43,96.21 175.63,94.41 175.63,87.45 174.54,86.36 v1(172.4,86.36) 172.4,86.13 173.67,84.86 173.67,79.39 173.27,79 173.27,76.91 173.4,76.78 v1(173.4,76.26) 174.46,75.2 174.81,75.2 175.7,74.31 175.7,68.75 179.95,64.5 179.95,63.48 180.63,62.8 v1(180.63,62.38)
  BOTTOM w0.076: U35.BA12 134.06,101.72 134.09,101.69 134.09,100.63 135,99.71 135.44,99.71 136.45,98.7 137.62,98.7 138.03,98.28 138.03,97.94
  BOTTOM w0.127: U44.20 167.19,75.39 167.77,75.97 170.41,75.97 171.18,75.2 171.77,75.2 172.62,76.05 173.2,76.05 v1(173.4,76.26) ; 138.03,97.94 138.03,96.82 138.18,96.67 138.18,92.36 139.62,90.91 142,90.91 149.78,83.14 164.5,83.14 166.53,85.17 166.53,85.69 168.82,87.98 171.81,87.98 172.4,87.4 v1(172.4,86.36) ; U45.6 188.14,39.4 188.29,39.54 188.29,41.46 v1(187.79,41.96)
LPC_LFRAME#_C: length 2.3
  TOP w0.127: v1(192.21,173.76) 191.71,174.25 R699.1
  BOTTOM w0.127: CN10.73 191.97,174 v1(192.21,173.76)
LPCPD: length 2.4
  BOTTOM w0.127: U44.28 171.17,70.37 v1(171.32,70.52) 171.76,70.96 R744.2
LPM_ZVM_N: length 69.2
  TOP w0.127: R762.2 97.07,113.68 96.7,113.32 86.44,113.32 83.68,110.56 77.58,110.56 76.39,109.37 68.13,109.37 66.6,107.84 66.6,105.76 62.85,102 54.16,102 49.84,97.68 49.84,88.54 v1(49.44,88.14) 48.05,86.75 PR280.1
M_A_A0: length 64
  IN1 w0.14: v1(116.51,46.69) 116.26,46.94 116.26,47.83 116.87,48.44 116.87,52.22 116.34,52.74 116.34,63.3 115.26,64.38 115.26,66.18 115.12,66.33 115.12,66.59 115.35,66.83 115.35,67.35 115.12,67.58 115.12,68.68 113.42,70.38 113.42,70.9 112.5,71.83 112.5,90.06 112.25,90.31 112.25,97.4 v1(111.31,98.34)
  BOTTOM w0.076: 112.49,100.46 112.49,100.75 112.31,100.93 112.31,101.19 112.34,101.27 112.35,101.28 112.37,101.31 112.37,101.45 112.3,101.68 112.3,101.81 112.38,102.03 112.58,102.23 U35.AY50
  BOTTOM w0.102: v1(111.31,98.34) 111.31,98.67 112.49,99.84 112.49,100.46
  BOTTOM w0.203: JDIM1.144 118.47,45.56 117.34,46.69 v1(116.51,46.69)
M_A_A1: length 63.9
  IN1 w0.14: v1(110.63,96.01) 111.31,96.01 111.75,95.56 111.75,89.94 111.66,89.84 111.66,71.17 111.82,71.01 112.12,71.01 112.58,70.55 112.58,70.01 113.98,68.62 113.98,68.35 113.7,68.07 113.7,67.72 113.84,67.58 114.17,67.58 114.28,67.47 114.28,67.18 114.17,67.06 113.84,67.06 113.7,66.92 113.7,66.68 113.81,66.57 114.17,66.57 114.28,66.45 114.28,65.98 114.43,65.84 114.43,64.59 114.26,64.42 113.93,64.42 113.77,64.27 113.77,64 114,63.77 114.61,63.77 115.37,63.01 115.37,62.76 115.26,62.64 114.98,62.64 114.82,62.48 114.82,60.14 114.99,59.96 114.99,59.29 114.82,59.11 114.82,58.82 115.04,58.6 115.04,58.14 115.37,57.8 115.37,57.55 114.83,57.01 114.83,56.73 114.97,56.59 115.36,56.59 115.51,56.44 115.51,56.2 115.38,56.08 114.95,56.08 114.79,55.93 114.79,55.7 114.95,55.55 115.4,55.55 115.51,55.45 115.51,55.1 115.3,54.9 114.87,54.9 114.48,55.29 114.26,55.29 114.06,55.1 114.06,54.65 114.2,54.51 114.68,54.51 114.82,54.37 114.82,52.64 116.01,51.45 v1(116.01,50.06)
  BOTTOM w0.102: v1(110.63,96.01) 111.77,97.15 111.77,98.5 112.68,99.41 112.68,100.98 U35.BB50
  BOTTOM w0.203: v1(116.01,50.06) 115.72,50.34 JDIM1.133
M_A_A2: length 65.3
  IN1 w0.14: v1(115.37,45.44) 115.37,45.08 115.5,44.95 115.8,44.95 115.98,45.13 115.98,46.4 115.83,46.55 115.83,47.99 116.45,48.61 116.45,51.6 115.24,52.82 115.24,54.24 115.93,54.93 115.93,63.05 114.85,64.13 114.85,66.01 114.7,66.16 114.7,68.49 113,70.19 113,70.73 112.08,71.65 112.08,89.86 112,89.94 112,95.9 v1(110.63,97.28)
  BOTTOM w0.076: U35.AY51 112.18,102.48 112.18,101.98 112.13,101.82 112.13,101.68 112.19,101.46 112.19,101.34 112.15,101.23 112.15,100.86 112.3,100.71 112.3,99.91 110.42,98.03 110.42,97.48 v1(110.63,97.28)
  BOTTOM w0.203: v1(115.37,45.44) 115.37,44.95 115.47,44.85 JDIM1.132
M_A_A3: length 64.7
  IN1 w0.14: v1(110.63,94.74) 111.11,95.22 111.28,95.22 111.51,94.99 111.51,94.76 111.18,94.43 111.18,94.07 111.51,93.75 111.51,90.19 111.24,89.92 111.24,70.76 111.54,70.47 111.73,70.47 111.8,70.53 112.01,70.53 112.17,70.38 112.17,70.16 112.1,70.1 112.1,69.9 113.28,68.73 113.28,66.51 113.59,66.19 113.59,65.93 113.28,65.62 113.28,65.3 113.54,65.03 113.54,64.64 113.28,64.37 113.28,63.84 113.76,63.35 114.44,63.35 114.67,63.12 114.67,62.93 114.4,62.66 114.4,59.96 114.57,59.79 114.57,59.46 114.4,59.29 114.4,58.64 114.6,58.44 114.6,57.41 114.41,57.23 114.41,56.41 114.21,56.2 114.21,55.87 113.65,55.31 113.65,53.22 115.5,51.37 115.5,48.91 115.63,48.79 v1(116.01,48.79)
  BOTTOM w0.102: U35.BA50 112.58,101.59 112.87,101.3 112.87,99.34 111.97,98.43 111.97,96.08 v1(110.63,94.74)
  BOTTOM w0.203: JDIM1.131 115.22,48.43 115.38,48.28 115.86,48.28 116.01,48.43 v1(116.01,48.79)
M_A_A4: length 64.3
  IN1 w0.076: 109.74,90.87 110.04,91.17 110.04,96.16 109.82,96.39 v1(109.41,96.39)
  IN1 w0.14: v1(113.97,45.56) 113.54,45.99 112.78,45.99 112.58,46.2 112.58,46.48 112.73,46.63 113.09,46.63 113.21,46.76 113.21,47.97 112.74,48.44 112.74,50.4 112.29,50.86 111.27,50.86 110.28,51.85 110.28,56.66 110.64,57.02 110.64,58.09 110.28,58.45 110.28,67.52 108.69,69.11 108.69,89.81 109.74,90.87
  BOTTOM w0.076: v1(109.41,96.39) 109.81,96.79 109.81,98.13 111.15,99.47 111.15,100.98 U35.BB52
  BOTTOM w0.203: v1(113.97,45.56) 114.23,45.56 114.47,45.32 JDIM1.128
M_A_A5: length 65.9
  IN1 w0.14: v1(110.63,92.83) 111.05,92.41 111.05,90.92 109.94,89.81 109.94,70.23 111.98,68.19 111.98,63.3 112.83,62.45 112.83,60.6 112.71,60.47 112.5,60.47 112.35,60.32 112.35,60.11 112.5,59.96 112.92,59.96 113.06,59.81 113.06,59.6 112.92,59.46 112.53,59.46 112.38,59.3 112.38,58.8 112.53,58.65 112.75,58.65 112.91,58.49 112.91,56.43 112.76,56.28 112.5,56.28 112.35,56.13 112.35,52.69 114.2,50.83 114.2,47.06 v1(113.97,46.83)
  BOTTOM w0.076: U35.BA51 111.69,101.84 111.69,101.61 111.69,101.6 111.68,101.6 111.68,101.6 111.65,101.51 111.65,101.31 111.68,101.22 111.68,100.86 111.48,100.66 111.48,99.33 110.22,98.07 110.22,93.24 v1(110.63,92.83)
  BOTTOM w0.203: v1(113.97,46.83) 113.8,47.01 113.34,47.01 113.09,46.76 113.09,46.5 113.49,46.1 113.49,45.36 113.97,44.88 JDIM1.126
M_A_A6: length 64.5
  IN1 w0.076: 110.22,90.93 110.22,97.85 110.06,98.01 109.76,98.01 v1(109.41,97.66)
  IN1 w0.14: 110.22,90.93 109.11,89.81 109.11,69.28 110.48,67.91 110.75,67.91 110.93,67.74 110.93,67.51 110.7,67.28 110.7,62.63 110.9,62.43 110.9,62.17 110.7,61.97 110.7,61.72 110.8,61.61 111.18,61.61 111.51,61.28 111.51,59.44 111.33,59.26 110.85,59.26 110.7,59.11 110.7,58.89 110.85,58.74 111.38,58.74 111.51,58.61 111.51,58.36 111.31,58.16 111.31,57.88 111.51,57.68 111.51,56.63 111.17,56.28 110.95,56.28 110.7,56.03 110.7,53.03 110.93,52.8 110.93,51.79 111.45,51.28 112.57,51.28 113.16,50.69 113.16,48.61 113.24,48.53 113.41,48.53 v1(113.72,48.85)
  BOTTOM w0.076: U35.BA52 111.25,101.51 110.99,101.25 110.99,99.55 110.77,99.33
  BOTTOM w0.102: v1(109.41,97.66) 109.41,97.97 110.77,99.33
  BOTTOM w0.203: v1(113.72,48.85) 113.91,48.85 114.22,49.16 JDIM1.127
M_A_A7: length 66.8
  IN1 w0.14: v1(109.41,95.75) 109.71,95.75 109.84,95.63 109.84,91.38 109.38,90.93 109.11,90.93 108.87,91.16 108.64,91.16 108.27,90.8 108.27,68.94 108.94,68.27 108.94,67.63 109.22,67.35 109.73,67.35 109.86,67.22 109.86,58.11 110.19,57.78 110.19,57.17 109.86,56.84 109.86,54.71 109.33,54.18 109.33,52.2 111.34,50.19 111.57,50.19 111.82,50.44 112.11,50.44 112.31,50.24 112.31,47.53 112.44,47.39 v1(112.71,47.39)
  BOTTOM w0.076: 110.6,99.44 110.82,99.66 110.82,101.77 111.03,101.98 111.03,102.52 111.35,102.85 U35.AW52
  BOTTOM w0.102: 110.6,99.44 108.99,97.82 108.99,96.17 v1(109.41,95.75)
  BOTTOM w0.203: v1(112.71,47.39) 112.71,46.25 113.11,45.84 113.11,44.44 112.97,44.31 JDIM1.122
M_A_A8: length 65.6
  IN1 w0.14: v1(113.72,50.12) 113.72,50.72 112.74,51.71 111.63,51.71 111.49,51.85 111.49,52.1 111.93,52.55 111.93,53.02 111.75,53.19 111.25,53.19 111.12,53.32 111.12,53.56 111.27,53.72 111.8,53.72 111.93,53.84 111.93,54.12 111.8,54.25 111.27,54.25 111.12,54.4 111.12,54.63 111.27,54.78 111.78,54.78 111.93,54.93 111.93,55.16 111.78,55.32 111.25,55.32 111.12,55.44 111.12,55.64 111.93,56.45 111.93,61.08 112.08,61.23 112.26,61.23 112.41,61.38 112.41,61.59 112.26,61.74 111.65,61.74 111.5,61.89 111.5,62.1 111.65,62.25 111.93,62.25 112.08,62.4 112.08,62.61 111.93,62.76 111.27,62.76 111.12,62.91 111.12,63.24 111.27,63.39 111.42,63.39 111.56,63.54 111.56,63.74 111.42,63.89 111.26,63.89 111.12,64.03 111.12,64.27 111.26,64.41 111.42,64.41 111.56,64.55 111.56,65.93 111.28,66.21 111.28,66.63 111.56,66.9 111.56,68.02 111.13,68.45 110.93,68.45 110.83,68.35 110.63,68.35 110.46,68.52 110.46,68.72 110.56,68.82 110.56,69.02 110.39,69.19 110.19,69.19 110.1,69.1 109.88,69.1 109.73,69.25 109.73,69.47 109.82,69.56 109.82,69.76 109.53,70.05 109.53,89.81 110.82,91.11 110.82,91.87 v1(110.63,92.07)
  BOTTOM w0.076: U35.AY52 111.45,102.29 111.45,102.02 111.52,101.84 111.52,101.63 111.48,101.54 111.48,101.28 111.52,101.19 111.52,100.93 111.32,100.73 111.32,99.4 110.04,98.12 110.04,92.65 v1(110.63,92.07)
  BOTTOM w0.203: JDIM1.125 v1(113.72,50.12)
M_A_A9: length 64.4
  IN1 w0.14: v1(109.41,92.35) 107.85,90.79 107.85,68.37 108,68.22 108.39,68.22 108.52,68.1 108.52,67.83 108.39,67.71 108,67.71 107.85,67.56 107.85,67.35 108,67.2 108.76,67.2 108.91,67.05 108.91,64.5 109.05,64.36 109.29,64.36 109.44,64.2 109.44,63.99 109.29,63.83 109.05,63.83 108.91,63.7 108.91,63.42 109.07,63.27 109.29,63.27 109.44,63.12 109.44,62.91 109.29,62.76 109.07,62.76 108.91,62.61 108.91,61.99 109.2,61.71 109.2,61.41 108.91,61.13 108.91,59.38 109.07,59.23 109.29,59.23 109.44,59.08 109.44,58.87 109.29,58.72 109.07,58.72 108.91,58.57 108.91,58.34 109.05,58.21 109.05,57.98 108.91,57.85 108.91,56.36 109.07,56.21 109.29,56.21 109.44,56.05 109.44,55.84 109.29,55.68 109.07,55.68 108.91,55.53 108.91,55.32 109.07,55.16 109.25,55.16 109.4,55.01 109.4,54.84 108.91,54.35 108.91,52.03 110.94,50 110.94,48.98 111.06,48.86 111.29,48.86 111.44,49.01 111.44,49.52 111.61,49.69 v1(111.86,49.69)
  BOTTOM w0.076: 110.13,99.79 110.17,99.79 110.32,99.95 110.32,100.98 U35.BB54
  BOTTOM w0.102: v1(109.41,92.35) 108.36,93.4 108.36,98.02 109.85,99.52 110.13,99.79
  BOTTOM w0.203: v1(111.86,49.69) 112.29,49.69 112.72,50.13 JDIM1.121
M_A_A10: length 67.7
  IN1 w0.14: v1(121.41,44.62) 121.93,45.14 121.93,46.97 120.35,48.54 120.35,50.29 120.68,50.61 120.68,53.94 120.01,54.61 120.01,59.41 120.43,59.84 120.43,64.03 119.63,64.83 119.63,66.17 120.09,66.63 120.09,68.64 119.58,69.15 118.99,69.15 116.5,71.63 116.5,72.17 115.56,73.11 115.56,90.58 115.07,91.08 115.07,100.21 112.56,102.72 112.56,104.03 v1(112.06,104.53)
  BOTTOM w0.203: U35.AT50 v1(112.06,104.53) ; JDIM1.146 120.97,44.18 v1(121.41,44.62)
M_A_A11: length 65.1
  IN1 w0.14: v1(112.09,46.04) 111.59,45.54 111.05,45.54 110.8,45.79 110.8,46.5 110.1,47.2 110.1,49.66 108.08,51.68 108.08,65.93 107.01,67 107.01,90.84 108.71,92.54 108.71,93.6 v1(109.41,94.3)
  BOTTOM w0.076: 110.27,99.65 110.49,99.87 110.49,101.26 110.22,101.52 U35.BA54
  BOTTOM w0.102: 110.27,99.65 108.55,97.92 108.55,94.6 108.84,94.3 v1(109.41,94.3)
  BOTTOM w0.203: v1(112.09,46.04) 112.4,46.04 112.71,45.74 112.71,44.6 112.47,44.37 JDIM1.120
M_A_A12: length 66.5
  IN1 w0.14: v1(109.41,93.62) 108.96,93.18 108.96,92.41 107.43,90.88 107.43,67.17 107.83,66.77 108.29,66.77 108.5,66.57 108.5,51.86 110.52,49.83 110.52,47.45 110.96,47.01 111.36,47.01 111.54,47.19 111.54,47.42 111.38,47.57 111.38,47.94 v1(111.86,48.42)
  BOTTOM w0.076: 110.34,99.45 110.66,99.76 110.66,101.74 110.43,101.96 110.43,102.51 110.12,102.82 U35.AW54
  BOTTOM w0.102: 110.34,99.45 108.79,97.9 108.79,95.15 109.23,94.71 109.61,94.71 109.84,94.48 109.84,94.05 v1(109.41,93.62)
  BOTTOM w0.203: v1(111.86,48.42) 111.68,48.42 111.25,48.85 111.25,49.74 111.69,50.18 111.97,50.18 112.22,50.44 JDIM1.119
M_A_A13: length 68.4
  IN1 w0.14: v3(114.85,103.88) 114.85,102.35 116.08,101.11 116.77,101.11 117.28,100.6 117.28,99.33 117.57,99.04 117.57,90.66 117.76,90.46 117.76,73.93 121.9,69.8 122.18,69.8 123.37,68.6 123.63,68.6 124.21,68.02 124.21,61.79 124.53,61.47 124.53,56.47 123.6,55.54 123.6,54.53 124.03,54.1 124.03,51.86 123.25,51.07 123.25,47.87 124.38,46.74 124.38,46.35 124.2,46.17 v1(123.68,46.17)
  BOTTOM w0.203: v3(114.85,103.88) U35.AU46 ; v1(123.68,46.17) 123.95,46.17 124.16,45.96 124.16,44.7 123.97,44.51 JDIM1.158
M_A_ACT#: length 64.3
  IN1 w0.14: v1(107.57,98.34) 107.14,98.34 106.99,98.19 106.99,95.12 107.77,94.34 107.77,92.74 105.75,90.73 105.75,66.41 106.13,66.03 106.13,64.18 105.87,63.93 105.87,51.25 106.74,50.38 106.74,49.6 107.66,48.68 108.47,48.68 108.71,48.44 108.71,47.9 110.23,46.38 v1(110.23,45.93)
  BOTTOM w0.076: U35.BA55 109.33,101.83 109.33,101.6 109.28,101.47 109.28,101.36 109.33,101.22 109.33,100.68 109.21,100.56
  BOTTOM w0.102: 109.21,100.56 109.19,100.55 109.19,99.96 v1(107.57,98.34)
  BOTTOM w0.203: JDIM1.114 110.97,45.31 110.36,45.93 v1(110.23,45.93)
M_A_ALERT#: length 66.6
  IN1 w0.14: v1(110.63,94.1) 111.28,93.45 111.28,90.5 110.59,89.81 110.59,70.5 112.63,68.46 112.63,63.57 113.74,62.46 113.74,58.49 113.56,58.31 113.56,56.14 113,55.58 113,52.95 114.85,51.1 114.85,46.5 114.62,46.27 114.62,45.29 114.1,44.77 v1(112.09,44.77)
  BOTTOM w0.076: U35.AW50 112.85,102.71 112.85,101.76 112.91,101.7
  BOTTOM w0.102: 112.91,101.7 113.06,101.54 113.06,99.26 112.2,98.39 112.2,95.67 v1(110.63,94.1)
  BOTTOM w0.203: JDIM1.116 111.47,44.16 v1(112.09,44.77)
M_A_BA#0: length 67
  IN1 w0.14: v3(111.12,103.88) 112.07,102.93 112.07,102.61 113.47,101.21 113.47,100.34 114.79,99.02 114.79,90.9 115.14,90.55 115.14,72.93 116.08,71.99 116.08,71.46 118.82,68.73 119.41,68.73 119.67,68.47 119.67,66.8 119.21,66.34 119.21,64.66 120.01,63.85 120.01,60.01 119.54,59.54 119.54,54.49 119.93,54.09 119.93,48.37 120.88,47.41 120.88,46.43 v1(121.41,45.89)
  BOTTOM w0.203: v1(121.41,45.89) 121.54,45.89 121.97,45.46 JDIM1.150 ; U35.AU52 v3(111.12,103.88)
M_A_BA#1: length 66.5
  IN1 w0.14: v1(113.92,104.53) 113.9,104.53 113.51,104.13 113.51,103.48 113.98,103.02 113.98,102.08 115.63,100.43 115.63,99.01 116.16,98.48 116.16,90.95 116.41,90.7 116.41,73.5 117.34,72.58 117.34,72.02 117.58,71.77 118.14,71.77 118.32,71.6 118.32,71.4 118.22,71.3 118.22,71.1 118.39,70.93 118.59,70.93 118.69,71.03 118.88,71.03 119.05,70.86 119.05,70.66 118.95,70.57 118.95,70.37 119.13,70.2 119.32,70.2 119.42,70.3 119.62,70.3 121.42,68.49 121.42,68.04 121.28,67.9 121.07,67.9 120.93,67.76 120.93,67.51 121.07,67.38 121.28,67.38 121.42,67.24 121.42,66.99 121.28,66.85 121.07,66.85 120.93,66.71 120.93,66.47 121.07,66.33 121.28,66.33 121.47,66.15 121.47,65.55 121.34,65.42 121.11,65.42 120.86,65.17 120.86,64.78 121.42,64.22 121.42,61.61 121.93,61.11 121.93,56.56 121.67,56.31 121,56.31 120.85,56.15 120.85,55.39 120.97,55.26 121.27,55.26 121.54,54.99 121.54,52.57 121.81,52.3 121.81,49.84 v1(121.52,49.55)
  BOTTOM w0.203: v1(121.52,49.55) 121.15,49.55 120.72,49.97 JDIM1.145 ; v1(113.92,104.53) U35.AT48
M_A_BG#0: length 65.5
  IN1 w0.14: v1(109.22,48.01) 109.66,48.44 109.66,49.51 107.66,51.51 107.66,53.66 107.54,53.78 107.37,53.78 107.24,53.92 107.24,54.16 107.37,54.3 107.52,54.3 107.66,54.44 107.66,54.68 107.52,54.82 107.37,54.82 107.24,54.96 107.24,55.2 107.37,55.34 107.52,55.34 107.66,55.48 107.66,55.9 107.21,56.35 107.21,58.37 107.66,58.82 107.66,59.07 107.02,59.71 107.02,60.02 107.21,60.22 107.21,60.6 107.37,60.76 107.37,61.11 107.21,61.27 107.21,62.47 107.66,62.92 107.66,64.25 107.18,64.72 107.18,66.23 106.59,66.82 106.59,90.86 108.4,92.67 108.4,96.9 108.23,97.07 v1(107.57,97.07)
  BOTTOM w0.076: 109.88,100.1 109.99,100.21 109.99,100.66 109.79,100.86 109.79,101.23 109.8,101.26 109.84,101.34 109.84,101.46 109.77,101.68 109.77,101.82 109.83,101.98 109.83,102.16 109.75,102.32 109.46,102.61 U35.AY55
  BOTTOM w0.102: v1(107.57,97.07) 107.98,97.47 107.98,98.2 109.88,100.1
  BOTTOM w0.203: v1(109.22,48.01) 109.77,48.01 110.29,48.53 110.29,49.37 111.25,50.33 111.25,51.37 JDIM1.115
M_A_BG#1: length 65.7
  IN1 w0.14: v1(107.57,95.8) 107.86,95.8 108.1,95.56 108.1,92.72 106.17,90.79 106.17,66.65 106.77,66.05 106.77,64.55 107.1,64.21 107.1,63.98 106.95,63.82 106.51,63.82 106.36,63.67 106.36,63.44 106.51,63.29 106.88,63.29 107.03,63.14 107.03,62.91 106.88,62.76 106.46,62.76 106.29,62.59 106.29,59.45 106.48,59.26 106.86,59.26 107.07,59.06 107.07,58.82 106.79,58.55 106.79,53.18 106.86,53.11 107.09,53.11 107.24,52.95 107.24,52.67 107.09,52.52 106.46,52.52 106.3,52.37 106.3,52.15 106.46,52 107.1,52 107.24,51.86 107.24,51.63 107.09,51.48 106.75,51.48 106.6,51.33 106.6,51.11 106.75,50.96 107.09,50.96 107.24,50.81 107.24,50.08 107.39,49.93 107.59,49.93 107.91,50.25 108.25,50.25 v1(109.22,49.28)
  BOTTOM w0.076: 109.91,99.85 110.16,100.1 110.16,100.73 109.96,100.93 109.96,101.19 110.01,101.31 110.01,101.45 109.95,101.68 109.95,101.81 110.02,102.03 110.02,102.29 U35.AY54
  BOTTOM w0.102: v1(107.57,95.8) 108.17,96.39 108.17,98.11 109.91,99.85
  BOTTOM w0.203: JDIM1.113 110.72,50.34 109.66,49.28 v1(109.22,49.28)
