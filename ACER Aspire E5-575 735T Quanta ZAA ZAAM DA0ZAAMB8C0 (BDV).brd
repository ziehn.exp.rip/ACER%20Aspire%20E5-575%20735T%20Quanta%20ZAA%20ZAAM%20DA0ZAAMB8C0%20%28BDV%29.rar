# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.813x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC1808
  rect 2.159x2.286 smd: 1(-2.349,0) 2(2.349,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-DLP11SN900HL2L-4P-1
  rect 0.711x0.305 smd: 1(-0.625,0.275) 2(0.625,0.275) 3(0.625,-0.275) 4(-0.625,-0.275)
CHOKE-ETQP4LR36WFC-SMT
  rect 3.302x3.404 smd: 1(-4.65,0) 2(4.65,0)
CHOKE-PCMC063T-3R3MN-SMT
  rect 1.854x3.505 smd: 1(-3.275,0) 2(3.275,0)
CHOKE-PCMC063T-R82MN-4P-SMT
  custom 0.591x0.591 smd: 1(-3.596,0) 2(3.596,0)
  rect 1.473x0.305 smd: 3(-2.452,0) 4(2.452,0)
D-DO-214AC
  rect 1.88x2.032 smd: 1(-2.1,0) 2(2.1,0)
D-TO277_213-6_1X4_3
  rect 1.168x1.397 smd: 1(3.885,1.05) 2(3.885,-1.05)
  rect 4.648x3.505 smd: 3(0,0)
DDR4-D4AR0-26001-1P52-RVS-SMT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
DDR4-D4AS0-26001-1P52-STD-SMT
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DFN10-3X3-5-11P-RT9296
  rect 0.305x0.991 smd: 1(-1,-1.6) 2(-0.5,-1.6) 3(0,-1.6) 4(0.5,-1.6) 5(1,-1.6) 6(1,1.6) 7(0.5,1.6) 8(0,1.6) 9(-0.5,1.6) 10(-1,1.6)
  rect 2.464x1.626 smd: 11(0,0)
DSM
  rect 1.016x0.508 smd: 1(-1.3,0) 2(1.321,0)
DSMV
  rect 1.016x0.762 smd: 1(-1.27,0) 2(1.27,0)
DSUB-95-0005-01-15P
  round 0.965 hole 0.711: 1(-4.58,-0.9) 2(-2.29,-0.9) 3(0,-0.9) 4(2.29,-0.9) 5(4.58,-0.9) 6(-5.725,-0.9) 7(-3.435,-0.9) 8(-1.145,-0.9) 9(1.145,-0.9) 10(3.435,-0.9)
  round 1.118 hole 0.711: 11(-4.58,0.5) 12(-2.29,0.5) 13(0,0.5) 14(2.29,0.5) 15(4.58,0.5)
  oval 2.007x2.769 hole 0.991x1.753: 16(-10.05,0) 17(10.05,0)
ECAP6_3X6_1-7_2
  rect 3.505x1.6 smd: 1(2.8,0) 2(-2.8,0)
ESD10-4_1X2-8-11P
  rect 0.203x0.508 smd: 1(-1.8,-0.95) 2(-1,-0.95) 3(-0.2,-0.95) 4(0.6,-0.95) 5(1.4,-0.95) 6(1.8,0.95) 7(1,0.95) 8(0.2,0.95) 9(-0.6,0.95) 10(-1.4,0.95)
  rect 1.397x0.787 smd: 11(-0.4,0)
ESD-1X0_6-2P
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
ESD-3_8X1-9P
  rect 0.203x0.61 smd: 1(-1.7,-0.475) 2(-0.8,-0.475) 3(0,-0.475) 4(0.8,-0.475) 5(1.7,-0.475) 6(1.3,0.475) 7(0.4,0.475) 8(-0.4,0.475) 9(-1.3,0.475)
GS12401-1011-40P-R-NH-SMT
  round 0.94 hole 0.94 unplated: (-10.5,0) (10.5,0)
  rect 0.254x1.143 smd: 1(9.75,2.125) 2(9.25,2.125) 3(8.75,2.125) 4(8.25,2.125) 5(7.75,2.125) 6(7.25,2.125) 7(6.75,2.125) 8(6.25,2.125) 9(5.75,2.125) 10(5.25,2.125) 11(4.75,2.125) 12(4.25,2.125) 13(3.75,2.125) 14(3.25,2.125) 15(2.75,2.125) 16(2.25,2.125) 17(1.75,2.125) 18(1.25,2.125) 19(0.75,2.125) 20(0.25,2.125) 21(-0.25,2.125) 22(-0.75,2.125) 23(-1.25,2.125) 24(-1.75,2.125) 25(-2.25,2.125) 26(-2.75,2.125) 27(-3.25,2.125) 28(-3.75,2.125) 29(-4.25,2.125) 30(-4.75,2.125) 31(-5.25,2.125) 32(-5.75,2.125) 33(-6.25,2.125) 34(-6.75,2.125) 35(-7.25,2.125) 36(-7.75,2.125) 37(-8.25,2.125) 38(-8.75,2.125) 39(-9.25,2.125) 40(-9.75,2.125)
  rect 1.499x2.997 smd: 41(12.65,0) 42(-12.65,0)
  rect 2.794x1.499 smd: 43(5.7,-2.45) 44(-5.7,-2.45)
H-C87D87N
  round 2.21 hole 2.21 unplated: (0,0)
H-C217D217N
  round 5.512 hole 5.512 unplated: (0,0)
H-C236D140P2
  round 5.994 hole 3.556: 1(0,0)
H-C236I156D140P2
  round 5.994 hole 3.556: 1(0,0)
H-C256D161P2
  round 6.502 hole 4.089: 1(0,0)
H-O146X87D146X87N
  oval 3.708x2.21 hole 3.708x2.21 unplated: (0,0)
H-TC217IC197BC197D126P2
  round 5.004 hole 3.2: 1(0,0)
H-TC236IC236BC256D161P2
  round 6.502 hole 4.089: 1(0,0)
H-ZAB-5
  custom 1.403x1.403 hole 6.502: 1(0,0)
HDMI-10444-19001-19P
  round 0.813 hole 0.559: 1(-4.5,6.65) 2(-4,8.2) 3(-3.5,6.65) 4(-3,8.2) 5(-2.5,6.65) 6(-2,8.2) 7(-1.5,6.65) 8(-1,8.2) 9(-0.5,6.65) 10(0,8.2) 11(0.5,6.65) 12(1,8.2) 13(1.5,6.65) 14(2,8.2) 15(2.5,6.65) 16(3,8.2) 17(3.5,6.65) 18(4,8.2) 19(4.5,6.65)
  oval 1.803x2.794 hole 0.787x1.803: 20(-9.25,0) 22(9.25,0)
  oval 1.803x3.607 hole 0.787x2.591: 21(-7.25,7.6) 23(7.25,7.6)
HG-C315D134P2
  round 8.001 hole 3.404: 1(0,0)
  round 1.016 hole 0.61: 2(0,2.794) 3(-1.976,1.976) 4(-2.794,0) 5(-1.976,-1.976) 6(0,-2.794) 7(1.976,-1.976) 8(2.794,0) 9(1.976,1.976)
HG-C354D134P2
  round 8.992 hole 3.404: 1(0,0)
  round 1.016 hole 0.61: 2(0,3.048) 3(-2.155,2.155) 4(-3.048,0) 5(-2.155,-2.155) 6(0,-3.048) 7(2.155,-2.155) 8(3.048,0) 9(2.155,2.155)
HG-TC354IC236BC236D118P2
  round 8.992 hole 2.997: 1(0,0)
  round 1.016 hole 0.61: 2(0,2.349) 3(1.661,1.661) 4(2.349,0) 5(1.661,-1.661) 6(0,-2.349) 7(-1.661,-1.661) 8(-2.349,0) 9(-1.661,1.661)
HG-ZAB-2
  custom 2.25x2.25 hole 3.404: 1(0,0)
  round 1.016 hole 0.61: 2(0,2.349) 3(1.661,1.661) 4(2.349,0) 5(1.661,-1.661) 6(0,-2.349) 7(-1.661,-1.661) 8(-2.349,0) 9(-1.661,1.661)
HS8803F-3P-L
  rect 0.787x1.905 smd: 1(-1.25,4.875) 2(0,4.875) 3(1.25,4.875)
  rect 1.295x3.353 smd: 4(-4.1,0) 5(4.1,0)
JOPEN25X30_S
  custom 0.159x0.159 smd: 1(-0.368,0) 2(0.368,0)
L3_2X2_5-1_55
  rect 1.245x2.007 smd: 1(-1.275,0) 2(1.275,0)
LEDLTST-S326KGJRKT-3P-SMT
  rect 0.991x0.991 smd: 1(-1.5,0) 3(1.5,0)
  rect 0.889x0.889 smd: 2(0,-0.65)
LGA16-3X3-5
  rect 0.305x0.94 smd: 1(-1,-1.525) 2(-0.5,-1.525) 3(0,-1.525) 4(0.5,-1.525) 5(1,-1.525) 9(1,1.525) 10(0.5,1.525) 11(0,1.525) 12(-0.5,1.525) 13(-1,1.525)
  rect 0.94x0.305 smd: 6(1.525,-0.5) 7(1.525,0) 8(1.525,0.5) 14(-1.525,0.5) 15(-1.525,0) 16(-1.525,-0.5)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
MIC-KMM40301026-11DN-8P
  rect 0.457x0.94 smd: 1(-0.425,0.675) 2(-0.425,-0.675) 3(0.425,-0.675) 4(0.425,0.675)
  rect 1.295x0.457 smd: 5(0,1.775) 7(0,-1.775)
  rect 0.457x2.311 smd: 6(-1.275,0) 8(1.275,0)
NGFF-NASE0-S6701-TS48-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NASM0-S6701-TS50-KM-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
O-ZAA-1
  round 6.502 hole 6.502 unplated: (0,0)
O-ZAB-1
  custom 0.903x0.903 smd: 1(0,0)
O-ZAB-2
  round 8.992 hole 2.997: 1(0,0)
  round 1.016 hole 0.61: 2(2.349,0) 3(1.661,-1.661) 4(0,-2.349) 5(-1.661,-1.661) 6(-2.349,0)
POWER-3_3X3_3-65-5P-SMT
  rect 0.762x0.432 smd: 1(1.43,-0.975) 2(1.43,-0.325) 3(1.43,0.325) 4(1.43,0.975)
  custom 0.562x0.562 smd: 5(-0.725,0)
POWER-3_5X5-5-14P
  rect 0.254x0.559 smd: 1(-1,-2.325) 2(-0.5,-2.325) 3(0,-2.325) 4(0.5,-2.325) 5(1,-2.325)
  rect 2.972x1.473 smd: 6(0.37,-1.115)
  custom 0.588x0.588 smd: 9(0,0)
  rect 1.956x0.686 smd: 13(0.25,2.262)
  rect 0.559x0.254 smd: 19(-1.575,0.5) 20(-1.575,0) 21(-1.575,-0.5) 22(-1.575,-1) 23(-1.575,-1.5)
  rect 0.533x0.254 smd: 24(-1.575,-2)
POWER-5X6-1_27-7P
  rect 0.635x0.66 smd: 1(2.835,-1.905) 5(-2.835,1.905) 6(-2.835,0.635) 7(-2.835,-0.635) 8(-2.835,-1.905)
  custom 0.485x0.485 smd: 2(2.18,0.115)
  rect 2.159x3.988 smd: 9(-0.525,0)
QFN13-2X3-5
  rect 0.254x1.499 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 8(0,0.55)
  rect 0.711x0.254 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 10(-1.45,0.75) 11(-1.45,0.25) 12(-1.45,-0.25) 13(-1.45,-0.75)
  rect 0.254x0.711 smd: 7(0.5,0.95) 9(-0.5,0.95)
QFN16-3X3-5-22P-TPS2544RTER
  custom 0.07x0.07 smd: 1(-0.75,-1.475) 2(-0.25,-1.475) 3(0.25,-1.475) 4(0.75,-1.475) 5(1.475,-0.75) 6(1.475,-0.25) 7(1.475,0.25) 8(1.475,0.75) 9(0.75,1.475) 10(0.25,1.475) 11(-0.25,1.475) 12(-0.75,1.475) 13(-1.475,0.75) 14(-1.475,0.25) 15(-1.475,-0.25) 16(-1.475,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
  round 0.508 hole 0.305: 18(-0.5,-0.5) 19(0.5,-0.5) 20(0.5,0.5) 21(-0.5,0.5) 22(0,0)
QFN20-3X3-4-21P-0_8H
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.6x1.6 smd: 21(0,0)
QFN20-3X3-4-26P
  rect 0.203x0.787 smd: 1(-0.8,-1.5) 2(-0.4,-1.5) 3(0,-1.5) 4(0.4,-1.5) 5(0.8,-1.5) 11(0.8,1.5) 12(0.4,1.5) 13(0,1.5) 14(-0.4,1.5) 15(-0.8,1.5)
  rect 0.787x0.203 smd: 6(1.5,-0.8) 7(1.5,-0.4) 8(1.5,0) 9(1.5,0.4) 10(1.5,0.8) 16(-1.5,0.8) 17(-1.5,0.4) 18(-1.5,0) 19(-1.5,-0.4) 20(-1.5,-0.8)
  rect 1.803x1.803 smd: 21(0,0)
  round 0.508 hole 0.305: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5) 26(0,0)
QFN20-4X3-5-27P
  rect 0.203x0.61 smd: 1(-1.25,-1.4) 2(-0.75,-1.4) 3(-0.25,-1.4) 4(0.25,-1.4) 5(0.75,-1.4) 6(1.25,-1.4) 11(1.25,1.4) 12(0.75,1.4) 13(0.25,1.4) 14(-0.25,1.4) 15(-0.75,1.4) 16(-1.25,1.4)
  rect 0.61x0.203 smd: 7(1.9,-0.75) 8(1.9,-0.25) 9(1.9,0.25) 10(1.9,0.75) 17(-1.9,0.75) 18(-1.9,0.25) 19(-1.9,-0.25) 20(-1.9,-0.75)
  rect 2.591x1.6 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-1,-0.5) 23(0,-0.5) 24(1,-0.5) 25(1,0.5) 26(0,0.5) 27(-1,0.5)
QFN23-4X4-5-25P
  rect 0.254x0.787 smd: 1(-1.25,-2) 2(-0.75,-2) 3(-0.25,-2) 4(0.25,-2) 5(0.75,-2) 6(1.25,-2) 12(1.25,2) 13(0.75,2) 14(0.25,2) 15(-0.25,2) 16(-0.75,2) 17(-1.25,2)
  rect 0.787x0.254 smd: 7(2,-1.25) 8(2,-0.75) 9(2,-0.25) 10(2,0.75) 11(2,1.25) 18(-2,1.25) 19(-2,0.75) 20(-2,0.25) 21(-2,-0.25) 22(-2,-0.75) 23(-2,-1.25)
  rect 2.591x1.295 smd: 24(0,-0.65)
  rect 2.591x0.889 smd: 25(0,0.85)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.61 hole 0.305: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-5X5-5-33P-0_85H
  rect 0.305x0.991 smd: 1(-1.75,-2.6) 2(-1.25,-2.6) 3(-0.75,-2.6) 4(-0.25,-2.6) 5(0.25,-2.6) 6(0.75,-2.6) 7(1.25,-2.6) 8(1.75,-2.6) 17(1.75,2.6) 18(1.25,2.6) 19(0.75,2.6) 20(0.25,2.6) 21(-0.25,2.6) 22(-0.75,2.6) 23(-1.25,2.6) 24(-1.75,2.6)
  rect 0.991x0.305 smd: 9(2.6,-1.75) 10(2.6,-1.25) 11(2.6,-0.75) 12(2.6,-0.25) 13(2.6,0.25) 14(2.6,0.75) 15(2.6,1.25) 16(2.6,1.75) 25(-2.6,1.75) 26(-2.6,1.25) 27(-2.6,0.75) 28(-2.6,0.25) 29(-2.6,-0.25) 30(-2.6,-0.75) 31(-2.6,-1.25) 32(-2.6,-1.75)
  rect 3.505x3.505 smd: 33(0,0)
QFN32-5X5-5-37P-0_85H
  rect 0.279x0.838 smd: 1(-1.75,-2.55) 2(-1.25,-2.55) 3(-0.75,-2.55) 4(-0.25,-2.55) 5(0.25,-2.55) 6(0.75,-2.55) 7(1.25,-2.55) 8(1.75,-2.55) 17(1.75,2.55) 18(1.25,2.55) 19(0.75,2.55) 20(0.25,2.55) 21(-0.25,2.55) 22(-0.75,2.55) 23(-1.25,2.55) 24(-1.75,2.55)
  rect 0.838x0.279 smd: 9(2.55,-1.75) 10(2.55,-1.25) 11(2.55,-0.75) 12(2.55,-0.25) 13(2.55,0.25) 14(2.55,0.75) 15(2.55,1.25) 16(2.55,1.75) 25(-2.55,1.75) 26(-2.55,1.25) 27(-2.55,0.75) 28(-2.55,0.25) 29(-2.55,-0.25) 30(-2.55,-0.75) 31(-2.55,-1.25) 32(-2.55,-1.75)
  rect 3.759x3.759 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-0.6,-0.6) 35(0.6,-0.6) 36(0.6,0.6) 37(-0.6,0.6)
QFN40-5X5-4-41P-ISL62771-SMT
  rect 0.203x0.838 smd: 1(-1.8,-2.514) 2(-1.4,-2.514) 3(-1,-2.514) 4(-0.6,-2.514) 5(-0.2,-2.514) 6(0.2,-2.514) 7(0.6,-2.514) 8(1,-2.514) 9(1.4,-2.514) 10(1.8,-2.514) 21(1.8,2.514) 22(1.4,2.514) 23(1,2.514) 24(0.6,2.514) 25(0.2,2.514) 26(-0.2,2.514) 27(-0.6,2.514) 28(-1,2.514) 29(-1.4,2.514) 30(-1.8,2.514)
  rect 0.838x0.203 smd: 11(2.514,-1.8) 12(2.514,-1.4) 13(2.514,-1) 14(2.514,-0.6) 15(2.514,-0.2) 16(2.514,0.2) 17(2.514,0.6) 18(2.514,1) 19(2.514,1.4) 20(2.514,1.8) 31(-2.514,1.8) 32(-2.514,1.4) 33(-2.514,1) 34(-2.514,0.6) 35(-2.514,0.2) 36(-2.514,-0.2) 37(-2.514,-0.6) 38(-2.514,-1) 39(-2.514,-1.4) 40(-2.514,-1.8)
  rect 3.505x3.505 smd: 41(0,0)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.813x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
RJ45-JM361C-HP34AA03-9H-8P
  round 1.295 hole 0.889: 1(3.57,10.1) 2(2.55,11.2) 3(1.53,10.1) 4(0.51,11.2) 5(-0.51,10.1) 6(-1.53,11.2) 7(-2.55,10.1) 8(-3.57,11.2)
  oval 1.092x2.108 hole 0.61x1.6: 9(8.4,0) 10(8.4,7.8) 11(-8.4,0) 12(-8.4,7.8)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SATA-C166FQ-12208-L-22P-R
  round 1.067 hole 0.711: 1(15.875,-0.8) 2(14.605,-0.8) 3(13.335,-0.8) 4(12.065,-0.8) 5(10.795,-0.8) 6(9.525,-0.8) 7(8.255,-0.8) 8(1.905,-0.8) 9(0.635,-0.8) 10(-0.635,-0.8) 11(-1.905,-0.8) 12(-3.175,-0.8) 13(-4.445,-0.8) 14(-5.715,-0.8) 15(-6.985,-0.8) 16(-8.255,-0.8) 17(-9.525,-0.8) 18(-10.795,-0.8) 19(-12.065,-0.8) 20(-13.335,-0.8) 21(-14.605,-0.8) 22(-15.875,-0.8)
  oval 1.803x2.87 hole 0.991x2.083: 23(18.71,0) 24(-18.71,0)
SATA-C185Q2-11311-L-13P-R
  round 1.092 hole 1.092 unplated: (-11.85,0) (11.85,0)
  round 1.067 hole 0.711: 1(9.38,0) 2(8.11,0) 3(6.84,0) 4(5.57,0) 5(4.3,0) 6(3.03,0) 7(1.76,0)
  round 1.016 hole 0.61: 8(-4.45,0) 9(-5.45,1.5) 10(-6.45,0) 11(-7.45,1.5) 12(-8.45,0) 13(-9.45,1.5)
  oval 1.803x3.2 hole 0.991x2.388: 14(13.43,0.7) 15(-13.43,0.7)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SDCARD-PSDAT4-11GLBS1NN4H4-11P
  round 1.092 hole 1.092 unplated: (-11.5,0)
  round 1.6 hole 1.6 unplated: (9.5,0)
  rect 0.991x1.499 smd: 1(6.875,2.8) 2(4.375,2.8) 3(1.875,2.8) 4(-0.625,2.8) 5(-3.125,2.8) 6(-5.625,2.8) 7(-8.125,2.8) 8(-9.755,2.8) 9(9.375,2.8)
  rect 0.711x1.499 smd: 10(-11.055,2.8) 11(-12.205,2.8)
  rect 1.499x2.794 smd: 12(11.3,1) 13(-13.65,1) 14(13.65,-13.6) 15(-13.65,-13.6)
SHORT3720
  rect 3.759x1.537 smd: 1(0,1.008) 2(0,-1.008)
SLP10-2_5X1-5-10P
  rect 0.203x0.686 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.406x1.549 smd: 3(0,0)
SO-8FL-5P-OA
  rect 0.991x0.762 smd: 1(3.73,-1.905) 2(3.73,-0.635) 3(3.73,0.635) 4(3.73,1.905)
  custom 1.132x1.132 smd: 5(0,0)
SOIC8-6-1_27
  rect 0.533x1.753 smd: 1(-1.905,-2.73) 2(-0.635,-2.73) 3(0.635,-2.73) 4(1.905,-2.73) 5(1.905,2.73) 6(0.635,2.73) 7(-0.635,2.73) 8(-1.905,2.73)
SOIC8-8-1_27
  rect 0.533x1.6 smd: 1(-1.905,-3.8) 2(-0.635,-3.8) 3(0.635,-3.8) 4(1.905,-3.8) 5(1.905,3.8) 6(0.635,3.8) 7(-0.635,3.8) 8(-1.905,3.8)
SON14-3X2-4-15P
  custom 0.05x0.05 smd: 1(-1.2,-1.025) 2(-0.8,-1.025) 3(-0.4,-1.025) 4(0,-1.025) 5(0.4,-1.025) 6(0.8,-1.025) 7(1.2,-1.025) 8(1.2,1.025) 9(0.8,1.025) 10(0.4,1.025) 11(0,1.025) 12(-0.4,1.025) 13(-0.8,1.025) 14(-1.2,1.025)
  rect 2.489x0.889 smd: 15(0,0)
SOP8-6-1_27-9P
  rect 0.533x1.727 smd: 1(-1.905,-2.73) 2(-0.635,-2.73) 3(0.635,-2.73) 4(1.905,-2.73) 5(1.905,2.73) 6(0.635,2.73) 7(-0.635,2.73) 8(-1.905,2.73)
  rect 3.302x2.794 smd: 9(0,0)
SOT23-2_8-95-6P
  rect 1.346x0.508 smd: 1(1.325,-0.95) 2(1.325,0) 3(1.325,0.95) 4(-1.325,0.95) 5(-1.325,0) 6(-1.325,-0.95)
SOT23-5
  rect 1.016x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23_123-2_8-1_9
  rect 1.092x0.533 smd: 1(1.45,-0.95) 2(1.45,0.95) 3(-1.45,0)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT323_213-2_1-1_3-2N7002W
  rect 0.787x0.61 smd: 1(0.8,0.65) 2(0.8,-0.65) 3(-0.8,0)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SPAD-C197NP
  round 5.004 smd: 1(0,0)
SPAD-C276NP
  round 7.01 smd: 1(0,0)
SPAD-C298NP
  round 7.569 smd: 1(0,0)
SPAD-RE157X315NP
  rect 3.988x8.001 smd: 1(0,0)
SPAD-RE157X488NP
  rect 3.988x12.395 smd: 1(0,0)
SPAD-RE157X491NP
  rect 3.988x12.471 smd: 1(0,0)
SPAD-RE157X1267NP
  rect 3.988x32.182 smd: 1(0,0)
SPAD-RE157X1282NP
  rect 3.988x32.563 smd: 1(0,0)
SPAD-RE531X205NP
  rect 13.487x5.207 smd: 1(0,0)
SPAD-ZAB-1NP
  custom 1.3x1.3 smd: 1(0,0)
SPAD-ZAB-2NP
  custom 1.25x1.25 smd: 1(0,0)
SPAD-ZAB-3NP
  custom 1.535x1.535 smd: 1(0,0)
SSOP5-P-A-TOSHIBA-B
  rect 1.067x0.305 smd: 1(0.85,-0.65) 2(0.85,0) 3(0.85,0.65) 4(-0.85,0.65) 5(-0.85,-0.65)
SW-DS-A40E-4P
  round 1.041 hole 1.041 unplated: (0,-1.5)
  oval 0.838x0.94 hole 0.838x0.94 unplated: (0,1)
  rect 0.787x1.194 smd: 1(-2.15,-1.2) 2(-2.15,1.2) 3(2.15,-1.2) 4(2.15,1.2)
SW-TME-532-V-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TQFN10-1_6X1_3-4-SMT
  rect 0.203x0.711 smd: 1(-0.2,-0.46) 2(0.2,-0.46) 6(0.2,0.46) 7(-0.2,0.46)
  rect 0.61x0.203 smd: 3(0.785,-0.4) 4(0.785,0) 5(0.785,0.4) 8(-0.785,0.4) 9(-0.785,0) 10(-0.785,-0.4)
TQFN32-3X6-4-41P-0_8H
  custom 0.05x0.05 smd: 1(-2,-1.5) 2(-1.6,-1.5) 3(-1.2,-1.5) 4(-0.8,-1.5) 5(-0.4,-1.5) 6(0,-1.5) 7(0.4,-1.5) 8(0.8,-1.5) 9(1.2,-1.5) 10(1.6,-1.5) 11(2,-1.5) 12(3,-0.8) 13(3,-0.4) 14(3,0) 15(3,0.4) 16(3,0.8) 17(2,1.5) 18(1.6,1.5) 19(1.2,1.5) 20(0.8,1.5) 21(0.4,1.5) 22(0,1.5) 23(-0.4,1.5) 24(-0.8,1.5) 25(-1.2,1.5) 26(-1.6,1.5) 27(-2,1.5) 28(-3,0.8) 29(-3,0.4) 30(-3,0) 31(-3,-0.4) 32(-3,-0.8)
  rect 4.597x1.803 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1.5,-0.5) 35(-0.5,-0.5) 36(0.5,-0.5) 37(1.5,-0.5) 38(1.5,0.5) 39(0.5,0.5) 40(-0.5,0.5) 41(-1.5,0.5)
TRF-N1010G-25P
  rect 0.635x1.778 smd: 1(-5.5,-4.54) 2(-4.5,-4.54) 3(-3.5,-4.54) 4(-2.5,-4.54) 5(-1.5,-4.54) 6(-0.5,-4.54) 7(0.5,-4.54) 8(1.5,-4.54) 9(2.5,-4.54) 10(3.5,-4.54) 11(4.5,-4.54) 12(5.5,-4.54) 13(5.5,4.45) 14(4.5,4.45) 15(3.5,4.45) 16(2.5,4.45) 17(1.5,4.45) 18(0.5,4.45) 19(-0.5,4.45) 20(-1.5,4.45) 21(-2.5,4.45) 22(-3.5,4.45) 23(-4.5,4.45) 24(-5.5,4.45)
  rect 0.889x0.787 smd: 25(-6.82,0)
TSOP6-2_8-95
  rect 0.787x0.635 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,0) 6(-1.2,-0.95)
UB3-YUSB0021-P001A-9P-SMT
  round 1.295 hole 0.813: 1(3.5,7.6) 2(1,7.6) 3(-1,7.6) 4(-3.5,7.6) 5(-4,6.1) 6(-2,6.1) 7(0,6.1) 8(2,6.1) 9(4,6.1)
  oval 1.295x2.896 hole 0.711x2.311: 10(6.4,6.85) 11(-6.4,6.85)
  oval 1.295x2.108 hole 0.711x1.499: 12(-7.85,0.4) 13(7.85,-2.6)
UB31-DX07B024XJ1AR1000-24P-SMT
  round 0.787 hole 0.787 unplated: (-3.6,0)
  oval 0.94x0.787 hole 0.94x0.787 unplated: (3.6,0)
  oval 1.092x1.956 hole 0.61x1.448: 1(-4.8,-0.875) 2(4.8,-0.875)
  oval 1.092x2.388 hole 0.61x1.6: 3(-5.8,-5.1) 4(5.8,-5.1)
  rect 0.305x1.092 smd: A1(-2.75,0.66) A2(-2.25,0.66) A3(-1.75,0.66) A4(-1.25,0.66) A5(-0.75,0.66) A6(-0.25,0.66) A7(0.25,0.66) A8(0.75,0.66) A9(1.25,0.66) A10(1.75,0.66) A11(2.25,0.66) A12(2.75,0.66)
  round 0.61 hole 0.406: B1(2.8,-0.55) B2(2.4,-1.35) B3(1.6,-1.35) B4(1.35,-0.55) B5(0.8,-1.35) B6(0.4,-0.55) B7(-0.4,-0.55) B8(-0.8,-1.35) B9(-1.35,-0.55) B10(-1.6,-1.35) B11(-2.4,-1.35) B12(-2.8,-0.55)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed#2
  round 1.016 smd: 1(0,0)
WDFN5-3_05X3_05-65
  rect 0.66x0.432 smd: 1(1.385,-0.975) 2(1.385,-0.325) 3(1.385,0.325) 4(1.385,0.975)
  custom 0.575x0.575 smd: 5(-0.735,0)
WQFN20-3X3-4-21P
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.702x1.702 smd: 21(0,0)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTL-3_2X2_5-2_2X1_7-4P
  rect 1.397x1.194 smd: 1(1.1,0.85) 2(-1.1,0.85) 3(-1.1,-0.85) 4(1.1,-0.85)

## Nets
2.469V: PR144.2 PR145.1 PU4.3
3.3V_AUX: TP4000.1 U3002.P8
3V_LDO: PC6098.1 PR6280.1 PR6296.1 PU6010.3
3V_LR: C4773.1 C4774.1 C4775.1 L4209.1 R203.1 R206.1 R254.1 R258.1 R617.2 R11211.1 R11212.1 R11213.1 R11214.1 U9.9 U9.25
3V_MAIN_PWGD: PR321.2 PR345.1 Q4200.3 R4200.1 R4202.2
+1.2VSUS: C308.2 C311.2 C312.2 C313.2 C318.1 C323.1 C325.1 C326.1 C327.1 C328.1 C1244.1 C1246.1 C1247.1 C1248.1 C1250.1 C1253.1 C1254.1 C1256.1 C1260.1 C1261.1 C1262.1 C1263.1 C1264.1 C1271.1 C1272.1 C1273.1 C1308.1 C1309.1 C1312.1 C1313.1 C1314.1 C1318.1 C1321.1 C1325.1 C1328.1 C1330.1 C1331.1 C1332.1 C1334.1 C1335.1 C1336.1 C1337.1 EC36.1 EC37.1 EC38.1 EC39.1 EC41.1 EC42.1 EC43.1 EC44.1 EC45.1 EC46.1 EC47.1 EC48.1 EC49.1 EC50.1 JDIM1.12 JDIM1.33 JDIM1.54 JDIM1.75 JDIM1.96 JDIM1.111 JDIM1.112 JDIM1.117 JDIM1.118 JDIM1.123 JDIM1.124 JDIM1.129 JDIM1.130 JDIM1.135 JDIM1.136 JDIM1.141 JDIM1.142 JDIM1.147 JDIM1.148 JDIM1.153 JDIM1.154 JDIM1.159 JDIM1.160 JDIM1.163 JDIM1.178 JDIM1.199 JDIM1.220 JDIM1.241 JDIM2.12 JDIM2.33 JDIM2.54 JDIM2.75 JDIM2.96 JDIM2.111 JDIM2.112 JDIM2.117 JDIM2.118 JDIM2.123 JDIM2.124 JDIM2.129 JDIM2.130 JDIM2.135 JDIM2.136 JDIM2.141 JDIM2.142 JDIM2.147 JDIM2.148 JDIM2.153 JDIM2.154 JDIM2.159 JDIM2.160 JDIM2.163 JDIM2.178 JDIM2.199 JDIM2.220 JDIM2.241 PC194.1 PC198.1 PC205.1 PC215.1 PC216.1 PC219.1 PC284.1 PL11.2 PR254.1 PU21.19 Q35.2 R194.1 R679.1 R10871.1 R10875.1 R10879.1 R10881.1 R10883.1 R10884.1 R10885.1 R10888.1 R10891.1 R10892.1 R10894.1 R10896.1 R10922.1 R10925.1 R10926.1 R10928.1 R10929.1 R10931.1 R10933.1 R10934.1 R10936.1 R10939.1 R10941.1 R10942.1 U35.AU23 U35.AU28 U35.AU35 U35.AU42 U35.BB23 U35.BB32 U35.BB41 U35.BB47 U35.BB51
+1.5V: C541.2 C759.2 L18.2 PR1247.2 Q29.2 Q38.1 R366.2 R683.2 R712.1
+1.05V_GFX: C4000.2 C4001.2 C4002.2 C4003.2 C4004.1 C4005.1 C4006.1 C4007.1 C4008.2 C4009.2 C4010.2 C4011.2 C4012.2 C4014.2 L4100.2 L4200.1 L4201.1 L4207.2 PC302.1 PC303.2 PL14.2 PR311.2 R4010.1 U3002.AG13 U3002.AG15 U3002.AG16 U3002.AG18 U3002.AG19 U3002.AG21 U3002.AG22 U3002.AG24 U3002.AG25 U3002.AH15 U3002.AH18 U3002.AH21 U3002.AH25 U3002.AH26 U3002.AH27 U3002.AJ27 U3002.AK27 U3002.AL27 U3002.AM28 U3002.AN28
+1.5VA: C520.1 C524.1 L18.1 U23.40
+1.8V_PRIM: C686.1 C687.1 R565.1 U35.G61 U35.H63
+1.8V_S5: PR1249.2 R180.2 R192.2 R565.2 R590.2 R593.2 R599.2 R600.2 R607.2 R608.2 R611.2 R613.2 R615.2 R765.2 R767.2 R775.1
+1.35V_GFX: C4100.2 C4101.2 C4102.2 C4103.2 C4104.2 C4105.2 C4106.2 C4107.2 C4108.2 C4109.2 C4110.2 C4111.2 C4113.2 C4115.2 C4117.2 C4119.2 C4512.2 C4513.2 C4514.1 C4515.2 C4516.2 C4517.2 C4518.2 C4519.2 C4520.2 C4521.2 C4522.2 C4523.1 C4524.2 C4525.2 C4526.2 C4527.2 C4528.1 C4529.1 C4530.1 C4531.1 C4532.1 C4533.1 C4534.1 C4535.1 C4536.1 C4537.1 C4538.1 C4539.1 C4540.1 C4541.1 C4542.1 C4543.1 C4544.1 C4545.1 C4546.1 C4547.1 C4548.1 C4549.1 C4550.1 C4551.1 C4552.1 C4553.1 C4554.1 C4555.1 C4666.1 C4667.1 C4668.2 C4669.1 C4670.1 C4671.1 C4672.2 C4673.1 C4674.1 C4675.2 C4676.2 C4677.1 C4678.1 C4679.2 C4680.1 C4681.1 C4682.1 C4683.2 C4684.2 C4685.1 C4686.1 C4687.1 C4688.2 C4689.1 C4690.2 C4691.2 C4692.2 C4693.2 C4694.1 C4695.1 C4696.1 C4697.2 C4698.1 C4699.1 C4700.1 C4701.1 C4702.1 C4703.2 C4704.1 C4705.1 C4706.1 C4707.1 C4708.1 C4709.1 C4815.2 PC273.1 PC274.2 PC275.1 PC278.1 PC279.1 PC281.1 PC282.1 PC287.1 PC288.1 PL18.2 PR108.1 R4100.1 R4102.1 R4103.1 R4105.1 R4115.2 R4117.1 R4510.1 R4512.1 R4514.1 R4516.1 R4518.1 R4520.1 R4522.1 R4524.1 R4538.2 R4541.2 R4551.1 R4557.1 R11071.1 R11072.2 R11074.1 R11077.1 R11081.1 R11082.1 R11086.2 R11095.1 R11096.1 R11099.1 R11101.1 R11104.1 U3002.AA27 U3002.AA30 U3002.AB27 U3002.AB33 U3002.AC27 U3002.AD27 U3002.AE27 U3002.AF27 U3002.AG27 U3002.B13 U3002.B16 U3002.B19 U3002.E13 U3002.E16 U3002.E19 U3002.H8 U3002.H9 U3002.H10 U3002.H11 U3002.H12 U3002.H13 U3002.H14 U3002.H15 U3002.H16 U3002.H18 U3002.H19 U3002.H20 U3002.H21 U3002.H22 U3002.H23 U3002.H24 U3002.L27 U3002.M27 U3002.N27 U3002.P27 U3002.R27 U3002.T27 U3002.T30 U3002.T33 U3002.V27 U3002.W27 U3002.W30 U3002.W33 U3002.Y27 VRAM3000.B1 VRAM3000.B3 VRAM3000.B12 VRAM3000.B14 VRAM3000.C5 VRAM3000.C10 VRAM3000.D1 VRAM3000.D3 VRAM3000.D11 VRAM3000.D12 VRAM3000.D14 VRAM3000.E5 VRAM3000.E10 VRAM3000.F1 VRAM3000.F3 VRAM3000.F12 VRAM3000.F14 VRAM3000.G1 VRAM3000.G2 VRAM3000.G4 VRAM3000.G11 VRAM3000.G13 VRAM3000.G14 VRAM3000.H3 VRAM3000.H12 VRAM3000.K3 VRAM3000.K12 VRAM3000.L1 VRAM3000.L2 VRAM3000.L4 VRAM3000.L11 VRAM3000.L13 VRAM3000.L14 VRAM3000.M1 VRAM3000.M3 VRAM3000.M12 VRAM3000.M14 VRAM3000.N5 VRAM3000.N10 VRAM3000.P1 VRAM3000.P3 VRAM3000.P11 VRAM3000.P12 VRAM3000.P14 VRAM3000.R5 VRAM3000.R10 VRAM3000.T1 VRAM3000.T3 VRAM3000.T12 VRAM3000.T14 VRAM3001.B1 VRAM3001.B3 VRAM3001.B12 VRAM3001.B14 VRAM3001.C5 VRAM3001.C10 VRAM3001.D1 VRAM3001.D3 VRAM3001.D11 VRAM3001.D12 VRAM3001.D14 VRAM3001.E5 VRAM3001.E10 VRAM3001.F1 VRAM3001.F3 VRAM3001.F12 VRAM3001.F14 VRAM3001.G1 VRAM3001.G2 VRAM3001.G4 VRAM3001.G11 VRAM3001.G13 VRAM3001.G14 VRAM3001.H3 VRAM3001.H12 VRAM3001.K3 VRAM3001.K12 VRAM3001.L1 VRAM3001.L2 VRAM3001.L4 VRAM3001.L11 VRAM3001.L13 VRAM3001.L14 VRAM3001.M1 VRAM3001.M3 VRAM3001.M12 VRAM3001.M14 VRAM3001.N5 VRAM3001.N10 VRAM3001.P1 VRAM3001.P3 VRAM3001.P11 VRAM3001.P12 VRAM3001.P14 VRAM3001.R5 VRAM3001.R10 VRAM3001.T1 VRAM3001.T3 VRAM3001.T12 VRAM3001.T14 VRAM3002.B1 VRAM3002.B3 VRAM3002.B12 VRAM3002.B14 VRAM3002.C5 VRAM3002.C10 VRAM3002.D1 VRAM3002.D3 VRAM3002.D11 VRAM3002.D12 VRAM3002.D14 VRAM3002.E5 VRAM3002.E10 VRAM3002.F1 VRAM3002.F3 VRAM3002.F12 VRAM3002.F14 VRAM3002.G1 VRAM3002.G2 VRAM3002.G4 VRAM3002.G11 VRAM3002.G13 VRAM3002.G14 VRAM3002.H3 VRAM3002.H12 VRAM3002.K3 VRAM3002.K12 VRAM3002.L1 VRAM3002.L2 VRAM3002.L4 VRAM3002.L11 VRAM3002.L13 VRAM3002.L14 VRAM3002.M1 VRAM3002.M3 VRAM3002.M12 VRAM3002.M14 VRAM3002.N5 VRAM3002.N10 VRAM3002.P1 VRAM3002.P3 VRAM3002.P11 VRAM3002.P12 VRAM3002.P14 VRAM3002.R5 VRAM3002.R10 VRAM3002.T1 VRAM3002.T3 VRAM3002.T12 VRAM3002.T14 VRAM3003.B1 VRAM3003.B3 VRAM3003.B12 VRAM3003.B14 VRAM3003.C5 VRAM3003.C10 VRAM3003.D1 VRAM3003.D3 VRAM3003.D11 VRAM3003.D12 VRAM3003.D14 VRAM3003.E5 VRAM3003.E10 VRAM3003.F1 VRAM3003.F3 VRAM3003.F12 VRAM3003.F14 VRAM3003.G1 VRAM3003.G2 VRAM3003.G4 VRAM3003.G11 VRAM3003.G13 VRAM3003.G14 VRAM3003.H3 VRAM3003.H12 VRAM3003.K3 VRAM3003.K12 VRAM3003.L1 VRAM3003.L2 VRAM3003.L4 VRAM3003.L11 VRAM3003.L13 VRAM3003.L14 VRAM3003.M1 VRAM3003.M3 VRAM3003.M12 VRAM3003.M14 VRAM3003.N5 VRAM3003.N10 VRAM3003.P1 VRAM3003.P3 VRAM3003.P11 VRAM3003.P12 VRAM3003.P14 VRAM3003.R5 VRAM3003.R10 VRAM3003.T1 VRAM3003.T3 VRAM3003.T12 VRAM3003.T14 VRAM3004.B1 VRAM3004.B3 VRAM3004.B12 VRAM3004.B14 VRAM3004.C5 VRAM3004.C10 VRAM3004.D1 VRAM3004.D3 VRAM3004.D11 VRAM3004.D12 VRAM3004.D14 VRAM3004.E5 VRAM3004.E10 VRAM3004.F1 VRAM3004.F3 VRAM3004.F12 VRAM3004.F14 VRAM3004.G1 VRAM3004.G2 VRAM3004.G4 VRAM3004.G11 VRAM3004.G13 VRAM3004.G14 VRAM3004.H3 VRAM3004.H12 VRAM3004.K3 VRAM3004.K12 VRAM3004.L1 VRAM3004.L2 VRAM3004.L4 VRAM3004.L11 VRAM3004.L13 VRAM3004.L14 VRAM3004.M1 VRAM3004.M3 VRAM3004.M12 VRAM3004.M14 VRAM3004.N5 VRAM3004.N10 VRAM3004.P1 VRAM3004.P3 VRAM3004.P11 VRAM3004.P12 VRAM3004.P14 VRAM3004.R5 VRAM3004.R10 VRAM3004.T1 VRAM3004.T3 VRAM3004.T12 VRAM3004.T14 VRAM3005.B1 VRAM3005.B3 VRAM3005.B12 VRAM3005.B14 VRAM3005.C5 VRAM3005.C10 VRAM3005.D1 VRAM3005.D3 VRAM3005.D11 VRAM3005.D12 VRAM3005.D14 VRAM3005.E5 VRAM3005.E10 VRAM3005.F1 VRAM3005.F3 VRAM3005.F12 VRAM3005.F14 VRAM3005.G1 VRAM3005.G2 VRAM3005.G4 VRAM3005.G11 VRAM3005.G13 VRAM3005.G14 VRAM3005.H3 VRAM3005.H12 VRAM3005.K3 VRAM3005.K12 VRAM3005.L1 VRAM3005.L2 VRAM3005.L4 VRAM3005.L11 VRAM3005.L13 VRAM3005.L14 VRAM3005.M1 VRAM3005.M3 VRAM3005.M12 VRAM3005.M14 VRAM3005.N5 VRAM3005.N10 VRAM3005.P1 VRAM3005.P3 VRAM3005.P11 VRAM3005.P12 VRAM3005.P14 VRAM3005.R5 VRAM3005.R10 VRAM3005.T1 VRAM3005.T3 VRAM3005.T12 VRAM3005.T14 VRAM3006.B1 VRAM3006.B3 VRAM3006.B12 VRAM3006.B14 VRAM3006.C5 VRAM3006.C10 VRAM3006.D1 VRAM3006.D3 VRAM3006.D11 VRAM3006.D12 VRAM3006.D14 VRAM3006.E5 VRAM3006.E10 VRAM3006.F1 VRAM3006.F3 VRAM3006.F12 VRAM3006.F14 VRAM3006.G1 VRAM3006.G2 VRAM3006.G4 VRAM3006.G11 VRAM3006.G13 VRAM3006.G14 VRAM3006.H3 VRAM3006.H12 VRAM3006.K3 VRAM3006.K12 VRAM3006.L1 VRAM3006.L2 VRAM3006.L4 VRAM3006.L11 VRAM3006.L13 VRAM3006.L14 VRAM3006.M1 VRAM3006.M3 VRAM3006.M12 VRAM3006.M14 VRAM3006.N5 VRAM3006.N10 VRAM3006.P1 VRAM3006.P3 VRAM3006.P11 VRAM3006.P12 VRAM3006.P14 VRAM3006.R5 VRAM3006.R10 VRAM3006.T1 VRAM3006.T3 VRAM3006.T12 VRAM3006.T14 VRAM3007.B1 VRAM3007.B3 VRAM3007.B12 VRAM3007.B14 VRAM3007.C5 VRAM3007.C10 VRAM3007.D1 VRAM3007.D3 VRAM3007.D11 VRAM3007.D12 VRAM3007.D14 VRAM3007.E5 VRAM3007.E10 VRAM3007.F1 VRAM3007.F3 VRAM3007.F12 VRAM3007.F14 VRAM3007.G1 VRAM3007.G2 VRAM3007.G4 VRAM3007.G11 VRAM3007.G13 VRAM3007.G14 VRAM3007.H3 VRAM3007.H12 VRAM3007.K3 VRAM3007.K12 VRAM3007.L1 VRAM3007.L2 VRAM3007.L4 VRAM3007.L11 VRAM3007.L13 VRAM3007.L14 VRAM3007.M1 VRAM3007.M3 VRAM3007.M12 VRAM3007.M14 VRAM3007.N5 VRAM3007.N10 VRAM3007.P1 VRAM3007.P3 VRAM3007.P11 VRAM3007.P12 VRAM3007.P14 VRAM3007.R5 VRAM3007.R10 VRAM3007.T1 VRAM3007.T3 VRAM3007.T12 VRAM3007.T14
+1V_S5: C173.2 C179.2 C182.2 C191.2 C192.2 C217.2 C225.2 C672.1 C680.1 C695.2 C698.2 C699.2 PC234.1 PC235.2 PC236.1 PC239.1 PC242.1 PC245.1 PC248.1 PC250.1 PC268.1 PL15.2 PQ23.3 PQ26.5 PR86.1 R153.2 R512.2 R11131.2 U35.A10 U35.A14 U35.AB17 U35.AB19 U35.AB20 U35.AF18 U35.AF19 U35.AF20 U35.AF21 U35.AK20 U35.K15 U35.K17 U35.K19 U35.L15 U35.L19 U35.L21 U35.N15 U35.N16 U35.N17 U35.N18 U35.N20 U35.P15 U35.P16 U35.P18 U35.T19 U35.T20 U35.V15 U35.V20 U35.V21 U35.Y18
+1V_S5_ON: PR83.2 U45.95
+1V_SUS: PC6230.2 PQ23.1 PR139.1 R112.1 R550.1
+1V_VCCST: C628.1 C677.2 C814.2 C815.2 C816.2 C817.2 C818.2 C819.2 PC6228.1 PR340.1 PR341.1 Q31.3 R85.2 R134.1 R138.1 R488.2 R513.2 R514.1 R515.1 R529.1 R550.2 R559.1 R761.2 R788.1 U33.5 U35.A18
+2.5V: PQ6065.1 PR6298.1 R11170.2 R11174.2
+2.5V_SUS: C1257.1 C1266.1 C1320.1 C1324.1 JDIM1.257 JDIM1.259 JDIM2.257 JDIM2.259 PC232.1 PC233.1 PC241.2 PL17.2 PQ6065.3 PR273.2
+3V: C41.1 C332.2 C353.1 C356.1 C360.1 C371.1 C373.1 C376.1 C386.1 C413.1 C1163.1 C1164.1 C1268.1 C1276.1 C1316.1 C1326.1 C4024.2 C4025.2 C4607.1 C4608.1 C4609.1 C4733.1 C4734.1 C4735.1 C4752.2 C4783.2 C4784.2 C4785.1 C4786.1 C4787.1 L4.1 L4208.1 PC114.1 PC174.1 PR53.2 PR73.2 PR107.2 PR137.1 PR196.1 PR197.1 PR259.2 PR293.2 PR295.2 PR296.2 PR314.2 PR318.2 PU10.8 PU10.9 Q1.2 Q2.2 Q2.5 Q20.2 Q23.5 Q25.2 Q32.2 Q32.5 Q41.2 R7.2 R9.2 R11.1 R12.2 R19.1 R58.2 R110.2 R115.2 R204.2 R207.1 R208.2 R209.2 R215.2 R216.2 R218.1 R220.2 R223.2 R227.2 R228.2 R234.2 R237.2 R245.2 R257.1 R277.1 R281.1 R318.1 R319.2 R322.2 R361.1 R365.2 R367.2 R374.2 R378.1 R426.2 R444.2 R448.1 R449.1 R485.1 R533.1 R561.1 R572.2 R573.2 R574.2 R575.2 R576.2 R609.1 R618.2 R619.1 R625.1 R629.1 R630.1 R631.2 R639.1 R722.1 R781.2 R789.2 R948.2 R961.1 R4201.2 R4205.2 R10872.1 R10880.1 R10889.1 R10923.1 R10924.1 R10940.1 R11133.2 R11134.2 R11187.1 R11263.1 R11274.2 R11275.2 R11284.1 R11285.2 R11286.2 R11297.2 U1.4 U1.6 U13.14 U13.26 U14.5 U15.12 U16.1 U16.2 U17.1 U18.1 U18.18 U18.22 U4001.5 U4002.5 U4512.1 U4512.2
+3V3_SATA_N1: C1162.1 C1165.1 C1166.1 C1167.1 C1168.1 C1169.1 CN23.2 CN23.4 CN23.70 CN23.72 CN23.74 R948.1 R951.2
+3V3_SATA_N1_N: CN23.12 CN23.14 CN23.16 CN23.18 R951.1
+3V3_SD_SW: C4617.1 C4618.2 CN4.4 R6308.1 U15.13
+3V3_TPM: C768.1 C774.1 C775.1 C776.1 R744.1 R745.2 U44.8 U44.14 U44.22
+3V3_TPM_VSB: C766.1 C767.1 R725.1 U44.1
+3V_EC: C482.1 R361.2 R779.2 U45.11
+3V_GFX: C4013.1 C4026.2 C4027.1 C4028.2 C4029.2 C4031.2 C4038.2 C4039.1 C4041.1 PQ19.1 PR164.1 Q4000.1 Q4300.2 Q4300.5 Q4301.5 R382.2 R740.2 R4000.1 R4001.1 R4003.2 R4004.2 R4008.2 R4200.2 R4204.2 R4210.1 R4300.2 R4301.2 R4302.2 R4303.2 R4304.2 R4316.1 R4317.1 R4318.2 R4319.2 R4320.2 R4321.2 R4322.2 R4323.2 R4324.1 R4341.2 R4342.2 R4344.1 U3002.AG12 U3002.AH12 U3002.J8 U3002.K8
+3V_LAN: Q24.3 R248.1
+3V_LDO_EC: D12.1 PR6295.2 PR6296.2 R368.2 R730.2 R731.2 R732.2 R741.2 R747.1 R753.2 R11119.2 R11126.2 R11287.2
+3V_MAIN: C4032.2 C4033.1 C4034.2 C4035.2 L4206.2 Q4000.3 Q4002.2 Q4302.2 Q4302.5 R4003.1 R4203.2 R4305.2 R4306.2 R4307.2 R4330.1 R4331.1 U3002.L8 U3002.M8
+3V_MAIN_EN: Q4001.2 R4001.2 R4320.1 U3002.L7
+3V_PCH_ME: C754.2 R591.1 R649.1 R698.2 R11126.1 R11127.1 U41.8
+3V_RTC: C381.1 D7.3 R249.2 R252.2 R299.1 R300.1 R719.1 R756.2
+3V_RTC_1: D7.1 R308.2
+3V_RTC_2: D7.2 R301.2 R304.1
+3V_S5: C164.2 C168.2 C763.1 C808.2 C811.2 C812.2 C813.2 L19.1 L4209.2 PC108.1 PC173.1 PR104.1 PR285.2 PR292.2 PU10.13 PU10.14 Q43.2 Q43.5 R152.2 R160.2 R165.2 R166.1 R167.1 R169.2 R177.2 R179.2 R182.2 R185.2 R186.2 R187.2 R188.2 R193.1 R195.1 R198.2 R205.2 R211.1 R212.1 R240.2 R247.2 R250.2 R275.2 R280.2 R283.2 R290.2 R291.1 R402.1 R439.2 R440.2 R540.2 R541.2 R542.2 R543.2 R570.1 R577.2 R578.1 R580.1 R582.1 R585.1 R586.1 R628.1 R651.1 R682.1 R697.2 R705.2 R708.2 R716.1 R725.2 R733.2 R734.2 R745.1 R779.1 R11118.2 R11127.2 R11193.1 R11194.1 R11197.1 R11198.1 R11203.1 R11205.1 R11206.1 R11208.1 R11251.2 R11278.2 U6.5 U8.5 U43.5 U47.5 U48.5 U49.5 U50.5
+3V_WLAN: Q22.3 Q38.3 R221.1
+3VPCU: C345.2 C555.1 C4782.2 PC106.1 PC137.1 PC246.1 PC249.1 PC6224.1 PC6225.2 PL6012.2 PQ19.3 PR9.2 PR14.2 PR16.2 PR101.1 PR179.2 PR312.1 PR1248.1 PR1250.1 PR6279.1 PR6284.1 PR6295.1 PU10.1 PU10.2 PU10.6 PU10.7 PU18.9 PU18.10 Q22.1 Q24.1 R52.2 R53.1 R210.2 R231.1 R260.1 R271.2 R278.2 R304.2 R388.1 R427.2 R428.2 R429.2 R434.2 R435.2 R436.2 R437.2 R438.2 R695.1 R757.2 R2870.1 R11289.2 RP1.2 RP1.10
+3VPCU_EC: C508.1 C514.1 C770.1 C771.1 C777.1 C780.1 L12.1 L22.2 R747.2 U45.26 U45.50 U45.92 U45.114 U45.121
+3VPCU_ECPLL: C772.1 L22.1 U45.127
+5V: C187.2 C321.2 C456.1 C515.2 C525.1 C713.2 C720.2 C4749.2 C4753.1 L16.1 PC91.1 PC105.1 PR153.1 PU11.8 PU11.9 Q18.1 Q21.3 Q26.3 Q28.3 Q34.1 Q34.2 Q34.5 Q34.6 R16.1 R148.1 R338.2 R339.2 R343.2 R672.2 U12.2 U13.17 U25.1 U25.3 U37.5 U40.5
+5V_HDD: C435.1 C436.1 C437.1 C438.1 C453.1 C457.1 CN14.14 CN14.15 CN14.16 R339.1
+5V_KB: C169.2 C170.2 Q18.3 R119.1
+5V_KB_R: CN6.2 CN6.4 R119.2
+5V_ODD: Q34.4 R657.2 R672.1 R673.1
+5V_PVDD: C500.1 C501.1 C509.1 C510.1 L13.2 U23.41 U23.46
+5V_S5: C424.1 C4714.1 PC85.1 PC97.1 PR55.2 PR56.2 PR61.2 PR62.2 PR143.1 PR204.1 PR264.2 PR274.1 PR6301.2 PU11.13 PU11.14 R11201.2 U20.5 U4511.5
+5V_S5_V2: C4766.2 C4769.2 C4772.1 PC189.1 PC208.1 PU20.13 PU20.14 U28.2 U28.3 U28.4 U28.5
+5VA: C523.2 C526.1 C532.1 C536.1 L16.2 R395.1 U23.26 U25.4
+5VODD: C721.1 C726.1 C730.1 C733.1 C737.1 C740.1 CN9.9 CN9.10 R657.1
+5VPCU: C483.1 PC83.1 PC90.1 PC185.1 PC6226.2 PC6227.1 PL6013.1 PR68.2 PR81.2 PR88.1 PR93.2 PR103.2 PR111.1 PR6281.2 PR6282.1 PR6290.2 PR6292.1 PR6300.1 PU11.1 PU11.2 PU11.6 PU11.7 PU20.1 PU20.2 PU6010.14 R356.1 R360.1 U22.1
+A3VPCU: C495.1 L12.2 U45.74
+VCCATS_1P8: C250.1 R180.1 U35.AA1
+VCCCORE: C144.2 C150.2 C181.2 C184.2 C189.2 C196.2 C200.2 C201.2 C203.2 C209.2 C212.2 C214.2 C215.2 C219.2 C222.2 C224.2 C226.2 C227.2 C228.2 C233.2 C235.2 C236.2 C237.2 C243.2 C245.2 C246.2 C251.2 C252.2 C255.2 C257.1 C258.1 C259.1 C262.2 C269.2 C272.2 C273.2 C282.2 C285.2 C289.2 C645.2 C647.1 C650.2 C651.1 C657.1 C659.2 C663.1 C664.1 C666.2 C667.1 C673.1 C674.1 C675.1 C676.1 C678.1 C679.1 PC59.1 PC161.1 PC162.1 PC164.1 PC168.1 PL4.2 PR31.2 R96.1 U35.A30 U35.A34 U35.A39 U35.A44 U35.AK33 U35.AK35 U35.AK37 U35.AK38 U35.AK40 U35.AL33 U35.AL37 U35.AL40 U35.AM32 U35.AM33 U35.AM35 U35.AM37 U35.AM38 U35.G30 U35.G32 U35.G33 U35.G35 U35.G37 U35.G38 U35.G40 U35.G42 U35.J30 U35.J33 U35.J37 U35.J40 U35.K33 U35.K35 U35.K37 U35.K38 U35.K40 U35.K42 U35.K43
+VCCDSW_1P0: C712.1 U35.AL1
+VCCEOPIO: C708.1 C709.1 PR6307.2 U35.AE62 U35.AG62
+VCCGT: C148.1 C151.1 C155.1 C158.1 C161.1 C171.2 C178.2 C185.1 C186.1 C188.2 C190.2 C193.2 C194.2 C195.2 C197.2 C198.2 C199.2 C202.2 C204.2 C205.2 C206.2 C218.1 C223.1 C232.1 C239.2 C240.2 C241.2 C248.2 C274.2 C275.2 C276.2 C277.2 C279.1 C280.1 C281.1 C290.1 C291.1 C302.2 C303.2 C307.2 C310.2 C316.1 C317.1 C324.1 C690.2 C691.2 C692.2 C693.2 C694.2 C696.2 C697.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 C4732.2 C4816.2 PC158.1 PC159.1 PC160.1 PC163.1 PC166.1 PC167.1 PC170.1 PC172.1 PL2.2 PL3.2 PR187.2 R155.1 U35.A48 U35.A53 U35.A58 U35.A62 U35.A66 U35.AA63 U35.AA64 U35.AA66 U35.AA67 U35.AA69 U35.AA70 U35.AA71 U35.AC64 U35.AC65 U35.AC66 U35.AC67 U35.AC68 U35.AC69 U35.AC70 U35.AC71 U35.AK42 U35.AK43 U35.AK45 U35.AK46 U35.AK48 U35.AK50 U35.AK52 U35.AK53 U35.AK55 U35.AK56 U35.AK58 U35.AK60 U35.AK70 U35.AL43 U35.AL46 U35.AL50 U35.AL53 U35.AL56 U35.AL60 U35.AM48 U35.AM50 U35.AM52 U35.AM53 U35.AM56 U35.AM58 U35.AU58 U35.AU63 U35.BB57 U35.BB66 U35.J43 U35.J45 U35.J46 U35.J48 U35.J50 U35.J52 U35.J53 U35.J55 U35.J56 U35.J58 U35.J60 U35.K48 U35.K50 U35.K52 U35.K53 U35.K55 U35.K56 U35.K58 U35.K60 U35.L62 U35.L63 U35.L64 U35.L65 U35.L66 U35.L67 U35.L68 U35.L69 U35.L70 U35.L71 U35.M62 U35.N63 U35.N64 U35.N66 U35.N67 U35.N69 U35.N70 U35.N71 U35.R63 U35.R64 U35.R65 U35.R66 U35.R67 U35.R68 U35.R69 U35.R70 U35.R71 U35.T62 U35.U65 U35.U68 U35.U71 U35.W63 U35.W64 U35.W65 U35.W66 U35.W67 U35.W68 U35.W69 U35.W70 U35.W71 U35.Y62
