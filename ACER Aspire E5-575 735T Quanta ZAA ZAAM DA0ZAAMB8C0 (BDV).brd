# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VSTBY_FSPI: length 7
  BOTTOM w0.127: U45.106 176.78,44.28 176.33,44.72 R11119.1 176.82,45.71 176.82,46.34 177.73,47.25 R11118.1 177.15,47.84 177.15,48.85 v1(177.25,48.96)
VSYNC: length 29.6
  TOP w0.114: R11270.1 20.48,70.85 v1(20.48,70.02) 20.48,69.9 21.03,69.35 U13.18 ; U37.2 v1(10.47,89.55)
  BOTTOM w0.114: v1(10.47,89.55) 11.36,88.67 v1(12.5,88.67) 14.82,88.67 15.73,87.75 15.73,79.12 18.93,75.92 18.93,72.71 20.25,71.39 20.25,70.25 v1(20.48,70.02)
WIFI_SUSCLK: length 5.8
  BOTTOM w0.127: U43.4 200.35,183.27 200.11,183.03 200.11,182.74 R714.1 200.11,181.54 v1(200.11,181.12) 200.11,180.26 199.6,179.75 CN10.50
WLAN_CLKREQ#: length 17.4
  TOP w0.127: R253.2 R245.1 178.1,180.64 v1(177.59,181.16)
  BOTTOM w0.127: v1(177.59,181.16) 177.82,181.16 178.22,180.76 Q23.4 178.22,179.49 178.36,179.34 183.06,179.34 183.4,179.01 190,179.01 190.01,179 CN10.53
WLAN_RST#: length 4.8
  BOTTOM w0.127: C821.2 R680.2 200.71,180.48 200.83,180.6 R671.2 ; C821.2 199.99,179.22 199.95,179.25 CN10.52 ; C821.2 200.71,178.51 v1(200.72,178.51)
WLAN_WAKE_R#: length 15.6
  TOP w0.127: v1(179.52,177.15) 179.88,177.51 R242.1 179.88,178.31 R243.2
  BOTTOM w0.127: CN10.55 183.19,178.5 182.85,178.84 179.69,178.84 179.52,178.67 Q23.1 v1(179.52,177.15)
WLANPWR#: length 227
  TOP w0.127: v1(210.24,52.85) 210.24,59.02 216.12,64.9 216.12,78.42 v1(218.99,81.28) v1(220.15,82.44) ; R230.1 R231.2 R710.1 205.91,189.5 R712.2 205.04,189.77 204.76,190.06 v1(204.76,190.16)
  IN1 w0.089: v1(220.15,82.44) 217.98,84.61 217.98,95.21 221.79,99.02 221.79,99.02 225.56,102.78 227.91,102.78 229.63,104.5 229.63,112.85 229.27,113.21 229.27,116.33 229.55,116.61 229.55,119.75 228.87,120.43 228.87,132.53 227.33,134.06 227.33,152.07 224.56,154.83 223.83,154.83 220.26,158.4 208.46,158.4 207.07,159.79 207.07,169.67 205.11,171.63 205.11,172 204.45,172.66 204.45,179.73 204.72,180 204.72,183.57 203.21,185.08 203.21,188.23 204.76,189.78 v1(204.76,190.16) ; v1(184.94,26.05) 186.47,27.58 191.19,27.58 192.33,28.72 192.33,35.35 189.79,37.89 189.79,40.63 191.13,41.97 191.13,43.12 189.79,44.45 189.79,48.46 190.41,49.07 190.41,49.07 190.71,49.36 191.28,49.36 195.33,53.41 209.68,53.41 v1(210.24,52.85)
  BOTTOM w0.127: v1(184.94,26.05) 184.78,26.22 U45.35
WRST#: length 70
  IN1 w0.089: v1(211.89,49.8) 211.89,50.06 208.77,53.18 195.38,53.18 191.37,49.17 190.79,49.17 190.05,48.43 190.05,44.47 191.57,42.95 v1(191.57,41.93)
  BOTTOM w0.127: Q56.6 217.73,70.75 217.61,70.63 217.61,68.78 218.1,68.28 218.1,66.17 v1(217.35,65.42) 212.63,60.7 212.63,50.54 v1(211.89,49.8) ; v1(191.57,41.93) 191.57,41.42 193.35,39.64 193.35,38.07 192.72,37.43 D12.2 192.72,35.83 192.47,35.59 R368.1 190.95,35.96 189.67,35.96 189.16,35.45 C491.1 189.03,35.45 188.29,36.2 U45.14
XCLK_BIASREF: length 7.4
  TOP w0.127: R512.1 v1(120.07,125.75)
  BOTTOM w0.076: 118.04,123.84 117.89,123.69 117.89,122.93 117.79,122.83 117.79,122.19 117.66,122.07 117.33,122.07 117.12,121.86 U35.E42
  BOTTOM w0.127: 118.04,123.84 118.67,124.48 119.56,124.48 120.07,124.99 v1(120.07,125.75)
XDP_BPM#0: length 6.3
  BOTTOM w0.076: 108.63,126.26 108.63,125.97 109.21,125.38 109.21,124.06 109.36,123.92 109.36,122.85 U35.C55
  BOTTOM w0.127: 108.63,126.26 108.63,128.61 TP89.1
XDP_BPM#1: length 5.8
  BOTTOM w0.076: 109.3,126.26 109.3,126.19 109.24,126.13 109.24,125.59 109.38,125.45 109.38,124.13 109.53,123.98 109.53,123.11 109.76,122.88 109.76,122.6 109.47,122.31 U35.D55
  BOTTOM w0.127: 109.3,126.26 TP90.1
XDP_BPM#2: length 4.3
  TOP w0.127: TP64.1 109.3,126.13 v1(109.66,125.78)
  BOTTOM w0.076: v1(109.66,125.78) 109.54,125.66 109.54,124.2 109.69,124.05 109.69,123.45 110.03,123.11 U35.B54
XDP_BPM#3: length 3.9
  TOP w0.127: TP62.1 v1(108.18,125.11)
  BOTTOM w0.076: U35.C56 108.91,122.59 108.5,123 108.5,123.5 108.47,123.57 108.47,124.23 108.55,124.32 108.55,124.75 v1(108.18,125.11)
XDP_PRDY#: length 8.9
  BOTTOM w0.076: U35.D56 108.91,121.95 109.28,122.32 109.28,122.52 109.18,122.62 109.18,122.86 109.19,122.88 109.19,123.85 109.05,123.99 109.05,125.29 108.2,126.14 108.2,126.26
  BOTTOM w0.127: 108.2,126.26 108.2,129.14 108.36,129.31 TP91.1
XDP_PREQ#: length 1.7
  TOP w0.127: TP92.1 106.94,121.99 v1(106.94,121.56)
  BOTTOM w0.127: U35.D61 106.74,121.76 v1(106.94,121.56)
XDP_TCK0: length 15.9
  IN1 w0.089: v1(106.84,125.7) 106.84,126.28 106.18,126.94 106.18,127.83 105.47,128.54 104.83,128.54 v1(103.94,129.43)
  BOTTOM w0.076: v1(106.84,125.7) 107.41,125.13 107.41,123.86 U35.A59 ; 105.42,126.26 105.47,126.21 105.47,126 106.74,124.73 106.74,123.37 U35.B61
  BOTTOM w0.127: R513.1 v1(103.94,129.43) R558.2 104.39,128.36 104.39,127.29 105.42,126.26
XDP_TCK1: length 6
  BOTTOM w0.076: 107.61,126.26 107.61,126.23 108.72,125.13 108.72,124.25 108.63,124.17 108.63,123.62 108.66,123.55 108.66,123.31 U35.B56
  BOTTOM w0.127: R537.2 106.69,128.03 107.05,127.67 107.05,127.08 107.61,126.52 107.61,126.26
XDP_TDI: length 10.3
  BOTTOM w0.076: 107.35,126.26 107.35,126.13 107.77,125.71 107.77,124.24 108,124 108,123.64 107.94,123.47 107.94,123.33 108.01,123.1 108.01,122.97 107.93,122.79 107.93,122.36 107.55,121.98 U35.D59
  BOTTOM w0.127: R515.2 105.58,130.06 105.28,129.75 105.28,129.12 105.58,128.81 R796.1 105.97,128.81 106.17,128.61 106.17,127.21 106.64,126.74 106.94,126.74 107.35,126.33 107.35,126.26
XDP_TDI_CPU: length 7
  IN1 w0.089: v1(106.06,124.86) 105.72,125.2 v1(105.72,127.4)
  BOTTOM w0.076: U35.D60 106.33,122.09 106.13,122.29 106.13,122.35 106.14,122.35 106.14,123.55 105.83,123.86 105.83,124.63 v1(106.06,124.86)
  BOTTOM w0.127: R796.2 v1(105.72,127.4)
XDP_TDO: length 7.4
  BOTTOM w0.076: 107.94,126.26 107.94,126.16 108.88,125.22 108.88,123.74 U35.A56
  BOTTOM w0.127: 107.94,126.26 107.94,128.52 107.65,128.81 R795.1 107.5,129.17 R559.2
XDP_TDO_CPU: length 4.9
  IN1 w0.089: v1(106.23,124.23) 107.27,125.27 107.27,127.17 v1(107.5,127.4)
  BOTTOM w0.076: v1(106.23,124.23) 106.43,124.03 U35.A61
  BOTTOM w0.127: R795.2 v1(107.5,127.4)
XDP_TMS: length 10.2
  BOTTOM w0.076: 106.95,126.26 107.59,125.62 107.59,124.16 107.84,123.91 107.84,123.67 107.78,123.5 107.78,123.31 107.84,123.08 107.84,123 107.76,122.83 107.76,122.62 U35.C59
  BOTTOM w0.127: 106.95,126.26 106.78,126.44 106.05,126.44 105.28,127.21 105.28,128.61 105.08,128.81 R797.1 104.64,128.81 104.39,129.06 104.39,129.8 104.64,130.06 R514.2
XDP_TMS_CPU: length 6.2
  BOTTOM w0.076: U35.C60 106.99,124.73 105.76,125.96 105.76,126.26
  BOTTOM w0.127: R797.2 105.01,127.85 105.01,127.06 105.76,126.31 105.76,126.26
XTAL24_IN: length 17.2
  IN1 w0.089: v1(112.71,127.16) 112.87,127 112.87,126.44 113.89,125.43 113.89,124.28 114.8,123.37 118.96,123.37 119.6,122.74 119.6,121.58 v1(119.43,121.42)
  BOTTOM w0.127: Y4.3 113.14,131.04 113.14,129.22 C665.2 112.7,128.78 R536.1 112.7,127.17 v1(112.71,127.16) ; U35.E37 119.44,121.42 v1(119.43,121.42)
XTAL24_OUT: length 15.4
  IN1 w0.089: v1(113.48,127.16) 113.34,127.02 113.34,126.64 114.36,125.62 114.36,124.48 114.99,123.84 119.16,123.84 120.07,122.93 120.07,121.48 v3(120.26,121.29)
  BOTTOM w0.127: v3(120.26,121.29) 120.48,121.29 U35.E35 ; v1(113.48,127.16) R536.2 113.48,128.56 C658.2 113.71,129.76 Y4.1
XTAL27_IN: length 9.4
  TOP w0.127: Y4200.1 193.49,113.33 v1(193.49,113.81) 193.49,114.37 C4207.2 193.21,115.11 v1(193.21,115.34)
  BOTTOM w0.127: v1(193.21,115.34) 193.11,115.44 193.11,116.09 191.27,117.93 191.27,118.72 190.56,119.43 190.56,119.91 U3002.H3
XTAL27_OUT: length 10.2
  TOP w0.127: v1(192.45,115.34) 192.47,115.31 C4206.2 192.97,114.1 192.97,112.16 Y4200.3
  BOTTOM w0.127: v1(192.45,115.34) 192.6,115.49 192.6,115.88 190.76,117.72 190.76,118.66 190.13,119.3 U3002.H2
XTAL_OUTBUFF: length 8.7
  TOP w0.127: v1(188.92,120.74) 189.29,120.37 189.29,118.76 188.84,118.32 v1(188.84,116.32) 188.84,115.01 R4211.2 R4210.2
  BOTTOM w0.127: U3002.J4 188.93,120.74 v1(188.92,120.74)
XTAL_SSIN: length 5
  BOTTOM w0.127: 190.08,117.37 191.19,116.25 191.19,115.34 R4212.2 191.78,114.75 v1(192.11,114.75)
  BOTTOM w0.14: 190.08,117.37 190.08,118.69 U3002.H1
N59985: length 11.8
  TOP w0.102: 138.74,117.11 138.58,116.95 136.44,116.95 v3(135.86,116.37)
  TOP w0.127: 138.74,117.11 138.79,117.16 138.79,118.05 139.38,118.64 139.38,119.02 139.76,119.4 141.53,119.4 141.84,119.7 143.77,119.7 v1(143.99,119.92) 144.47,120.41 R571.2
  BOTTOM w0.127: U35.N9 135.86,116.52 v3(135.86,116.37)
N62917: length 1.7
  TOP w0.381: v3(102.75,119.41) 102.61,119.27 R158.2
  BOTTOM w0.254: U35.H66 103.05,119.1 v3(102.75,119.41)
N62945: length 0.6
  BOTTOM w0.254: U35.H65 103.85,119.42 v3(103.66,119.42)
  vias: v1(104.12,118.99)
N62977: length 3.5
  TOP w0.127: v3(132.21,104.54) 132.21,104.49 131.68,103.96 131.68,103.12 v1(131.41,102.85) 131.13,102.57 R635.2
  BOTTOM w0.076: U35.AT16 131.9,104.85 v3(132.21,104.54)
N62981: length 1.3
  TOP w0.127: R646.2 132.14,103.8 v3(132.21,103.88)
  BOTTOM w0.127: U35.AU16 v3(132.21,103.88)
N74227: length 4.3
  TOP w0.102: 138.81,112.87 138.69,112.75 137.52,112.75 v3(137.13,113.14)
  TOP w0.127: R174.2 139.88,113.05 139.76,113.18 139.12,113.18 138.81,112.87
  BOTTOM w0.127: v3(137.13,113.14) 137.13,112.84 U35.AB7
N108264: length 12.5
  BOTTOM w0.076: 137.9,100.73 137.23,101.4 136.95,101.4 136.8,101.55 136.8,102.19 136.62,102.37 136.37,102.37 135.92,102.82 U35.AW9
  BOTTOM w0.127: R623.2 145.7,101.37 145.39,101.06 143.71,101.06 142.84,100.2 139.27,100.2 138.74,100.73 137.9,100.73
N108478: length 16.9
  BOTTOM w0.076: 136.73,99.33 135.63,100.44 135.48,100.59 134.72,100.59 134.42,100.88 134.42,101.47 U35.BA11
  BOTTOM w0.127: C806.1 148.27,99.2 148.27,98.57 v1(148.09,98.39) 148.06,98.37 145.06,98.37 144.71,98.01 144.13,98.01 143.15,98.99 138.58,98.99 138.23,99.33 136.73,99.33
N109188: length 17.6
  BOTTOM w0.076: 137.47,100.6 137.31,100.77 136.95,100.77 136.84,100.88 136.84,101.26 135.92,102.18 U35.AY9
  BOTTOM w0.127: 137.47,100.6 137.67,100.4 138.69,100.4 139.12,99.97 142.92,99.97 143.68,100.73 147.88,100.73 148.26,101.1 R627.2 148.89,100.73 149.78,100.73 R626.2 150.29,99.55 v1(150.32,99.51)
N109300: length 8.8
  BOTTOM w0.076: 135.57,97.94 135.57,98.13 133.4,100.3 133.4,100.7 133.23,100.87 133.23,101.19 133.28,101.31 133.28,101.45 133.22,101.68 133.22,101.81 133.29,102.03 133.29,102.19 U35.AY13
  BOTTOM w0.127: R659.1 136.19,95.28 v1(135.74,95.73) 135.57,95.9 135.57,97.94
N109332: length 5.6
  BOTTOM w0.076: U35.BA13 133.76,101.47 133.76,100.46 136.03,98.19 136.45,98.19 136.58,98.06 136.58,97.94
  BOTTOM w0.127: R640.1 136.58,97.94
N109356: length 6.5
  BOTTOM w0.076: U35.BB13 133.49,100.87 133.57,100.8 133.57,100.43 135.82,98.17 135.82,97.94
  BOTTOM w0.127: R653.1 136.45,96.14 135.82,96.77 135.82,97.94
N109380: length 7.2
  BOTTOM w0.076: U35.AY12 134.06,102.52 133.76,102.22 133.76,101.79 133.93,101.63 133.93,100.56 136.04,98.44 136.84,98.44 137.35,97.94
  BOTTOM w0.127: R668.1 137.35,97.94
N112417: length 14.4
  BOTTOM w0.076: 143.69,104.21 143,104.91 141.41,104.91 141.36,104.96 U35.AT1
  BOTTOM w0.127: R616.2 151.58,102.89 151.82,102.89 152.15,103.22 152.15,103.83 v1(151.88,104.1) 151.63,104.35 146.6,104.35 146.35,104.1 143.81,104.1 143.69,104.21
N112429: length 7.3
  BOTTOM w0.127: U35.B7 137.6,123.37 137.6,124.53 138.18,125.11 139.93,125.11 141.15,126.33 TP63.1
N112433: length 6.4
  TOP w0.127: R145.2 135.94,120.15 v1(135.72,119.93) 135.44,119.65 135.44,118.51 135.18,118.26 134.8,118.26 134.47,118.59 134.47,120.24 v3(134.04,120.68)
  BOTTOM w0.127: v3(134.04,120.68) U35.E13
N119188: length 1.4
  TOP w0.127: v3(135.82,121.3) 136.08,121.57 R153.1
  BOTTOM w0.152: U35.E8 136.01,121.3 v3(135.82,121.3)
N136283: length 8.6
  TOP w0.127: CN2.2 165.6,93.18 166.05,92.73 166.05,91.71 v1(165.41,91.08)
  BOTTOM w0.127: R282.1 166.81,91.34 v1(166.55,91.09) 165.42,91.09 v1(165.41,91.08)
N136287: length 6.4
  TOP w0.127: v1(168.33,92.09) 166.6,93.83 CN2.4
  BOTTOM w0.127: R279.1 168.59,91.84 v1(168.33,92.09)
N136291: length 7.3
  TOP w0.127: CN2.6 167.6,94.35 v1(168.33,93.62)
  BOTTOM w0.127: R273.1 170.62,92.04 v1(169.04,93.62) v1(168.33,93.62)
N136295: length 8.1
  TOP w0.127: v1(171.51,91.97) 170.62,91.97 169.1,93.49 CN2.9
  BOTTOM w0.127: v1(170.85,92.55) 170.92,92.55 v1(171.51,91.97) 171.63,91.84 R268.1
N136299: length 7.4
  TOP w0.127: CN2.11 170.1,93.12 170.62,92.6 v1(171.51,92.6)
  BOTTOM w0.127: R265.1 172.65,91.79 v1(172.13,92.31) 171.84,92.6 v1(171.51,92.6)
N136321: length 7.7
  TOP w0.127: v1(173.41,91.99) 172.83,91.99 171.76,93.06 171.18,93.06 170.74,93.49 170.74,95.55 171.1,95.9 CN2.13
  BOTTOM w0.127: R267.1 173.67,91.56 173.41,91.82 v1(173.41,91.99)
N136329: length 7
  TOP w0.127: CN2.5 167.1,94.09 v1(168.33,92.86)
  BOTTOM w0.127: R274.1 v1(169.6,92.2) 168.94,92.86 v1(168.33,92.86)
N259399: length 21.3
  TOP w0.508: MR1.1 88.45,4.59 87.69,5.35
  TOP w1.016: D28.2 73.34,13.14 73.34,10.56 74.02,9.87 78.98,9.87 v1(82.99,5.86) 87.18,5.86 87.69,5.35
N321886: length 3
  BOTTOM w0.254: R395.2 R390.2 207.45,33.55 v1(207.9,33.1) 208.02,32.97 U25.5
N366230: length 4.1
  BOTTOM w0.508: Q36.3 223.58,105.94 v1(222.14,104.5) 221.93,104.3 R673.2
N16779565: length 5.2
  BOTTOM w0.127: Q18.2 227.01,122.2 R148.2 v1(226.13,121.3) 225,120.18 Q19.3
N16779579: length 3.7
  BOTTOM w0.508: Q42.2 131.25,13.99 130.49,14.74 R754.2 C786.1
N16781100: length 3.3
  BOTTOM w0.127: v1(123.12,22.63) 122.75,22.25 R402.2
  BOTTOM w0.508: R402.2 121.72,22.25 121.6,22.38 R416.1 R415.1
N16946782: length 2.5
  BOTTOM w0.127: Q5.2 90.81,130.32 v1(90.49,130.64) R74.2
N16946786: length 5.5
  BOTTOM w0.127: R74.1 89.71,130.95 89.21,130.45 87.69,130.45 87.31,130.07 87.31,129.43 86.54,129.43 v1(86.34,129.23)
N16998366: length 12.4
  IN1 w0.089: v1(196.53,49.41) 197.15,49.41 197.8,50.06 199.57,50.06 199.98,49.65 201.07,49.65 201.35,49.93 201.35,50.31 201.76,50.72 203.1,50.72 v1(203.51,50.31)
  BOTTOM w0.127: R343.1 194.85,47.52 v1(195.19,47.86) 195.66,48.33 Q27.2 196.14,49.19 196.36,49.41 v1(196.53,49.41) ; R344.2 v1(203.51,50.31)
N16998426: length 5.5
  BOTTOM w0.127: v1(195,52.14) Q27.3 195.59,51.18 196.54,50.22 R345.2 197.45,50.22 198.18,50.95 Q28.2
N17002655: length 2.7
  BOTTOM w0.127: U23.39 200.89,40.78 200.44,40.33 v1(200.36,40.33) 200.16,40.33 199.9,40.08 199.49,40.08 C529.2
N17002661:
  vias: v1(200.39,39.01)
N17002676: length 2.3
  BOTTOM w0.203: U23.34 203.38,38.53 203.3,38.45 203.3,37.84 v1(203.3,37.83) 202.88,37.41 C530.1
N17002678: length 3.4
  BOTTOM w0.102: C519.1 210.47,42.07 v1(210.47,42.77)
  BOTTOM w0.203: C519.1 210.41,41.98 U23.19
N17002722: length 2.1
  BOTTOM w0.203: TP34.1 200.34,45.38 201.34,44.38 U23.48
N17002952: length 4.6
  BOTTOM w0.127: U23.7 204.98,46.7 205.29,47.01 205.29,48.41 205.42,48.53 C481.1 206.03,48.91 v1(206.13,48.81)
N17003087: length 4.2
  BOTTOM w0.127: D9.1 D10.1 213.04,47.04 213,47 R352.2 211.77,46.48 v1(211.94,46.3)
N17003129: length 3.5
  TOP w0.203: v1(202.75,38.17) 201.66,38.17 v1(201.65,38.17) v1(201.1,37.61)
  BOTTOM w0.203: v1(202.75,38.17) 202.98,38.4 U23.35 ; C528.1 v1(201.1,37.61)
N17003186: length 3.6
  BOTTOM w0.203: 209.48,41.42 209.32,41.58 U23.20
  BOTTOM w0.508: R388.2 210.37,40.53 v1(210.06,40.84) 209.48,41.42
N17004316: length 2.1
  BOTTOM w0.381: D15.1 192.12,48.75 Q29.3
  vias: v1(192.56,49.17)
N17028021: length 3.2
  TOP w0.127: v1(204.22,190.52) 204.26,190.56 R230.2 C344.2
  BOTTOM w0.127: v1(204.22,190.52) 204.65,190.95 Q22.2
N17046941: length 2.6
  TOP w0.127: v1(150.48,172.03) 149.97,171.52 PR6.1
  BOTTOM w0.127: PJ1.3 150.55,172.28 150.48,172.21 v1(150.48,172.03)
N17047009: length 3.4
  TOP w0.191: PU5.20 157.52,179.06
  TOP w0.203: PR183.2 157.52,177.47 157.52,177.76 v1(158.1,178.33) 157.52,178.9 157.52,179.06
N17047028: length 3.2
  TOP w0.191: PU5.19 157.12,179.06
  TOP w0.203: PR184.2 157.12,177.52 157.12,177.67 v1(156.83,177.97) 156.83,178.15 157.12,178.45 157.12,179.06
N17047083: length 2.9
  TOP w0.381: PR8.1 155.63,171.31 v1(154.84,172.1)
  BOTTOM w0.381: v1(154.84,172.1) 154.55,172.4 PJ1.5
N17047087: length 12.5
  TOP w0.381: PC1.1 157.55,168.42 v2(158.39,168.42) ; PR186.1 154.98,175.59 v1(154.31,174.92)
  BOTTOM w0.178: PR176.2 166.64,177.41 168.31,177.41 168.69,177.03 168.69,175.23 168.84,175.08 PR169.1
  BOTTOM w0.305: v1(154.31,174.92) 154.72,174.92 155.23,174.42 155.23,172.49 156.7,171.01
  vias: v1(161.7,171.17) v2(158.43,169.95) v2(158.43,169.18) v2(158.43,167.66) v2(159.82,170.07) v2(159.85,168.32) v2(159.87,169.18) v2(159.87,167.38) v2(170.67,176.3) v2(171.07,177.74) v2(171.13,176.93) v2(172.14,177.97) v2(173.16,177.97) v2(174.15,177.97) v2(175.11,177.97) v2(176.03,177.97)
N17047112: length 64.8
  TOP w0.203: v1(157.84,187.98) 157.84,187.88 157.33,187.37 PR165.1
  IN3 w0.254: v1(157.84,187.98) 157.92,188.06 164.75,188.06 167.7,185.11 175.27,185.11 176.71,183.66 176.71,183.23 178.11,181.83 178.11,180.99 178.75,180.36 182.94,180.36 183.44,180.87 190.81,180.87 197.8,187.85 200.72,187.85 202.49,189.63 207.8,189.63 v1(209.17,191)
  BOTTOM w0.381: PQ22.4 212.36,191.36 212.27,191.27 PC136.2 210.88,191.27 210.77,191.37 PC133.2 209.78,191.37 209.4,191 v1(209.17,191)
N17047335:
  vias: v1(168.33,182.24)
N17047399:
  vias: v1(163.3,182.26)
N17047425: length 2.5
  TOP w0.127: PR7.1 152.79,171.72 v1(152.48,172.03)
  BOTTOM w0.127: v1(152.48,172.03) 152.55,172.1 PJ1.4
N17047601: length 4.6
  TOP w0.381: PC1.2 157.36,167.1 157.15,166.89 PR185.1 157.69,166.29 v1(158.17,166.77)
  BOTTOM w0.127: PQ1.4 157.23,166.01 v1(157.03,165.81)
  BOTTOM w0.381: PQ1.4 157.92,166.87 158.02,166.77 v1(158.17,166.77)
N17067472: length 6.4
  TOP w0.508: PR155.1 48.69,114.32 48.62,114.4 PR154.2 48.62,116.15 v1(48.91,116.43) 49.08,116.61 PC104.2 50.18,115.93 50.15,115.89 PU4.8
N17067476: length 7.5
  TOP w0.127: v1(46.64,112.21) 46.6,112.26 PQ12.1
  TOP w0.254: PQ12.1 45.65,111.31 PR152.1 44.07,109.72 42.7,109.72 42.07,109.09 PD4.1
N17067510: length 3.2
  TOP w0.254: PR154.1 46.79,115.36 v1(46.1,114.67) 45.72,114.29 PQ12.3
N17067514: length 4.7
  TOP w0.254: PQ12.2 43.62,111.55 43.91,111.26 PR152.2 v1(42.95,110.76) 42.37,110.76 41.81,111.32 PQ13.3
N17067548: length 8.6
  TOP w0.508: PR155.2 v1(47.17,110.78) PQ14.2 47.68,109.24 48.05,109.6 PC102.2 48.67,110.23 48.95,110.51 49.71,110.51 50.15,110.08 PU4.1
N17067560: length 8.8
  TOP w0.127: PQ9.3 v1(41.84,117.11)
  BOTTOM w0.127: PR262.1 35.73,114.82 v1(35.83,114.91) 36.89,115.97 40.7,115.97 v1(41.84,117.11)
N17067629: length 3.5
  TOP w0.127: v1(37.5,44.32) 37.8,44.02 PR137.2
  TOP w0.381: PQ4.3 39.12,42.66 38.63,43.16 PR137.2
N17067635: length 1.7
  TOP w0.127: PR153.2 PQ10.3
  vias: v1(37.85,33.85)
N17192633: length 3
  BOTTOM w0.305: U19.7 v1(223.77,57.04) R337.2
N17310717: length 13
  TOP w0.127: LED2.2 63.5,14.05 v1(62.38,15.17) 62.04,15.5 D24.1 R430.2
N17310725: length 13.8
  TOP w0.127: R433.2 D27.1 v1(55.31,15.4) 55.31,12.84 55.89,12.26 55.89,6.17 57,5.05 LED1.1
N17310735: length 14.2
  TOP w0.127: R431.2 D25.1 v1(65.47,15.78) 65.47,11.08 63.81,9.42 63.81,6.37 65,5.18 LED2.1
N17310861: length 13.4
  TOP w0.127: R432.2 D26.1 v1(53.41,15.17) 53.41,13.47 55.58,11.3 55.58,5.88 55.5,5.81 LED1.2
N17398787: length 3.1
  TOP w0.191: PU5.5 156.32,184.53 ; 156.32,184.79 v1(156.7,185.16)
  TOP w0.203: PR167.2 156.39,186.02 156.7,185.72 v1(156.7,185.16) ; 156.32,184.53 156.32,184.79
N17410561: length 11.8
  TOP w0.508: v1(53.3,91.18) 51.9,89.78 51.9,83.99 53.52,82.37 PR344.1
  TOP w0.762: PC223.1 53.18,91.29 v1(53.3,91.18)
  vias: v1(70.54,101.34) v2(55.17,95.78) v2(55.17,95.02) v2(55.94,95.78) v2(55.94,95.02) v2(56.7,95.78) v2(56.7,95.02) v2(57.46,95.78) v2(57.46,95.02) v2(66.35,97.81) v2(66.35,97.05) v2(67.11,97.81) v2(67.11,97.05) v2(68.64,99.33) v2(69.02,99.97) v2(69.4,99.33) v2(69.78,99.97)
N17410571: length 3.4
  TOP w0.127: v1(49.28,85.08) 49.03,85.34 v1(48.62,85.34)
  TOP w0.305: v1(49.28,85.08) 48.83,84.64 PR280.2 R697.1
  BOTTOM w0.305: PR288.1 49.69,84.68 v1(49.28,85.08)
N17410893: length 2.3
  BOTTOM w0.254: PU14.13 55.62,81.87 56.32,81.17 v1(56.42,81.17) PR290.2
N17424918: length 3.5
  TOP w0.191: PU5.11 154.01,181.71
  TOP w0.203: PR177.2 151.92,183.28 v1(152.61,182.6) 153.5,181.71 154.01,181.71
N17424920: length 3.3
  TOP w0.191: PU5.12 153.98,181.31
  TOP w0.203: 153.98,181.31 152.83,181.31 v1(152.81,181.33) 151.87,182.26 151.87,182.31 PR178.2
N17424921: length 4.3
  TOP w0.191: PU5.7 155.52,184.02 155.38,184.17
  TOP w0.203: 155.38,184.17 154.49,184.17 153.85,184.8 153.85,185.19 v1(153.88,185.21) 154.11,185.44 154.11,186.05 154.41,186.35 PR170.2
N17424925: length 4.4
  TOP w0.191: PU5.9 154.17,182.51
  TOP w0.203: 154.17,182.51 153.09,183.59 153.09,184.35 v1(152.58,184.86) 152.25,185.19 PR172.2
N17424950: length 6.1
  TOP w0.191: PU5.15 155.52,179.36 155.25,179.09
  TOP w0.203: PR13.2 151.87,179.34 151.9,179.37 153.09,179.37 153.37,179.09 155.25,179.09
  TOP w0.381: PR13.2 151.82,178.74 v1(152,178.56) 152.02,178.58 152.28,178.58 152.44,178.74 PR12.2
N17435661: length 2.9
  TOP w0.508: PR138.2 v1(73.46,94.23) 73.39,94.23 73.23,94.08 PQ5.3
N17542339: length 4.4
  TOP w0.127: v1(206.94,187.6) 206.95,187.61 C756.2 207.3,188.68 v1(207.3,189.05) 206.95,189.39 R710.2
  BOTTOM w0.127: v1(206.94,187.6) 206.94,187.47 206.3,186.84 Q38.2
N17642578: length 13.8
  IN3 w0.127: v3(134.95,105.26) 134.49,104.79 134.49,103.61 134.74,103.36 135.78,103.36 139.84,99.29 141.07,99.29 v1(141.79,98.57)
  BOTTOM w0.127: v1(141.79,98.57) 143.11,97.25 TP4367.1 ; U35.AT11 134.55,104.85 v3(134.95,105.26)
N17661815: length 5.4
  TOP w0.191: PU5.8 154.28,182.91
  TOP w0.203: 154.28,182.91 154.01,183.18 154.01,183.84 v1(153.93,183.92) 153.45,184.4 153.45,184.88 152.96,185.36 152.61,185.36 151.54,186.43 PR171.2
N17738230: length 4.9
  TOP w0.127: R316.1 17.96,42.56 16.65,41.25 D31.1 v1(15.14,42.37)
N17738233: length 2.5
  TOP w0.127: R317.1 18.98,42.34 v1(18.83,42.19) 18.83,41.95 19.49,41.29 D30.1
N17792383: length 9.1
  TOP w0.127: R172.1 101.66,113.3 101.72,113.24 104.83,113.24 105.72,112.35 v3(106.52,112.35) ; R172.1 100.9,113.06 v1(100.41,112.57) ; R172.1 R634.2
  BOTTOM w0.114: v3(106.52,112.35) 106.34,112.35 106.08,112.08 U35.AC63
N17792405: length 18.8
  TOP w0.127: v3(106.52,111.73) 105.97,111.73 104.71,112.98 102.1,112.98 101.45,112.34 100.84,112.34 100.56,112.06 97.49,112.06 97.22,112.34 91.29,112.34 90.46,111.5
  BOTTOM w0.114: v3(106.52,111.73) 106.43,111.73 106.01,111.3 105.52,111.3 U35.AE63
  vias: v1(89.97,111.48)
N17792407: length 14.6
  TOP w0.127: R633.2 v1(101.67,114.31) 102.45,113.53 104.91,113.53 105.64,112.8 106.71,112.8 107.73,111.78 v1(108.01,111.78)
  IN3 w0.127: v3(105.81,107.82) 105.63,107.99 105.63,110.5 106.14,111 107.07,111 107.85,111.78 v1(108.01,111.78)
  BOTTOM w0.127: U35.AL63 v3(105.81,107.82)
N17792421: length 22.4
  TOP w0.127: v1(108.01,110.76) 107.5,111.27 106.05,111.27 105.24,112.08 100.95,112.08 100.67,111.81 97.39,111.81 97.11,112.08 91.8,112.08 91.37,111.65 v1(91.37,111.5) R632.2
  IN3 w0.127: v1(108.01,110.76) 108.01,109.49 107.12,108.6 v3(106.48,108.6)
  BOTTOM w0.127: v3(106.48,108.6) 106.13,108.6 U35.AJ62
N17817978: length 15.2
  TOP w0.305: R438.1 R440.1 v1(51.5,15.78) 51.5,13.35 55.23,9.62 55.23,6.42 54,5.2 LED1.3
N17818190: length 14.8
  TOP w0.305: R437.1 R439.1 v1(60.01,12.87) 60.01,12.2 63.1,9.11 63.1,6.8 62,5.7 LED2.3
N18005998: length 6.2
  BOTTOM w0.127: R326.2 v1(225.46,54.26) 228.16,54.26 229.34,55.44 CN14.18
N18020348: length 1.7
  TOP w0.127: TP17.1 127.44,106.57 126.79,107.22 v3(126.71,107.22)
  BOTTOM w0.076: U35.AM23 126.95,107.45 v3(126.71,107.22)
N18021386: length 3.2
  TOP w0.127: v3(127.6,108.84) 128.1,108.35 128.62,108.35 TP14.1
  BOTTOM w0.076: U35.AM22 127.98,107.56 127.98,107.8
  BOTTOM w0.114: 127.98,107.8 127.98,108.04 127.6,108.42 v3(127.6,108.84)
N18022283: length 1.8
  TOP w0.127: v1(121.91,118.22) 121.91,118.62 TP12.1
  BOTTOM w0.114: U35.K32 122.06,118.22 v1(121.91,118.22)
N18022286: length 3.1
  TOP w0.127: TP20.1 123.51,107.96 123.51,109.07 v3(123.64,109.2)
  BOTTOM w0.114: v3(123.64,109.2) 123.54,109.1 122.83,109.1 122.61,108.88 U35.AK32
N18137715: length 4.7
  TOP w0.127: TP29.1 135.44,103.91 134.95,104.39 v3(134.95,104.63)
  BOTTOM w0.127: v3(134.95,104.63) 134.92,104.63 U35.AU11
N18832214: length 33.4
  BOTTOM w0.127: SW4.2 SW4.1 218.15,90.43 217.66,89.94 215.34,89.94 R11282.2 218.12,89.3 219.03,88.39 v1(219.03,77.14) 219.03,75.94 217.1,74.01 Q40.3
N18834425: length 5.3
  TOP w0.127: v1(219.13,74.06) 219.89,73.3 C764.1 R717.2
  BOTTOM w0.127: Q56.3 219.4,73.79 v1(219.13,74.06) 218.75,73.68 Q56.2
N18834459: length 2.8
  TOP w0.127: R756.1 R757.1 R717.1 218.3,72.15 v1(218.17,72.28)
N18849499: length 7.5
  TOP w0.127: R6.2 121.44,177.57 v1(121.72,177.85)
  BOTTOM w0.127: R6.2 121.44,177.57 v1(121.72,177.85) 122.08,178.2 122.63,178.2 122.89,177.95 125.02,177.95 125.86,177.1 125.86,176.75 CN5.11
N18849555: length 7.6
  TOP w0.127: R5.2 121.12,178.43 121.57,178.43 v1(121.72,178.58)
  BOTTOM w0.127: CN5.10 125.12,178.2 122.99,178.2 122.74,178.45 121.85,178.45 v1(121.72,178.58) 121.57,178.43 121.12,178.43 R5.2
N18953365: length 5.9
  BOTTOM w0.076: 140.92,100.97 140.48,101.4 140.05,101.4 139.83,101.63 139.83,102.08 139.54,102.37 U35.AY3
  BOTTOM w0.127: 141.92,101.11 141.77,100.97 140.92,100.97
  BOTTOM w0.381: R759.1 143.56,102.25 142.42,101.11 141.92,101.11
N18953425: length 5.7
  BOTTOM w0.33: U35.AY71 99.7,102.2 99.37,101.87
  BOTTOM w0.381: R760.1 95.91,102.09 v1(96.36,101.63) 96.5,101.49 98.99,101.49 99.37,101.87
N18954271: length 9.8
  BOTTOM w0.076: 101.86,126.26 101.86,126.05 102.7,125.22 103.59,125.22 104.11,124.7 104.11,124.21 104.4,123.92 104.4,123.28 104.51,123.17 U35.C64
  BOTTOM w0.127: 101.86,126.26 101.86,129 101.99,129.13 v1(101.99,129.48) 101.99,129.51 101.73,129.76 101.32,129.76 R761.1
N18954886: length 22.9
  TOP w0.127: R762.1 98.46,113.68 v3(98.74,113.96)
  IN2 w0.114: v3(98.74,113.96) 98.74,114.32 100.26,115.84 101.78,115.84 102.57,116.63 106.2,116.63 107.57,115.26 107.57,110.56 108.9,109.24 108.9,105.64 v3(109.35,105.19)
  BOTTOM w0.203: U35.AR56 109.02,105.5 109.34,105.19 v3(109.35,105.19)
N18954889: length 1.4
  TOP w0.127: v1(109.37,106.43) 108.9,105.96 TP88.1
  BOTTOM w0.203: U35.AP56 109.09,106.15 v1(109.37,106.43)
N18994895: length 4.8
  BOTTOM w0.127: C793.2 144.57,119.53 143.19,119.53 141.87,118.21 U35.L1
N19011701: length 3.2
  BOTTOM w0.127: v1(59.65,81.88) 59.65,83.42 PC231.1
N19018012: length 10.8
  TOP w0.127: v3(135.15,115.35) 135.15,117.2 136.2,118.26 136.96,118.26 137.22,118.51 137.22,119.65 137.6,120.03 137.88,120.03 138.05,120.21 138.79,120.21 139.24,120.66 C794.2 R775.2
  BOTTOM w0.127: v3(135.15,115.35) 134.83,115.03 U35.U11 U35.U12
N19520551: length 4.3
  BOTTOM w0.127: R776.1 151.44,17.41 151.61,17.58 D34.1 152.2,17.13 152.42,16.91 v1(152.42,16.08) CN20.27
N19736816: length 5.5
  TOP w0.127: v1(133.09,107.12) 133.6,106.61 133.6,103.59 133.66,103.52 133.66,102.76 TP84.1
  BOTTOM w0.114: v1(133.09,107.12) 133,107.12 U35.AM15
N19940934:
  vias: v1(49.99,43.2)
N19940984: length 2.6
  TOP w0.127: PR6289.2 62.91,50.07 v1(62.95,50.11)
  TOP w0.762: PC6222.1 PR6289.2
N19941046: length 5.2
  TOP w0.203: PR6284.2 53.42,42.26 v1(53.13,41.97) 52.81,41.64 PU6010.7
  TOP w0.381: PR6297.1 PR6283.1 54.44,43.04 PR6284.2
N19941188: length 2.5
  BOTTOM w0.203: v1(63.25,25.45) 63.37,25.56 PC6221.1
  BOTTOM w0.889: PR6288.2 64.77,26.46 PC6221.1
N19941230:
  vias: v1(49.66,34.08)
N20339214: length 14.4
  TOP w0.127: R778.1 147,108.08 v1(146.28,107.36) 145.95,107.36 145.78,107.53 145.28,107.53 144.18,106.42 140.7,106.42 140.04,107.08 139.38,107.08 138.94,107.51 137.55,107.51 v3(137.12,107.94)
  BOTTOM w0.076: v3(137.12,107.94) 137.12,108.76 137.34,108.99 138.23,108.99 138.84,109.6 U35.AG4
N20915811: length 3.8
  TOP w0.127: v3(133.15,107.84) 132.85,108.15 131.32,108.15 TP95.1
  BOTTOM w0.076: v3(133.15,107.84) 133.53,108.22 U35.AK13
N20965717: length 1
  BOTTOM w0.127: v1(210.57,174.29) 210.84,174.56 PC304.2
N20974305: length 1.2
  BOTTOM w0.127: PR285.1 163.51,50.95 v1(163.45,51)
N20974309: length 2
  BOTTOM w0.254: v1(171.3,49.02) 171.02,48.74 PR273.1
  BOTTOM w0.508: PR278.1 170.39,48.36 170.58,48.16 PR273.1
N20974321:
  vias: v1(168.2,44.85)
N20974323: length 189.8
  TOP w0.127: PR304.1 48.1,62.67 v1(48.19,62.76)
  IN1 w0.089: v1(43.49,37.23) 43.49,35.07 44.38,34.18 44.38,33.33 45.12,32.59 45.12,29.09 54.99,19.22 57.99,19.22 58.78,18.43 67.3,18.43 77.34,28.48 77.34,28.85 81.69,33.2 83.83,33.2 84.28,32.75 147.53,32.75 148.27,33.48 156.7,33.48 160.97,37.75 160.97,42.03 163.21,44.27 164.8,44.27 164.98,44.44 168.31,44.44 v1(170.49,46.63)
  IN3 w0.114: v1(43.49,37.23) 43.49,47.01 40.19,50.31 40.19,52.72 40.75,53.28 40.75,59.38 43.62,62.25 47.68,62.25 v1(48.19,62.76)
  BOTTOM w0.127: v1(170.49,46.63) 171,46.63 171.25,46.37 PR307.2 170.75,46 v1(170.4,45.65) 170.24,45.49 PR271.2
N20974337:
  vias: v1(169.17,47.62)
N20974362: length 1.3
  BOTTOM w0.508: PU16.5 167.04,49.83 167.18,49.97 PR306.2
N21057139: length 5.1
  TOP w0.381: PU2.2 45.95,47.8 v1(46.28,47.47) 46.79,46.96 47.11,46.96 PR37.2 47.14,45.87 PR54.1 48.15,45.85 PC61.2
N21057151: length 1.1
  TOP w0.127: v1(35.03,47.67) 35.16,47.79 PC71.1
N21057157:
  vias: v1(46.21,49.27)
N21057159: length 4.9
  TOP w0.127: v1(36.79,45.56) 36.79,46.52 PR119.1
  TOP w0.381: PU2.7 38.38,47.8 37.98,48.2 PR121.2 37.47,47.7 37.42,47.64 PR119.1
N21057165: length 6.3
  TOP w0.381: PC70.2 46.94,52.46 46.94,52.46 46.4,51.92 46.4,51.44 PR68.1 46.36,51.36 46.36,50.79 v1(46.19,50.62) 45.91,50.34 PU2.4
  TOP w0.508: PC70.2 47.46,53.22 48.39,54.15 PC81.2
N21057401: length 5.9
  BOTTOM w0.381: PC75.2 162.76,63.04 PR69.2 162.24,62.89 161.84,62.49 PR75.1 161,63.11 v1(161,63.21) 160.82,63.39 160.09,63.39 159.82,63.66 159.82,64.65
N21057413:
  vias: v1(157.96,71.76)
N21057419: length 6.5
  BOTTOM w0.508: PR1250.2 159.8,59.38 v1(159.54,59.63) 159.25,59.93 PC78.2 PC76.1 159.25,62.95 158.55,63.65 PU6.3
N21057421: length 4.1
  BOTTOM w0.127: PR156.2 160.84,73.05 v1(160.84,73.78)
  BOTTOM w0.305: PR133.1 160.14,72.17 160.87,72.9 PR156.2
  BOTTOM w0.381: 159.82,70.11 159.82,71.71 PR133.1
N21057427: length 6.6
  BOTTOM w0.254: v1(158.25,59.94) 158.45,60.14 158.45,61.36 158.21,61.6 PR81.1
  BOTTOM w0.508: PU6.4 157.28,63.44 157.78,62.95 PC77.2 157.89,62.57 PR81.1 157.8,61.69 157.07,61.69 PC79.2
N21060883:
  vias: v1(184.11,103.19)
N21061023: length 291.6
  TOP w0.305: PQ17.2 185.76,103.17 v1(185.73,103.14)
  TOP w0.381: PR157.1 56.14,72.74 55.58,72.18 PQ15.3 54.64,72.18 54.13,72.69 PR159.2 53.34,71.96 v1(53.21,71.84) ; v1(180.35,63.98) 178.96,63.98 176.74,61.76 175.97,61.76 175.54,62.2 174.99,62.2 173.11,64.08 171.18,64.08 170.02,62.92 170.02,54.03 168.71,52.72 164.24,52.72 163.12,51.61 163.12,50.79 162.62,50.29 162.62,50.01 v1(162.49,49.88)
  IN1 w0.381: v1(162.49,49.88) 160.03,49.88 159.06,48.91 159.06,44.85 158.58,44.37 158.58,39.92 155.91,37.26 152.38,37.26 150.96,35.83 149.01,35.83 147.36,34.18 113.64,34.18 113.34,33.88 106.15,33.88 105.12,34.91 81.43,34.91 80.32,33.8 79.3,33.8 76.16,30.65 76.16,28.36 67.7,19.91 67.43,19.91 66.3,18.77 58.92,18.77 58.13,19.56 55.13,19.56 45.45,29.23 45.45,32.73 44.81,33.37 44.81,34.23 44.1,34.94 44.1,39.16 v1(40.82,42.44)
  IN2 w0.305: v1(180.35,63.98) 180.37,64.01 180.37,64.51 177.78,67.1 177.78,74.92 177.22,75.48 177.22,80.51 180.8,84.09 180.8,92.32 179.27,93.86 179.27,100.24 181.16,102.13 184.08,102.13 185.1,103.14 v1(185.73,103.14)
  IN3 w0.381: v1(53.21,71.84) 52.95,71.84 52.38,71.27 52.38,69.49 51.56,68.66 49.78,68.66 44.63,63.52 43.11,63.52 40.39,60.8 40.39,53.68 39.81,53.11 39.81,49.55 41.33,48.03 41.33,45.99 40.82,45.49 v1(40.82,42.44)
  BOTTOM w0.305: PQ16.2 197.16,104.03 v1(196.64,103.51) 196.4,103.27 185.86,103.27 v1(185.73,103.14)
N21061031: length 4.5
  TOP w0.127: PR158.1 53.27,69.13 v1(53.37,69.03)
  TOP w0.381: PQ15.2 53.42,70.15 53.4,70.12 PC109.2 ; PR160.2 PC109.2 ; PC109.2 PR158.1
N21390980: length 1.8
  BOTTOM w0.127: CN23.10 172.5,94.43 TP108.1
N21390982: length 5.3
  BOTTOM w0.127: CN23.56 161,92.26 TP109.1
N21390990: length 3.2
  BOTTOM w0.127: TP150.1 160.5,93.79 CN23.58
N21401502: length 4.5
  BOTTOM w0.076: U35.A50 112.51,124.04 112.54,124.07 112.54,125.67 112.07,126.13
  BOTTOM w0.127: TP4395.1 111.49,126.92 111.49,126.72 112.07,126.13
N21401506: length 6.7
  BOTTOM w0.076: U35.B50 112.51,123.28 112.22,123.57 112.22,123.99 112.37,124.13 112.37,125.45 111.56,126.26 111.41,126.26
  BOTTOM w0.127: TP4394.1 110.37,128.29 110.37,127.77 110.36,127.76 110.36,127.35 110.37,127.34 110.37,127.3 111.41,126.26
N21401510: length 6.9
  TOP w0.127: v1(111.36,124.61) 110.42,125.55 110.42,126.53 109.68,127.27 TP4392.1
  BOTTOM w0.076: v1(111.36,124.61) 111.56,124.4 111.56,124.3 111.88,123.98 111.88,123.15 111.64,122.91 111.64,122.63 111.95,122.32 U35.D51
N21401514: length 6.8
  TOP w0.127: v1(111.36,125.24) 111.12,125.24 110.67,125.69 110.67,126.64 109.78,127.53 TP4393.1
  BOTTOM w0.076: v1(111.36,125.24) 111.41,125.24 111.78,124.87 111.78,124.32 112.05,124.05 112.05,122.84 U35.C51
N21466717: length 1.1
  TOP w0.508: C1329.2 113.72,60.23 113.85,60.35 R10930.1
N21467141: length 11.7
  TOP w0.508: R11134.1 154.74,61.5 154.74,62.13 154.99,62.38 R11174.1 154.99,62.97 155.16,63.14 C1322.1 155.16,64.15 154.99,64.33 C1338.1 v1(153.93,64.66) 151.63,64.66 151.31,64.98 v1(148.64,64.98)
  BOTTOM w0.254: JDIM2.255 148.22,64.77 148.44,64.98 v1(148.64,64.98)
N21627699: length 6
  TOP w0.127: v1(117.91,125.62) 118.55,124.99 118.55,124.89 119.06,124.38 TP4389.1
  BOTTOM w0.076: U35.D41 116.9,122.34 116.59,122.65 116.59,122.88 116.84,123.12 116.84,124.02 117.4,124.59 117.4,125.11 v1(117.91,125.62)
N21627701: length 4.7
  TOP w0.127: v1(117.91,124.99) 118.42,124.48 TP4387.1
  BOTTOM w0.076: U35.C41 117,122.84 117,123.95 117.66,124.61 117.66,124.73 v1(117.91,124.99)
N21715628: length 3.5
  TOP w0.127: v1(64.6,21.89) 65.09,21.4 PC88.1
  TOP w0.203: v1(65.72,20.87) 65.32,20.87 PC88.1
  BOTTOM w0.191: PU11.4 65.66,20.82 v1(65.72,20.87)
  BOTTOM w0.203: PR6282.2 66.12,20.62 65.87,20.87 v1(65.72,20.87)
N21715632: length 1.7
  BOTTOM w0.191: PC175.1 v1(61.78,21.33) 61.89,21.22 PU11.12
N21715634: length 3.8
  BOTTOM w0.127: v1(59.34,20.85) 59.37,20.82 60.64,20.82 61.03,20.43 PC98.1
  BOTTOM w0.191: PC98.1 61.27,20.34 61.47,20.14 61.88,20.14 62.17,20.42 PU11.10
N21715675: length 3.6
  TOP w0.203: v1(65.72,20.21) 65.59,20.09 PC87.1
  BOTTOM w0.127: v1(66.53,18.87) 66.34,19.05 PR6291.1
  BOTTOM w0.191: v1(65.72,20.21) 65.54,20.21 65.33,20.42 PU11.5
  BOTTOM w0.203: PR6291.1 66.34,19.71 65.84,20.21 v1(65.72,20.21)
N21715683: length 2.8
  BOTTOM w0.191: 65.36,21.33 65.25,21.22 PU11.3
  BOTTOM w0.203: 65.36,21.33 65.54,21.51 v1(65.61,21.51) 66.27,21.51 PC84.1
  BOTTOM w0.381: PC84.1 PR6285.2
N21716568: length 3.1
  TOP w0.127: PR6292.2 59.92,54.56 v1(59.92,55.32)
  TOP w0.305: v1(60.67,54.5) 60.62,54.55 PR6292.2
  BOTTOM w0.191: 60.68,54.5 60.63,54.45 PU10.4
  BOTTOM w0.206: v1(60.67,54.5) 60.7,54.5 60.76,54.55 PC111.1
N21716582: length 1.6
  BOTTOM w0.191: PC177.1 56.53,54.88 56.58,54.93 v1(56.93,54.93) 57.17,54.93 57.26,54.85 PU10.12
N21716584: length 4.1
  BOTTOM w0.127: PC176.1 56.2,54.01 55.77,54.44 54.15,54.44 v1(54.13,54.45)
  BOTTOM w0.191: PC176.1 56.25,53.82 57.03,53.82 57.26,54.05 PU10.10
N21716627: length 3.3
  TOP w0.127: v1(61.32,54.27) 61.32,53.5 PR6294.1
  TOP w0.305: PR6294.1 61.02,53.49 v1(60.69,53.82)
  BOTTOM w0.191: v1(60.69,53.82) 60.45,54.05 PU10.5
  BOTTOM w0.206: PR6294.1 61.02,53.49 v1(60.69,53.82)
N21716633: length 3.4
  TOP w0.127: v1(61.27,56.33) 61.27,55.59 PR6293.2
  TOP w0.305: PR6293.2 61.27,55.57 60.84,55.14 v1(60.66,55.14)
  BOTTOM w0.191: PU10.3 60.27,54.85 60.56,55.14 v1(60.66,55.14)
  BOTTOM w0.203: v1(60.66,55.14) 60.86,55.14 PR6293.2
N21720428: length 12.3
  TOP w0.127: R4548.2 v1(186.75,170.58)
  IN1 w0.089: v1(186.75,170.58) 186.75,169.06 186.11,168.42 186.11,163.81 v3(188.91,161.01)
  BOTTOM w0.127: v3(188.91,161.01) 188.93,161.01 VRAM3000.J1
N21720740: length 5.1
  TOP w0.127: 169.15,160.98 169.68,160.98 VRAM3001.J13
  TOP w0.14: R4552.2 v1(166.71,161.56) 166.81,161.56 167.7,160.67 168.84,160.67 169.15,160.98
N21720776: length 6.1
  BOTTOM w0.127: R4546.2 202.74,164.36 201.61,164.36 v1(201.34,164.09) 200.72,163.47 200.72,162.5 200.06,161.85 199.36,161.85 VRAM3000.J13
N21721587: length 4.4
  TOP w0.127: VRAM3004.J1 189.3,161.44 187.5,161.44 v1(186.19,162.75) 186.12,162.82 R4551.2
N21721607: length 4.9
  TOP w0.127: R4554.2 v1(183.1,162.82) 182.93,162.82 181.52,161.42 179.71,161.42 VRAM3001.J1
N21722041: length 13.1
  TOP w0.127: R4557.2 v1(183.44,170.58)
  IN1 w0.102: v3(179.29,160.99) 179.68,161.38 180.29,161.38
  IN1 w0.122: 180.29,161.38 180.47,161.38 183.44,164.36 v1(183.44,170.58)
  BOTTOM w0.14: v3(179.29,160.99) VRAM3005.J1
N21722089: length 5.6
  TOP w0.127: v1(166.3,164.23) 166.17,164.1 R4555.2
  IN1 w0.122: v3(169.66,161.82) 169.2,162.28 168.36,162.28 166.4,164.23 v1(166.3,164.23)
  BOTTOM w0.14: v3(169.66,161.82) VRAM3005.J13
N21722784: length 7.1
  TOP w0.127: VRAM3004.J13 199.33,161.82 200.46,161.82 201.35,162.71 201.35,164.61 v1(201.87,165.13) 202.04,165.3 202.66,165.3 R4549.2
N21854677: length 47.4
  BOTTOM w0.254: PC110.2 193.95,56.69 192.27,56.69 v1(191.83,57.13) 191.38,56.69 190.46,56.69 181.21,65.93 174.71,65.93 173.89,66.75 173.89,74.67 175.06,75.84 175.06,84.63 174.86,84.84 174.86,86.42 PR163.2 PR84.2
  BOTTOM w0.381: PR277.1 PC110.2
N21854679: length 47.2
  BOTTOM w0.254: PR85.2 PR162.2 174.48,86.45 174.48,84.68 174.68,84.47 174.68,76 173.51,74.83 173.51,66.59 174.55,65.55 181.04,65.55 190.29,56.31 191.38,56.31 v1(191.83,55.86) 192.27,56.31 193.54,56.31 PR279.1
N21854704:
  vias: v1(207.12,52.7)
N21854718: length 2.9
  BOTTOM w0.305: PC227.2 196.66,54.25 197.28,54.25 PR260.2 197.86,54.38 v1(198.23,54.76) 198.23,55.43 PR275.1
N21854764: length 2.1
  BOTTOM w0.127: PR114.2 204.41,55.59 204.66,55.34 v1(204.86,55.34)
  BOTTOM w0.381: PR112.1 203.76,54.75 204.09,55.09 PR114.2
N21854773: length 10.4
  TOP w0.305: v1(202.24,54.86) 202.24,55.14 203,55.9 v1(203.79,55.9) 204.63,55.9 v1(204.68,55.95)
  BOTTOM w0.305: PR105.1 PC200.1 205.56,57.55 PR106.2 204.56,57.14 204.78,56.92 204.78,56.05 v1(204.68,55.95) ; v1(202.24,54.86) 202.24,55.48 PR115.1 201.6,55.05 200.25,55.05 200.01,55.29 PR113.2
N21854780:
  vias: v1(204.3,63.24)
N21854821:
  vias: v1(199.37,74.57)
N21854867: length 1.4
  BOTTOM w0.381: PC199.2 193.56,60.5 PR118.1
  vias: v1(194.42,61.23)
N21854979:
  vias: v1(190.28,72.51)
N21854999:
  vias: v1(195.33,63.22)
N21855085:
  vias: v1(207.37,56.53)
N21874303: length 8.7
  TOP w0.381: PQ6.3 71.94,106.45 72.95,105.43 PQ7.2 72.07,104.41 71.81,104.16 PQ8.2 71.13,105.06 v1(70.93,105.26) PR141.2 PR140.1
N21874329: length 2.5
  TOP w0.381: PQ7.3 74.99,104.31 v1(75.14,104.47) 75.55,104.88 PR139.2
N22152049: length 10.9
  TOP w0.127: R11068.2 222.55,127.91 v1(222.05,127.91) 222.03,127.88 v1(221.42,127.88)
  IN1 w0.089: v1(222.05,127.91) 220.4,127.91 220.27,127.78 214.43,127.78 v3(213.98,128.24)
  BOTTOM w0.127: v3(213.98,128.24) 213.59,128.24 VRAM3003.J1
N22152301: length 5.2
  TOP w0.14: R11075.2 v1(210.88,150.01) 212.61,148.28 212.61,147.32 212.97,146.96 VRAM3002.J13
N22152337: length 7.1
  TOP w0.127: R11089.2 v1(217.35,114.32)
  BOTTOM w0.127: VRAM3003.J13 213.42,117.6 213.42,116.61 214.31,115.72 v1(215.32,115.72) 215.96,115.72 v1(217.35,114.32)
N22152890: length 4.4
  TOP w0.127: R11096.2 v1(213.15,131.24) 213.15,131.08 212.98,130.91 VRAM3007.J1
N22152892: length 4.1
  TOP w0.127: 213.02,136.55 213.02,137.33 VRAM3002.J1
  TOP w0.14: R11073.2 v1(213.15,134.24) 213.15,135.79 213.02,135.92 213.02,136.55
N22153055: length 14.2
  TOP w0.127: v1(224.21,137.79) 224.03,137.97 223.09,137.97 R11071.2 v1(221.93,137.43)
  IN1 w0.089: v1(221.93,137.43) 221.29,137.43 219.89,136.04 213.51,136.04 213.01,136.54 213.01,137.35 v3(212.6,137.76)
  BOTTOM w0.127: VRAM3006.J1 213,137.37 v3(212.6,137.76)
N22153103: length 7
  TOP w0.127: R11084.2 216.29,150.59 v1(215.96,150.59)
  IN1 w0.102: v3(213.43,147.34) 213.88,147.8 215.32,147.8 215.58,148.05 215.58,150.21 v1(215.96,150.59)
  BOTTOM w0.14: v3(213.43,147.34) 213.04,146.96 VRAM3006.J13
N22153566: length 5.4
  TOP w0.127: VRAM3007.J13 212.53,117.58 212.53,116.48 v1(211.31,115.27) 210.5,114.45 R11106.2
N22203161: length 1.4
  TOP w0.127: C1252.2 v1(130.06,38.37) R10873.2
N22210005: length 3
  TOP w0.127: v1(124.18,41.52) 124.18,40.96 TP154.1
  BOTTOM w0.127: JDIM1.162 124.97,42.01 124.49,41.52 v1(124.18,41.52)
N22210006: length 8.3
  TOP w0.127: TP153.1 125.02,47.39 125.02,48.41 124.9,48.53 124.9,51.96 v1(125.91,52.98)
  BOTTOM w0.127: v1(125.91,52.98) 125.72,52.79 JDIM1.165
N22221753: length 12
  TOP w0.508: v1(154.62,54.1) 155.11,53.61 R11133.1 R11170.1 C1267.1 155.11,51.08 155.16,51.04 C1265.1
  BOTTOM w0.254: JDIM1.255 148.22,52.34 148.74,52.85 153.37,52.85 v1(153.77,53.25) v1(154.62,54.1)
N22317134: length 4.6
  BOTTOM w0.127: v1(171.46,22.45) 171.39,22.52 R11107.1 171.74,23.26 172.08,22.91 D4002.1 172.84,22.91 173.98,21.78 CN2019.27
N22411423: length 2.5
  BOTTOM w0.127: U1006.9 108.53,24.81 R2868.1
N22411495: length 1.6
  BOTTOM w0.127: R2872.1 108.41,24.23 108.6,24.41 U1006.8
N22485913: length 3.6
  BOTTOM w0.127: U44.30 170.62,69.37 170.86,69.62 171.76,69.62 171.94,69.44 TP4360.1
N22485947: length 2.7
  BOTTOM w0.127: U44.29 172.47,69.87 TP4361.1
N22521878: length 7.4
  BOTTOM w0.127: Q4200.2 178.55,106.92 178.22,107.25 176.37,107.25 C4200.1 R4201.1 175.64,108.33 v1(174.87,108.33) 174.33,108.33 174.18,108.18 Q4201.3
N22521888: length 6.3
  BOTTOM w0.127: Q4201.2 174.57,106.92 174.33,107.16 173.08,107.16 172.27,107.97 172.27,108.6 C4201.1 172.28,109.11 172.39,109.22 R4203.1 172.39,110.49 v1(172.19,110.69)
N22523419: length 5.5
  TOP w0.127: Q4001.3 v1(166.17,113.28) 166.17,113.3 167.07,114.2 R4000.2 R4002.1
N22523424: length 5.7
  TOP w0.127: C4013.2 C4019.1 R4002.2 169.09,112.53 v1(169.09,112.29) Q4000.2
N22570409: length 5.1
  BOTTOM w0.203: R774.1 C798.2 169.47,27.02 v1(169.81,27.35) 170.11,27.66 170.11,28.89 170.62,29.4 U45.66
N22570473: length 7.6
  BOTTOM w0.127: v1(183.32,49.12) 183.47,48.97 183.47,48.66 183.33,48.52 R460.1 C801.1 183.85,46.87 183.85,45.73 D4015.2 183.07,44.95 182.89,44.95 182,44.06 181.79,44.06 181.58,43.85 U45.118
N22570527: length 5.6
  BOTTOM w0.127: R190.1 172.71,46.94 172.71,45.67 C796.1 172.27,44.6 v1(172.42,44.45) 172.78,44.09 173.41,44.09 173.58,43.92 U45.98
N22570909: length 8.7
  TOP w0.127: v1(184.36,39.14) 184.11,39.39 v1(183.04,39.39) 182.44,39.39 C797.1 181.85,39.97 180.74,39.97 R349.1
  BOTTOM w0.127: U45.128 185.58,41.53 184.36,40.3 v1(184.36,39.14)
N22571742:
  vias: v1(190.61,37.33)
N22571917: length 3.2
  TOP w0.127: C778.1 v1(186.28,36.48) 185.67,36.48 v1(185.6,36.55)
  BOTTOM w0.127: v1(185.6,36.55) 186.06,37 U45.12
N22607007: length 6.2
  TOP w0.127: v1(184.44,37.21) 184.34,37.3 R11283.1 v1(185.1,37.99)
  BOTTOM w0.127: v1(185.1,37.99) 185.07,38.02 185.07,38.69 185.15,38.76 185.15,40.08 186.07,41 U45.2
N22668004:
  vias: v1(159.34,39.19)
N22678439: length 24.3
  TOP w0.127: v1(150.55,97.3) 150.93,97.3 151.36,97.73 151.36,98.64 152.06,99.33 R11140.2
  IN1 w0.132: v1(150.55,97.3) 148.27,99.59 145.98,99.59 145.78,99.79 143.97,99.79 143.6,100.16 139.95,100.16 139.27,100.85 137.24,100.85 134.5,103.59 134.5,104.69 v3(134.04,105.15)
  BOTTOM w0.114: v3(134.04,105.15) 133.68,105.5 U35.AR13
N22809719: length 4.2
  BOTTOM w0.127: v1(193.71,105.79) 193.47,105.79 192.97,105.29 Q4300.6 191.91,105.29 191.73,105.1 191.73,104.52 R4329.2 R4328.1
N22809734: length 3.7
  BOTTOM w0.127: Q4300.3 189.86,106.59 189.71,106.74 189.71,106.92 189.87,107.08 190.18,107.08 190.44,107.34 R4335.1 R4336.2 191.44,108.32 v1(191.45,108.33)
N22891363:
  vias: v1(26.24,71.85)
N22891365: length 2.5
  TOP w0.127: U13.10 24.68,71.5 v1(24.95,71.77) 25.33,72.16 R11188.2
N22891474: length 2.5
  TOP w0.127: TP4376.1 22.79,72.41 23.48,71.72 U13.13
N23103876: length 16.3
  TOP w0.127: v1(149.71,106.19) 149.46,106.45 TP4378.1
  IN3 w0.114: v3(136.48,109.87) 137.09,109.27 141.51,109.27 143.21,107.56 147.91,107.56 149.28,106.19 v1(149.71,106.19)
  BOTTOM w0.127: v3(136.48,109.87) 136.78,109.57 U35.AH8
N23103877: length 15.4
  TOP w0.127: v1(149.71,106.83) 150.09,106.45 TP4377.1
  IN3 w0.114: v1(149.71,106.83) 149.03,106.83 148.06,107.79 143.31,107.79 141.6,109.49 137.51,109.49 v3(137.13,109.87)
  BOTTOM w0.127: U35.AH7 137.43,109.57 137.13,109.87 v3(137.13,109.87)
N23189818: length 7.8
  TOP w0.127: TP4380.1 132.39,126.77 130.98,125.35 130.98,121.81 130.87,121.7 130.87,121.05 131.26,120.65 v3(131.31,120.65)
  BOTTOM w0.127: v3(131.31,120.65) 131.62,120.34 U35.F16
N23189822: length 5.6
  TOP w0.127: v3(131.31,121.26) 131.23,121.34 131.23,124.52 TP4379.1
  BOTTOM w0.127: U35.E16 131.58,120.99 v3(131.31,121.26)
N23189826: length 10.5
  BOTTOM w0.076: 130.23,126.26 130.23,126 130.12,125.9 130.12,123.59 130.1,123.53 130.08,123.48 130.08,123.33 130.13,123.18 130.13,122.99 130.06,122.79 130.06,122.62 U35.C19
  BOTTOM w0.127: 130.23,126.26 130.23,130.07 130.87,130.7 131.25,130.7 TP4382.1
N23189830: length 8.5
  BOTTOM w0.076: U35.D19 129.86,121.99 130.15,122.28 130.15,122.38 130.23,122.45 130.23,122.76 130.3,122.96 130.3,123.21 130.25,123.36 130.25,123.45 130.29,123.56 130.29,125.73 130.51,125.95 130.51,126.26
  BOTTOM w0.127: 130.51,126.26 130.51,129.03 130.92,129.43 TP4381.1
N23189838: length 22.2
  TOP w0.127: TP4385.1 145.6,123.97 v1(145.98,124.35)
  IN1 w0.089: v1(145.98,124.35) 145.22,125.11 141.53,125.11 140.77,124.35 140.77,122.19 139.38,120.8 139.38,119.4 138.09,118.12 135.51,118.12 135.33,117.94 133.84,117.94 133.18,118.59 132.04,118.59 131.3,119.34 v3(131.3,119.4)
  BOTTOM w0.127: U35.G18 130.87,119.69 131.15,119.4 v3(131.3,119.4)
N23189842: length 23.1
  TOP w0.127: TP4383.1 v1(146.61,124.35)
  IN1 w0.089: v3(131.27,120.03) 131.76,119.54 131.76,119.15 132.09,118.81 133.23,118.81 133.91,118.13 135.26,118.13 135.43,118.31 138.01,118.31 139.19,119.48 139.19,120.88 140.58,122.27 140.58,124.43 141.46,125.31 145.66,125.31 v1(146.61,124.35)
  BOTTOM w0.127: v3(131.27,120.03) 130.96,120.34 U35.F18
N23189846: length 11.7
  BOTTOM w0.076: 129.3,126.26 129.3,125.9 129.2,125.81 129.2,123.35 129.6,122.96 129.6,122.63 129.29,122.33 U35.D20
  BOTTOM w0.127: TP4386.1 129.72,132.73 129.72,131.46 129.3,131.04 129.3,126.26
N23189850: length 10.9
  BOTTOM w0.076: 129.04,126.26 129.04,123.28 129.29,123.03 U35.C20
  BOTTOM w0.127: TP4384.1 129.47,132.48 129.47,131.59 129.04,131.16 129.04,126.26
N23190260: length 14.7
  TOP w0.127: v1(144.2,122.91) 143.95,123.16 TP4390.1
  IN1 w0.089: v4(134.55,116.35) 134.93,116.35 135.33,116.75 138.75,116.75 142.17,120.18 142.17,121.69 143.39,122.91 v1(144.2,122.91)
  BOTTOM w0.076: U35.N11 134.55,116.52 v4(134.55,116.35)
N23228913: length 3.6
  TOP w0.191: PC214.1 v1(38.75,95.11) 38.9,95.26 PU20.3
  TOP w0.203: PC214.1 PR6299.2
N23228944: length 3.5
  TOP w0.191: v1(40.09,95.14) 39.3,95.93 PU20.4
  TOP w0.203: v1(40.09,95.14) 40.09,94.74 39.93,94.58 PC180.1 PR6300.2
N23228948: length 2.1
  TOP w0.191: PU20.12 v1(38.9,99.55)
  TOP w0.203: PC210.1 39.17,99.84 38.9,99.57 v1(38.9,99.55)
N23229578: length 10.4
  TOP w0.127: v1(32.57,50.87) 32.82,51.12 PQ6058.2
  TOP w0.254: PQ6058.2 32.82,52.78 33.28,53.23 34.73,53.23 35.62,54.12 PQ6057.3 38.26,54.12 39.65,52.73 PR6290.1
N23263090: length 1.8
  TOP w0.127: R11210.1 v1(31.68,115.31) U9.30
N23457928: length 7.4
  TOP w0.127: Q39.3 46.41,78.76 46.67,78.51 v1(46.67,78.32) R713.1 R715.1 45.78,78 45.15,78.62 43.49,78.62 43.36,78.75 R709.2
N23457985: length 16.1
  IN2 w0.508: v1(34.47,79.9) v1(34.47,82.4) v1(34.47,85.4) v1(34.47,88.4)
  BOTTOM w0.508: U42.4 v1(34.47,85.4) ; U42.1 v1(34.47,88.4) 35.11,88.4 35.11,88.4 C364.2 ; U42.10 33.97,79.4 v1(34.47,79.9) ; U42.7 v1(34.47,82.4)
N23458009: length 5.5
  TOP w0.127: C368.2 49.34,65.54 49.08,65.81 Q24.2 49.08,67.08 50.35,68.35 v1(50.35,69.22) R259.2
N23458593: length 2.6
  TOP w0.203: U15.32 38.5,68.64 v1(38.37,68.51) 38.18,68.32 38.18,67.11 R11259.1
N23458605: length 6.3
  TOP w0.127: R11261.2 R11260.2 v1(36.47,65.9) 36.65,65.9 36.76,66.01 36.76,67.14 37.7,68.09 U15.30
N23458824: length 5
  TOP w0.127: TP4333.1 44.89,70.76 43.61,70.76 C4603.1 43,71.27 42.33,71.94 41.7,71.94 41.58,72.06 U15.41
N23458866: length 5
  TOP w0.127: U15.37 41.37,70.46 41.99,69.84 42.58,69.84 42.73,70 C4604.1 43.11,70 43.62,69.49 44.89,69.49 TP4334.1
N23458888: length 6.3
  TOP w0.127: U15.40 42,71.66 43.16,70.5 45.9,70.5 TP4335.1
N23458910: length 6.5
  TOP w0.127: U15.43 42.53,72.86 42.86,72.54 42.86,72.16 43.24,71.77 45.9,71.77 TP44.1
N23458912: length 1.4
  TOP w0.127: U15.38 41.53,70.86 42.02,70.38 TP4336.1
N23534575: length 12.8
  TOP w0.127: U40.4 12.74,85.68 v1(12.5,85.44) ; v1(8.82,78) 9.33,77.49 R11269.1
  BOTTOM w0.127: v1(8.82,78) 9.33,78.51 9.33,79.39 8.57,80.16 8.57,83.08 v1(9.88,84.39) 10.93,85.44 v1(12.5,85.44)
N23535764: length 9.8
  TOP w0.127: R11272.1 9.2,78.51 v1(8.82,78.89) ; U37.4 v1(9.82,85.86)
  BOTTOM w0.127: v1(9.82,85.86) 9.33,85.86 8.31,84.85 8.31,79.39 v1(8.82,78.89)
N23556733: length 2.2
  TOP w0.127: U18.4 19.23,51.63 v1(19.41,51.81) 19.49,51.89 R11273.1
N23597462: length 9.4
  TOP w0.254: PC16.2 137.9,168.5 137.22,167.81 136.89,167.81 136.43,167.36 PC12.1
  TOP w0.305: PR187.1 135.37,167.85 135.42,167.8 PR191.2 136.41,167.33 PC12.1
  TOP w0.381: PC11.1 135.95,168.39 135.9,168.35 PR187.1 135.37,169.14 v1(135.74,169.51)
  BOTTOM w0.305: v1(135.74,169.51) 135.77,169.51 135.79,169.54 136.1,169.54 v1(136.41,169.85) 136.61,170.05 137.35,170.05 PR194.2
N23597481: length 7.8
  TOP w0.254: PR33.1 149.23,176.25 149.66,176.68 149.66,177.31 149.27,177.7 PC25.2
  TOP w0.305: PC25.2 149.26,177.93 PR31.1 PC26.2 147.03,177.93 146.6,177.5 PR201.2 145.85,177.85 v1(145.85,178.61) 145.85,178.68 145.34,179.19 PC27.1
N23597525: length 2.7
  BOTTOM w0.127: PR224.1 137.58,163.99 v1(137.6,163.98)
  BOTTOM w0.305: PR224.1 136.88,163.98 PR235.2 136.85,162.99 PR236.2
N23597538: length 1.8
  TOP w0.381: PC41.1 141.88,184.44 v1(141.36,183.92) PR44.2
N23597590: length 2.7
  BOTTOM w0.127: v1(124.72,161.89) PR225.1
  BOTTOM w0.305: PR227.2 PR226.2 125.45,162.84 PR225.1
N23597608: length 1.9
  TOP w0.381: PC139.1 v1(143.29,183.59) 142.92,183.21 PR216.2
