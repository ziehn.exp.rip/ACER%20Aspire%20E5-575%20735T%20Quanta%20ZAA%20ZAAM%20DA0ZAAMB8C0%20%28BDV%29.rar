# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN2 (solid shape): outline of 616 points within 206.3,178.79 227.87,192.66
GND on IN2 (solid shape): outline of 1389 points within 116.31,150.74 155.12,161.38
GND on IN2 (solid shape): outline of 2018 points within 178.39,60.37 218.98,111.5
GND on IN2 (solid shape): outline of 3519 points within 1.41,20.85 21.39,97.68
GND on IN2 (solid shape): outline of 4724 points within 0.51,0.51 244.39,198.19
GND on IN2 (solid shape): outline of 14553 points within 80.96,44.22 154.97,76.27
GND on IN3 (solid shape): 142.04,96.67 142.04,93.11 141.92,92.98 140.26,92.98 140.14,93.11 140.14,96.41 140.52,96.79 141.92,96.79
GND on IN3 (solid shape): 115.12,132.57 115.12,129.81 114.99,129.69 112.45,129.69 111.82,129.05 111.44,129.05 111.18,129.31 111.18,132.61 111.31,132.73 112.96,132.73 113.59,133.37 114.32,133.37
GND on IN3 (solid shape): 192.72,113.43 194.75,113.43 194.87,113.3 194.87,110.13 194.49,109.75 193.86,109.75 193.22,110.38 191.19,110.38 191.06,110.51 191.06,113.43 191.7,114.07 192.08,114.07
GND on IN3 (solid shape): 48.06,75.2 48.06,74.7 47.55,74.19 47.55,72.28 47.17,71.9 44.51,71.9 44.38,72.03 44.38,72.41 44.13,72.66 43.87,72.66 43.74,72.79 43.74,73.3 44.38,73.93 44.38,75.58 44.51,75.71 47.55,75.71
GND on IN3 (solid shape): 10.47,44.62 10.47,44.62 10.75,44.34 13.39,44.34 15.93,41.8 15.93,38.37 14.66,37.1 12.38,37.1 12.38,38.6 11.58,39.62 10.39,39.11 2.31,39.11 2.31,39.16 2.31,42.24 2.31,42.29 8.75,42.29 9.45,42.69 9.46,43.49 9.46,45.03 10.07,45.03
GND on IN3 (solid shape): 16.82,66.57 16.82,61.74 12.12,57.04 11.16,57.04 10.12,56 9.41,56 9.26,56.15 9.26,57.25 9.26,57.27 9.28,57.29 9.51,58.18 8.75,58.71 2.36,58.71 2.32,58.72 2.31,58.76 2.31,60.64 2.31,60.66 2.33,60.68 3.78,61.89 6.1,61.89 7.61,63.4 6.1,64.91 3.73,64.91 3.53,65.11 3.53,67.85 3.58,67.94 4.65,67.99 5.13,68.85 5.13,73.54 5.26,73.68 9.71,73.68
GND on IN3 (solid shape): outline of 187 points within 0.51,111.66 13.39,117.24
GND on IN3 (solid shape): outline of 225 points within 1.41,82.06 15.68,97.56
GND on IN3 (solid shape): outline of 1580 points within 196.19,172.1 225.74,192.42
GND on IN3 (solid shape): outline of 6814 points within 0.51,0.51 244.39,198.19
GND on SGND1 (solid shape): outline of 4426 points within 0.51,0.51 244.39,198.19
VCCGT_PHASE1 on BOTTOM (solid shape): 123.26,163.61 123.26,162.8 122.64,162.17 122.41,162.17 121.04,160.8 120.82,160.8 120.78,160.82 120.77,160.85 120.77,161.42 122.33,162.99 122.33,163.62 122.38,163.67 123.2,163.67
VCCGT_PHASE1 on BOTTOM (solid shape): 122.48,155.77 122.48,152.14 122.18,151.84 120.38,151.84 119.92,152.29 119.92,152.66 119.92,154.39 119.36,154.39 119.36,152.66 119.36,152.55 118.83,152.01 116.83,152.01 116.76,152.05 116.34,152.47 116.34,155.42 117,156.08 118.75,156.08 118.95,156.28 118.95,156.74 119.08,156.86 121.39,156.86
VCCGT_PHASE2 on BOTTOM (solid shape): 131.53,163.49 131.53,161.59 130.69,160.75 130.51,160.75 130.47,160.77 130.46,160.8 130.46,161.33 130.43,161.36 130.43,163.47 130.54,163.57 131.45,163.57
VCCGT_PHASE2 on BOTTOM (solid shape): 132.01,156.23 132.01,151.43 131.78,151.2 129.37,151.2 129.01,151.56 129.01,152.59 129.01,152.59 129.01,154.31 128.45,154.31 128.45,152.59 128.45,152.32 127.97,151.84 125.53,151.84 125.35,152.01 125.35,155.29 125.71,155.65 128.43,155.65 128.73,155.95 128.73,156.74 128.8,156.8 131.44,156.8
VCCGT_VBST1 on BOTTOM (solid shape): 121.82,163.57 121.82,162.83 120.68,161.69 120.33,161.69 120.02,161.39 120.02,161.32 120.02,160.88 120.01,160.84 119.97,160.83 119.82,160.83 119.78,160.84 119.77,160.88 119.77,161.37 119.77,161.51 120.91,162.66 120.91,163.6 120.96,163.65 121.75,163.65
VCCGT_VBST2 on BOTTOM (solid shape): 130.1,163.38 130.1,161.79 129.72,161.41 129.72,161.33 129.71,161.33 129.71,160.8 129.7,160.77 129.66,160.75 129.51,160.75 129.47,160.77 129.46,160.8 129.46,161.33 129.44,161.33 129.44,162.02 129.09,162.38 129.09,163.38 129.22,163.51 129.98,163.51
VCCGT_VCC1 on TOP (solid shape): 118.46,162.72 118.46,161.74 118.52,161.74 118.52,161.31 118.36,161.14 117.75,161.14 117.58,161.31 117.58,162.68 117.63,162.73 118.45,162.73
VCCGT_VCC1 on BOTTOM (solid shape): 118.6,162.58 118.6,160.69 118.58,160.66 118.55,160.64 118.05,160.64 118.05,160.4 118.55,160.4 118.58,160.38 118.6,160.35 118.6,160.19 118.55,160.14 118.04,160.14 118.04,160.14 117.66,160.14 117.4,160.4 117.4,162.61 117.51,162.71 118.47,162.71
VCCGT_VCC2 on TOP (solid shape): 127.39,161 127.87,161 128.05,160.82 128.05,160.22 127.87,160.04 126.09,160.04 126.04,160.09 126.04,160.92 126.08,160.97 127.06,160.97 127.06,161.01 127.39,161.01
VCCGT_VCC2 on BOTTOM (solid shape): 128.3,160.88 128.3,160.65 128.29,160.62 128.25,160.6 127.74,160.6 127.74,160.36 128.25,160.36 128.29,160.34 128.3,160.31 128.3,160.15 128.29,160.12 128.25,160.1 127.73,160.1 127.73,160.09 126.07,160.09 126.04,160.12 126.04,160.92 126.08,160.97 126.11,161.02 126.12,161.03 128.15,161.03
VCCSA_SW on BOTTOM (solid shape): 154.08,163.48 154.08,162.59 152.64,161.15 152.36,161.15 152.36,161.97 152.92,162.53 152.92,163.42 153.03,163.53 154.03,163.53
VCCSA_SW on BOTTOM (solid shape): 153.98,156.18 153.98,149.07 153.65,148.74 151.62,148.74 151.06,149.3 151.06,151.62 150.5,151.62 150.5,149.75 150.04,149.3 147.88,149.3 147.35,149.83 147.35,151.71 148.29,152.65 148.29,154.43 150.53,156.66 150.53,157.07 150.65,157.2 152.96,157.2
VCCSA_VBST on BOTTOM (solid shape): 152.61,163.48 152.61,162.64 151.93,161.96 151.68,161.96 151.62,161.89 151.62,161.15 151.36,161.15 151.36,162.28 151.52,162.43 151.52,163.44 151.61,163.54 152.56,163.54
VCCSA_VCC on BOTTOM (solid shape): 149.33,162.26 149.39,162.18 149.47,162.12 150.18,161.41 150.18,160.97 149.66,160.97 149.61,160.92 149.61,160.75 149.64,160.73 150.2,160.73 150.2,160.47 149.58,160.47 149.22,160.12 148.01,160.12 147.96,160.17 147.96,162.33 148.03,162.39 149.2,162.39
VDD10 on TOP (solid shape): 45.52,76.35 45.52,76.09 45.4,75.97 45.14,75.97 44.76,76.35 43.62,76.35 42.86,75.58 42.86,74.57 42.82,74.49 42.8,74.38 42.43,74.02 42.38,73.99 42.34,73.95 42.33,73.94 42.31,73.93 42.09,73.93 41.84,74.19 41.84,74.37 41.86,74.39 41.91,74.42 41.96,74.45 42.19,74.68 42.24,74.77 42.26,74.86 42.26,75.73 42.6,76.07 42.6,76.73 42.86,76.98 44.89,76.98
VDD10 on TOP (solid shape): 31.17,73.68 31.17,73 31.16,72.97 31.12,72.95 30.13,72.95 30.13,72.84 30.11,72.81 30.08,72.79 30.03,72.79 29.65,72.41 29.41,72.41 29.38,72.42 29.36,72.44 29.11,72.65 28.79,72.59 28.69,72.59 28.63,72.68 28.63,73.43 29.01,73.81 30.57,73.81 30.57,73.81 31.04,73.81
VDD10 on TOP (solid shape): 46.21,69.55 46.28,69.49 46.4,69.38 46.41,69.36 46.41,69.34 46.41,68.37 46.41,68.35 46.4,68.33 46.29,68.22 46.28,68.22 46.28,67.1 46.28,67.08 46.27,67.06 46.05,66.84 46.03,66.83 46.01,66.82 44.78,66.82 44.76,66.83 44.75,66.84 44.68,66.9 44.67,66.92 44.67,66.94 44.67,68.61 44.87,68.81 44.88,68.82 44.89,68.84 44.89,69.12 44.88,69.14 44.86,69.17 44.86,69.21 44.94,69.29 44.97,69.3 45.09,69.42 45.11,69.43 45.14,69.43 45.41,69.44 45.63,69.6 45.65,69.61 45.67,69.62 46.16,69.62
VDD10 on BOTTOM (solid shape): outline of 537 points within 28.76,67.08 46.28,79.14
VDD_DAC_33 on BOTTOM (solid shape): 21.52,68.98 21.52,68.35 21.01,67.84 21.01,67.2 20.88,67.08 20.25,67.08 20.12,67.2 20.12,68.85 20.38,69.11 21.39,69.11
VDDREG on TOP (solid shape): 39.75,70.1 39.79,70.08 39.8,70.05 39.8,69.07 39.81,69.07 39.81,68.98 40.19,68.6 40.57,68.6 41.33,67.84 41.33,66.95 41.46,66.82 42.47,66.82 42.6,66.69 42.6,65.9 42.55,65.72 42.59,65.54 42.51,65.46 41.03,65.46 41.03,65.37 40.82,65.17 39.93,65.17 39.81,65.3 39.81,68.45 39.6,68.65 39.6,70.07 39.63,70.1
VIN on TOP (solid shape): 153.24,160.7 153.24,159.71 153.02,159.48 151.44,159.48 151.16,159.76 151.16,160.67 151.39,160.9 153.04,160.9
VIN on TOP (solid shape): 117.02,162.71 117.02,161.44 116.64,161.05 115.89,161.05 115.5,161.44 115.5,162.71 115.75,162.96 116.77,162.96
VIN on TOP (solid shape): 57.61,47.21 57.61,43.78 57.44,43.61 54.9,43.61 54.02,44.48 54.02,45.9 54.01,45.92 54.01,47.82 54.35,48.17 56.66,48.17
VIN on TOP (solid shape): 144.23,161.61 144.23,159.2 143.92,158.9 139.32,158.9 139.07,158.64 139.07,157.91 138.99,157.83 138.16,157.83 138.03,157.96 138.03,159.63 138.77,160.37 141.38,160.37 142.91,161.89 143.95,161.89
VIN on TOP (solid shape): 57.38,68.4 57.38,63.32 57.08,63.01 55.43,63.01 55,63.44 54.46,63.44 54.39,63.52 54.09,63.52 54.08,63.52 52.68,63.52 52.68,63.52 51.9,63.52 50.95,64.47 50.95,68.21 51.38,68.65 57.13,68.65
VIN on TOP (solid shape): 58.15,33.07 58.15,32.81 58.12,32.79 58.12,30.5 57.92,30.3 56.83,30.3 56.55,30.02 56.55,29.1 56.42,28.98 54.51,28.98 54.13,29.36 50.83,29.36 50.25,29.94 50.25,32.66 50.37,32.79 53.42,32.79 54.06,33.42 57.79,33.42
VIN on TOP (solid shape): 54.09,80.2 55.03,80.2 56.7,78.53 59.98,78.53 60,78.51 61.02,78.51 61.14,78.38 61.14,75.92 60.72,75.5 60.02,75.5 58.49,73.97 54.98,73.97 54.79,73.78 50.26,73.78 48.19,75.85 48.19,78.28 48.22,78.28 48.44,78.51 50.04,78.51 50.53,78.99 50.53,79.57 50.78,79.83 51.95,79.83 52.22,80.09 53.16,80.09 53.27,80.21 54.08,80.21
VIN on TOP (solid shape): 166.78,185.11 166.78,181.88 165.79,180.89 165.79,179.65 165.69,179.55 165.03,179.55 164.14,178.66 164.14,177.97 163.94,177.77 161.35,177.77 161.25,177.87 161.25,179.19 161.47,179.42 161.5,179.41 161.82,179.46 161.98,179.74 161.98,179.76 162.22,180 162.22,180.17 163.38,181.33 163.38,181.78 163.57,181.97 163.57,181.99 163.58,182 163.67,182.37 163.4,182.63 163.38,182.65 163.38,184.83 163.76,185.21 166.68,185.21
VIN on TOP (solid shape): 212.53,82.27 212.55,82.27 212.69,82.13 212.69,71.62 212.13,71.06 206.86,71.06 206.46,71.47 206.46,80.72 205.7,81.48 200.59,81.48 200.58,81.46 200.12,81.46 198.74,80.08 185.45,80.08 183.09,77.72 183.09,73.5 182.12,72.54 178.16,72.54 176.84,73.86 176.84,80.4 176.85,80.43 176.88,80.45 178.86,81.93 179.56,84.31 179.57,84.33 179.58,84.34 180.04,84.81 195,84.81 195.04,84.84 196.08,84.84 197.82,86.58 208.21,86.58
VIN on TOP (solid shape): outline of 202 points within 220.4,124.51 232.21,175.91
VIN on BOTTOM (solid shape): 136.02,164.59 136.02,162.88 135.69,162.55 131.96,162.55 131.81,162.71 131.81,164.82 131.93,164.94 135.67,164.94
VIN on BOTTOM (solid shape): 165.99,181.02 165.99,180.08 165.82,179.9 164.06,179.9 163.81,180.16 163.81,180.97 164.01,181.17 165.84,181.17
VIN on BOTTOM (solid shape): 219,99.21 219,95.4 218.75,95.14 215.32,95.14 215.07,95.4 215.07,99.21 215.32,99.46 218.75,99.46
VIN on BOTTOM (solid shape): 133.66,170.07 134.83,170.07 135.29,169.62 135.29,167.58 134.91,167.2 131.5,167.2 131.43,167.28 131.43,170.12 131.76,170.45 133.28,170.45
VIN on BOTTOM (solid shape): 183.14,78.96 183.14,67.25 182.87,66.99 177.13,66.99 176.61,67.51 176.61,79.45 177.91,80.74 181.36,80.74
VIN on BOTTOM (solid shape): 60.31,45.59 61.4,45.59 61.6,45.38 61.6,41.7 61.4,41.5 58.86,41.5 56.77,43.58 54.95,43.58 54.18,44.34 54.18,45.99 54.36,46.17 59.72,46.17
VIN on BOTTOM (solid shape): 218.62,82.93 218.62,76.14 216.97,74.49 213.59,74.49 213.34,74.24 213.34,69.03 213.21,68.9 213.21,67.46 212.98,67.23 207.4,67.23 207.14,67.48 207.14,82.57 208.08,83.51 218.04,83.51
VIN on BOTTOM (solid shape): 61.6,68.04 61.6,65.83 61.5,65.73 59.34,65.73 59.33,65.72 58.01,65.72 57.41,65.12 57.41,64.56 56.93,64.08 52.21,64.08 51.03,65.26 51.03,67.68 52,68.65 60.99,68.65
VIN on BOTTOM (solid shape): 212.73,183.81 212.73,182.83 212.73,182.67 212.73,182.51 212.73,181.02 213.34,180.41 213.34,179.04 213.2,178.9 210.13,178.9 209.1,179.93 209.1,181.02 208.21,181.91 208.21,183.1 209.02,183.92 209.02,184.07 209.14,184.18 212.36,184.18
VIN on BOTTOM (solid shape): 113.67,163.01 113.67,162.73 113.73,162.67 115.24,162.67 115.3,162.73 115.3,163.01 115.63,163.34 117.02,163.34 117.15,163.21 117.15,161.31 116.77,160.93 116.26,160.93 115.75,161.44 112.2,161.44 112.07,161.56 112.07,163.47 112.2,163.6 113.09,163.6
VIN on BOTTOM (solid shape): 149.76,171.44 152.94,171.44 153.07,171.57 155.45,171.57 155.76,171.27 155.76,166.34 155.4,165.98 150.8,165.98 150.78,166 150.77,165.99 150.75,165.98 148.47,165.98 147.88,166.57 147.88,169.41 148.28,169.81 148.3,169.81 148.74,170.24 148.74,171.09 149.22,171.57 149.64,171.57
VIN on BOTTOM (solid shape): 161.19,166.36 161.19,163.27 161.18,163.26 161.18,160.46 160.5,159.78 158.1,159.78 157.77,159.46 150.37,159.46 150.36,159.47 150.36,159.83 150.22,159.97 149.64,159.97 149.64,160.23 150.25,160.23 150.36,160.34 150.36,161 153.45,161 155.3,162.85 155.33,162.85 155.45,162.97 155.92,162.97 156.5,163.55 156.5,164.38 158.76,166.64 160.91,166.64
VIN on BOTTOM (solid shape): 61.21,34.46 61.22,34.46 61.5,34.18 61.95,34.18 62.21,33.92 62.21,31.97 62.13,31.9 58.1,31.9 57,30.8 55.28,30.8 54.36,31.72 54.36,34.39 56.8,34.39 56.8,33.9 57.59,33.12 58.55,33.12 58.68,33.24 58.68,34.03 57.89,34.82 57.23,34.82 56.8,34.39 54.36,34.39 54.36,34.92 55.03,35.59 60.08,35.59
VIN on BOTTOM (solid shape): 221.39,174.72 222.54,174.72 222.87,175.05 227.29,175.05 228.02,174.31 231.76,174.31 232.36,173.71 232.36,170.19 231.78,169.62 228.22,169.62 227.6,168.99 225.89,168.99 225.46,169.42 225.46,172.38 225.1,172.74 223.35,172.74 222.61,173.48 221.42,173.48 221.11,173.78 218.52,173.78 218.52,174.26 218.4,174.39 218.21,174.39 218.21,174.4 217.4,174.4 217.4,174.66 218.21,174.66 218.21,174.67 218.34,174.67 218.52,174.85 218.52,175.08 221.04,175.08
VIN on BOTTOM (solid shape): 147.35,166.49 147.35,161.44 144.89,158.97 141.41,158.97 141.33,158.9 138.39,158.9 138.35,158.91 138.33,158.95 138.33,159.33 138.28,159.38 138.19,159.38 138.17,159.4 137.65,159.4 137.61,159.41 137.6,159.45 137.6,159.6 137.61,159.64 137.65,159.65 138.17,159.65 138.2,159.68 138.23,159.68 138.33,159.79 138.33,160.34 138.35,160.38 138.39,160.4 141.38,160.4 143.39,162.4 143.39,165.88 144.56,167.05 146.79,167.05
VIN on BOTTOM (solid shape): 54.72,82.72 54.72,81.58 55.07,81.22 55.48,81.22 55.71,81 55.71,80.33 55.66,80.28 55.12,80.28 55.02,80.18 55.02,79.45 55.3,79.17 55.63,79.17 55.71,79.09 55.71,78.58 56.27,78.02 58.88,78.02 61.48,75.42 62.65,75.42 62.97,75.1 65.56,75.1 65.59,75.08 65.59,74.7 65.82,74.47 66.68,74.47 66.68,74.24 65.79,74.24 65.59,74.04 65.59,73.81 63.02,73.81 62.97,73.86 62.97,73.96 62.83,74.11 61.54,74.11 61.37,73.93 57.45,73.93 57.44,73.92 51.92,73.92 51.51,74.33 51.51,79.36 52.25,80.11 53.17,80.11 53.93,80.87 53.93,81.99 54.21,82.27 54.21,82.82 54.62,82.82
VIN on SVCC (solid shape): outline of 2209 points within 42.98,21.61 233.22,183.15
VIN on IN2 (solid shape): outline of 113 points within 115.36,160.93 135.95,165.37
1P35V_BOOT on TOP (solid shape): 45.47,61.21 45.47,60.5 45.17,60.19 45.17,59.23 44.86,58.92 44.86,58.66 44.86,57.7 44.85,57.67 44.81,57.65 44.68,57.65 44.66,57.68 44.66,58.66 44.66,59.63 44.43,59.86 44.43,61.26 44.53,61.36 45.32,61.36
1P35V_LGATE on TOP (solid shape): 47.63,57.98 47.63,57.78 47.12,57.27 45.9,57.27 45.87,57.29 45.85,57.32 45.85,57.4 45.87,57.43 45.9,57.45 46.28,57.45 47.05,58.21 47.4,58.21
1P35V_LGATE on BOTTOM (solid shape): 58.71,61.77 58.71,61.16 58.68,61.13 57.26,61.13 57.17,61.22 57.17,61.73 57.31,61.87 58.6,61.87
1P35V_PHASE on TOP (solid shape): 48.32,59.99 48.32,59.2 48.06,58.95 46.97,58.95 45.68,57.65 45.51,57.65 45.47,57.67 45.46,57.7 45.46,58.62 45.47,58.65 45.51,58.67 45.73,58.67 47.15,60.09 48.22,60.09
1P35V_PHASE on BOTTOM (solid shape): 65.94,65.54 65.94,60.14 64.9,59.1 63.4,59.1 62.77,58.47 59.49,58.47 59.29,58.67 59.29,65.15 59.34,65.2 61.6,65.2 62.1,65.69 65.79,65.69
1P35V_UGATE on TOP (solid shape): 46.09,60.1 46.09,59.42 45.55,58.87 45.42,58.87 45.24,58.69 45.24,57.7 45.23,57.67 45.19,57.65 45.12,57.65 45.08,57.67 45.07,57.7 45.07,58.87 45.37,59.18 45.37,60.12 45.46,60.21 45.99,60.21
1P35V_UGATE on BOTTOM (solid shape): 59.11,65.12 59.11,64.33 59.06,64.28 57.82,64.28 57.69,64.41 57.69,64.99 57.84,65.15 59.09,65.15
554LX_0.95V on BOTTOM (solid shape): 207.5,173.98 207.53,173.97 207.55,173.93 207.55,172.96 207.74,172.96 207.74,173.93 207.76,173.97 207.8,173.98 208,173.98 208.03,173.97 208.05,173.93 208.05,172.96 208.24,172.96 208.24,173.93 208.26,173.97 208.3,173.98 209.45,173.98 210.83,172.61 211.84,172.61 214.84,169.62 214.84,167.63 214.86,167.61 214.86,167.2 214.38,166.72 207.83,166.72 207.22,167.33 207.22,172.93 207.24,172.96 207.24,173.93 207.26,173.97 207.3,173.98
554SVIN_0.95V on BOTTOM (solid shape): 207.55,178.56 207.55,177.15 207.55,176.22 207.53,176.18 207.5,176.17 207.3,176.17 207.26,176.18 207.24,176.22 207.24,177.15 207.22,177.17 207.22,177.54 206.84,177.92 206.41,177.92 206.18,178.15 204.93,178.15 204.83,178.25 204.83,178.73 204.88,178.79 207.32,178.79
1658R-BOOT1 on BOTTOM (solid shape): 203.38,62.68 203.38,61.89 203.27,61.78 202.69,61.78 201.96,61.06 201.96,60.89 201.95,60.86 201.91,60.84 201,60.84 200.96,60.86 200.95,60.89 200.95,61.11 202.57,62.73 203.33,62.73
1658R-BOOT2 on BOTTOM (solid shape): 198.76,61.13 198.76,60.85 198.75,60.84 197.8,60.84 197.76,60.86 197.74,60.89 197.74,61.26 197.2,61.81 196.36,61.81 196.25,61.92 196.25,62.73 196.27,62.76 197.14,62.76
1658R-LGATE1 on BOTTOM (solid shape): 197.82,79.24 197.82,77.9 197.77,77.85 196.73,77.85 196.65,77.92 196.65,79.27 196.91,79.52 197.54,79.52
1658R-LGATE1 on BOTTOM (solid shape): 198.22,73.34 198.22,72.92 197.86,72.56 197.86,71.72 197.81,71.67 196.77,71.67 196.72,71.72 196.72,73.12 197,73.4 197,73.4 197.16,73.56 198,73.56
1658R-LGATE2 on BOTTOM (solid shape): 192.87,76.03 192.87,74.73 192.56,74.43 191.98,74.43 191.7,74.71 191.7,76 191.78,76.08 192.82,76.08
1658R-LGATE2 on BOTTOM (solid shape): 192.82,69.88 192.82,68.51 192.19,67.89 191.19,67.89 191.14,67.94 191.14,68.4 191.42,68.68 191.42,69.62 191.43,69.63 191.43,69.81 191.56,69.93 192.77,69.93
1658R-LGATE2 on BOTTOM (solid shape): 199.55,63.16 199.55,61.26 199.52,61.23 199.4,61.23 199.37,61.25 199.35,61.28 199.35,62.24 199.35,62.24 199.35,62.4 198.89,62.86 198.89,63.24 199.04,63.39 199.32,63.39
1658R-PHASE1 on BOTTOM (solid shape): 202.62,64.1 202.62,63.06 200.82,61.26 200.6,61.26 200.57,61.27 200.55,61.31 200.55,62.24 201.43,63.11 201.43,64.05 201.53,64.15 202.57,64.15
1658R-PHASE1 on BOTTOM (solid shape): 203.31,85.14 204.43,85.14 204.86,84.7 204.86,78.73 205.29,78.3 206.28,78.3 206.41,78.18 206.41,74.26 206.15,74.01 205.19,74.01 204.81,73.63 204.81,72.16 205.34,71.62 206.36,71.62 206.46,71.52 206.46,67.33 206.3,67.18 198.71,67.18 198.43,67.46 198.43,79.52 198.05,79.9 194.39,79.9 193.17,81.12 193.17,84.93 193.4,85.16 203.28,85.16
1658R-PHASE2 on BOTTOM (solid shape): 198.23,64 198.23,63.19 199.15,62.26 199.15,61.28 199.14,61.25 199.1,61.23 198.94,61.23 197.03,63.14 197.03,64.13 197.08,64.18 198.05,64.18
1658R-PHASE2 on BOTTOM (solid shape): 191.62,84.88 191.62,80.84 190.91,80.13 190.91,68.9 190.28,68.27 185.65,68.27 184.92,69.01 184.92,69.03 183.9,69.03 183.77,69.16 183.77,72.36 183.9,72.49 184.94,72.49 185.07,72.61 185.1,72.61 185.3,72.82 185.3,75.2 185.2,75.31 183.95,75.31 183.85,75.41 183.85,79.09 181.39,81.55 181.39,85.01 181.62,85.24 191.27,85.24
1658R-PVCC on BOTTOM (solid shape): 201.57,64.62 201.57,64.47 200.89,63.8 200.89,63.7 200.82,63.62 200.13,63.62 199.95,63.44 199.95,62.24 199.95,62.24 199.95,61.31 199.94,61.27 199.9,61.26 199.8,61.26 199.77,61.27 199.75,61.31 199.75,62.24 199.73,62.26 199.73,63.37 199.45,63.65 198.96,63.65 198.89,63.72 198.89,64.26 198.96,64.33 199.52,64.33 199.88,64.69 199.88,64.68 200.95,64.68 200.95,64.69 201.49,64.69
1658R-UGATE1 on BOTTOM (solid shape): 206.33,73.45 206.33,72.08 206.28,72.03 205.26,72.03 205.21,72.08 205.21,73.5 205.42,73.71 206.08,73.71
1658R-UGATE1 on BOTTOM (solid shape): 206.39,80.16 206.39,78.84 206.32,78.76 205.33,78.76 205.25,78.84 205.25,80.16 205.48,80.39 206.16,80.39
1658R-UGATE1 on BOTTOM (solid shape): 203.49,61.46 203.49,61.01 202.9,60.42 201.97,60.42 201.95,60.44 201,60.44 200.96,60.46 200.95,60.49 200.95,60.62 200.96,60.64 201.95,60.64 201.95,60.65 202.01,60.65 202.89,61.52 203.42,61.52
1658R-UGATE2 on BOTTOM (solid shape): 184.99,68.63 184.99,67.2 184.79,67 184.11,67 183.88,67.23 183.88,68.6 183.93,68.65 184.97,68.65
1658R-UGATE2 on BOTTOM (solid shape): 185.04,74.75 185.04,73.32 184.82,73.1 184.11,73.1 183.88,73.32 183.88,74.75 183.93,74.8 184.99,74.8
1658R-UGATE2 on BOTTOM (solid shape): 197.59,60.88 197.59,60.75 197.69,60.65 197.76,60.65 197.76,60.64 198.74,60.64 198.76,60.62 198.76,60.49 198.75,60.46 198.71,60.44 197.76,60.44 197.74,60.42 197.59,60.42 197.58,60.41 196.86,60.41 196.19,61.07 196.19,61.35 196.42,61.58 196.89,61.58
24780_BST on TOP (solid shape): 161.6,182.26 161.6,181.43 161.55,181.38 160.18,181.38 160.03,181.53 159.31,181.53 159.24,181.6 159.12,181.6 159.12,181.61 158.35,181.61 158.32,181.73 158.4,181.81 159.12,181.81 159.12,181.81 160.38,181.81 160.66,182.09 160.66,182.21 160.76,182.32 161.55,182.32
24780_DH on TOP (solid shape): 169.44,184.86 169.44,184.44 169.17,184.17 167.39,184.17 167.32,184.25 167.32,184.83 167.39,184.91 168.77,184.91 168.88,185.02 169.28,185.02
24780_DH on TOP (solid shape): 160.33,182.44 160.33,182.06 160.23,181.96 159.49,181.96 159.44,182.01 158.35,182.01 158.32,182.04 158.32,182.16 158.34,182.19 158.37,182.21 159.13,182.21 159.16,182.24 159.49,182.24 159.8,182.54 160.23,182.54
24780_DL on TOP (solid shape): 169.8,179.57 169.8,178.25 169.6,178.05 169.2,178.05 169.04,178.2 169.04,179.6 169.07,179.62 169.75,179.62
24780_DL on TOP (solid shape): 160.2,180.64 160.2,180.22 160.06,180.08 159.68,180.08 159.47,180.29 159.47,180.61 159.29,180.79 159.12,180.79 159.12,180.81 158.39,180.81 158.32,180.87 158.32,180.97 158.36,181.01 159.12,181.01 159.12,181.02 159.82,181.02
24780_LX on TOP (solid shape): 161.65,183.61 161.65,182.82 161.6,182.77 159.82,182.77 159.47,182.42 158.37,182.42 158.34,182.43 158.32,182.47 158.32,182.54 158.39,182.61 159.12,182.61 159.12,182.62 159.19,182.62 159.47,182.9 159.47,183.43 159.7,183.66 161.6,183.66
24780_LX on TOP (solid shape): 171.42,183.79 171.42,182.35 175.95,182.35 176.56,181.73 176.56,179.52 176.56,179.52 176.56,179.45 176.33,179.22 171.76,179.22 171.13,178.58 170.36,178.58 170.11,178.84 170.11,182.01 169.98,182.14 167.32,182.14 167.19,182.26 167.19,183.92 167.28,184 168.36,184 168.58,183.94 168.8,184 168.81,184 168.89,184 168.9,184.02 171.2,184.02
24780_LX on BOTTOM (solid shape): 176.51,183.59 176.51,180.23 176.23,179.95 170.54,179.95 170.11,180.39 170.11,182.57 169.86,182.82 168.94,182.82 168.76,183 168.76,183.92 169.2,184.35 175.75,184.35
51225_DH1 on TOP (solid shape): 51.66,37.64 51.69,37.62 51.71,37.59 51.71,36.84 51.72,36.84 51.72,36.65 51.11,36.04 50.96,36.04 50.76,36.24 50.76,36.49 51.42,37.15 51.42,37.56 51.49,37.64
51225_DH1 on BOTTOM (solid shape): 58.5,33.88 58.5,33.32 58.45,33.27 57.74,33.27 56.98,34.03 56.98,34.26 57.33,34.61 57.77,34.61
51225_DH2 on BOTTOM (solid shape): 62.9,42.77 62.9,41.22 62.42,40.74 62.15,40.74 62.08,40.81 62.08,41.41 62.11,41.44 62.11,42.77 62.12,42.8 62.16,42.82 62.85,42.82
51225_DL1 on TOP (solid shape): 50.51,38.03 51.26,38.03 51.3,38.02 51.31,37.98 51.31,37.87 51.3,37.83 51.26,37.82 51.21,37.82 51.21,37.8 49.8,36.39 49.42,36.39 49.33,36.49 49.33,36.92 50.45,38.04 50.51,38.04
51225_DL1 on BOTTOM (solid shape): 58.5,28.24 58.5,27.4 57.84,26.74 57.56,26.74 57.31,26.99 57.31,27.55 57.77,28.01 57.77,28.26 58.48,28.26
51225_DL2 on BOTTOM (solid shape): 59.95,50.01 59.95,49.17 59.9,49.12 58.88,49.12 58.32,49.68 58.32,50.06 58.43,50.16 59.8,50.16
51225_SW1 on TOP (solid shape): 52.46,37.64 52.49,37.62 52.51,37.59 52.51,36.82 52.59,36.74 52.59,36.72 52.61,36.72 52.63,36.7 52.63,33.65 52.3,33.32 51.42,33.32 51.36,33.37 51.36,34.28 51.47,34.39 51.69,34.39 51.99,34.68 51.99,35.47 52.3,35.78 52.3,36.84 52.3,36.84 52.3,37.59 52.32,37.62 52.36,37.64
51225_SW1 on BOTTOM (solid shape): 68.2,34.67 68.2,27.78 67.72,27.3 65.28,27.3 65.19,27.21 64.03,27.21 62.2,29.04 58.08,29.04 57.94,29.18 57.94,31.26 58.15,31.47 62.11,31.47 62.77,32.13 62.77,34.61 63.59,35.44 67.43,35.44
51225_SW2 on TOP (solid shape): 52.79,43.94 52.79,42.16 52.51,41.88 52.51,40.62 52.51,39.9 52.49,39.86 52.46,39.85 52.36,39.85 52.32,39.86 52.3,39.9 52.3,40.62 52.3,40.69 52.23,40.76 52.23,42.84 52,43.07 51.82,43.07 51.72,43.17 51.72,43.99 51.77,44.04 52.69,44.04
51225_SW2 on BOTTOM (solid shape): 66.91,50.08 66.91,42.98 66.01,42.08 63.8,42.08 63.46,42.43 63.46,42.71 63.14,43.02 62.11,43.02 62.06,43.07 62.06,45.31 60.92,46.45 60.56,46.45 60.46,46.55 60.46,50.03 60.81,50.39 66.6,50.39
51225_VBST1 on TOP (solid shape): 52.06,37.64 52.09,37.62 52.11,37.59 52.11,36.84 52.13,36.82 52.13,35.94 51.63,35.44 51.63,34.75 51.52,34.64 50.7,34.64 50.65,34.69 50.65,35.5 50.73,35.58 51.09,35.58 51.9,36.39 51.9,36.84 51.9,36.84 51.9,37.59 51.92,37.62 51.96,37.64
51225_VBST2 on TOP (solid shape): 52.1,42.49 52.1,40.71 52.1,39.85 52.08,39.82 51.96,39.82 51.92,39.84 51.9,39.87 51.9,40.62 51.9,40.62 51.9,40.69 51.84,40.75 51.84,40.79 51.82,40.81 51.82,40.93 51.61,41.14 51.61,41.54 51.45,41.7 51.03,41.7 50.96,41.78 50.96,42.56 51.03,42.64 51.95,42.64
+AZA_VDD on BOTTOM (solid shape): 200.53,49.73 200.72,49.68 200.91,49.73 201.24,49.73 201.43,49.53 201.43,49.42 201.43,49.41 201.41,49.3 201.43,49.18 201.43,49.17 201.43,48.78 201.42,48.72 201.41,48.66 201.41,48.5 201.13,48.22 201.13,46.63 201.24,46.53 201.25,46.52 201.52,46.24 201.97,46.24 202.14,46.07 202.14,45.85 201.97,45.69 200.9,45.69 200.79,45.8 200.79,45.82 200.66,46.06 200.41,46.19 200.4,46.19 200.22,46.37 200.22,47.36 199.93,47.65 199.93,47.93 199.95,48.03 199.93,48.12 199.93,48.32 199.93,48.33 199.93,48.58 199.94,48.62 199.98,48.63 199.99,48.63 199.99,49.63 200.09,49.73
+TPVDD on BOTTOM (solid shape): 133.05,12.85 133.05,11.32 132.92,11.2 132.16,11.2 132.04,11.32 132.04,12.85 132.42,13.23 132.67,13.23
+TPVDD on BOTTOM (solid shape): 132.47,17.19 132.47,16.28 132.67,16.07 132.67,15.21 132.42,14.96 131.55,14.96 131.1,15.41 131.1,17.14 131.25,17.29 132.37,17.29
+TPVDD on BOTTOM (solid shape): 118.77,19.12 118.77,18.92 118.76,18.87 118.76,18.83 118.76,18.18 118.76,18.14 118.77,18.05 118.77,18.03 118.84,17.87 119,17.8 119.02,17.8 119.23,17.6 119.23,15.72 119.15,15.64 117.51,15.64 117.38,15.77 117.38,17.07 117.5,17.19 117.5,19.14 117.63,19.27 118.62,19.27
+TPVDD on IN2 (solid shape): outline of 263 points within 117.23,12.34 140.39,17.75
+TYPEC_VBUS on TOP (solid shape): 21.27,112.36 21.27,110.84 21.14,110.71 19.23,110.71 19.03,110.51 16.9,110.51 16.64,110.76 16.64,112.14 17,112.49 21.14,112.49
+TYPEC_VBUS on TOP (solid shape): outline of 266 points within 5.77,115.08 11.11,121.69
+TYPEC_VBUS on BOTTOM (solid shape): 11.11,116.86 11.11,115.46 10.72,115.08 9.33,115.08 9.07,115.34 9.07,116.61 9.45,116.99 10.98,116.99
+TYPEC_VBUS on BOTTOM (solid shape): 9.45,121.32 9.47,121.31 9.48,121.3 9.66,121.13 9.67,121.12 9.69,121.11 10.92,121.11 10.94,121.11 10.96,121.1 11.09,120.96 11.1,120.95 11.11,120.93 11.11,120.6 11.11,118.28 11.1,118.26 11.09,118.24 11.01,118.16 10.99,118.15 10.97,118.14 9.46,118.14 9.44,118.15 9.42,118.16 9.12,118.46 9.11,118.47 9.09,118.47 8.27,118.47 8.25,118.48 8.23,118.49 8.21,118.51 6.78,118.51 6.73,118.56 6.73,118.77 6.76,118.8 7.81,118.8 7.81,118.8 8.2,118.8 8.21,118.82 8.23,118.82 8.25,118.82 8.48,118.85 8.65,119.02 8.66,119.03 8.69,119.07 8.71,119.08 8.73,119.08 9.11,119.08 9.13,119.09 9.15,119.1 9.38,119.33 9.39,119.34 9.39,119.36 9.39,119.71 9.39,119.71 9.39,120.1 9.39,120.13 9.41,120.16 9.44,120.18 9.47,120.17 10.08,120.54 9.38,120.66 9.31,120.61 9.22,120.64 9.15,120.72 9.13,120.73 9.11,120.73 8.76,120.73 8.76,120.73 8.68,120.73 8.66,120.74 8.64,120.76 8.53,120.9 8.38,120.97 8.35,120.98 8.3,121.04 8.29,121.05 8.29,121.07 8.29,121.27 8.3,121.3 8.34,121.32
+TYPEC_VBUS on IN2 (solid shape): outline of 742 points within 5.77,110.38 19.23,123.34
+TYPEC_VBUS_C on TOP (solid shape): 27.87,111.53 27.87,108.86 28.12,108.6 29.39,108.6 29.54,108.46 30.94,108.46 31.04,108.35 31.04,108.3 31.03,108.27 30.99,108.25 30.36,108.25 30.36,107.96 30.99,107.96 31.03,107.94 31.04,107.91 31.04,107.84 30.96,107.75 30.19,107.75 28.96,106.52 28.25,106.52 28.07,106.7 26.22,106.7 24.89,108.03 24.89,109.18 24.44,109.62 22.28,109.62 21.9,110 21.9,112.67 22.15,112.92 26.47,112.92
+VGPU_CORE on TOP (solid shape): 186.49,96.54 186.49,95.45 186.14,95.09 184.56,95.09 184.46,95.19 184.46,96.69 184.54,96.77 186.26,96.77
+VGPU_CORE on TOP (solid shape): 181.71,133.46 182.21,133.46 182.43,133.24 182.43,132.35 182.18,132.1 181.1,132.1 180.69,131.69 180.69,130.88 180.66,130.86 179.75,130.86 179.72,130.88 179.72,132.69 180.06,133.02 180.51,133.02 180.97,133.47 181.71,133.47
+VGPU_CORE on TOP (solid shape): 186.47,132.71 186.47,132.48 186.06,132.08 186.06,130.86 186.01,130.8 184.92,130.8 184.83,130.89 184.83,131.48 184.16,132.14 184.13,132.17 184.09,132.21 184.04,132.26 184.04,132.4 184.05,132.42 184.06,132.44 184.08,132.46 184.13,132.52 184.18,132.56 184.21,132.58 184.3,132.59 184.34,132.58 184.59,132.58 184.9,132.28 185.05,132.28 185.06,132.27 185.24,132.23 185.42,132.27 185.43,132.28 185.5,132.28 186.06,132.84 186.34,132.84
+VGPU_CORE on TOP (solid shape): outline of 251 points within 172.9,109.75 183.95,127.65
+VGPU_CORE on BOTTOM (solid shape): 208.72,101.62 208.72,86.48 208.18,85.95 182.28,85.95 181.84,86.38 181.84,89.61 182.97,90.74 183.84,90.74 184.46,91.36 184.46,97.66 185.73,98.93 185.73,100.76 185.76,100.78 185.76,101.87 186.65,102.76 206.3,102.76 206.31,102.71 206.32,102.65 206.34,102.6 206.37,102.55 206.4,102.51 206.44,102.47 206.49,102.44 206.54,102.41 206.59,102.39 206.64,102.38 206.7,102.38 206.76,102.39 206.81,102.4 206.86,102.42 206.91,102.45 206.95,102.49 206.99,102.53 207.02,102.58 207.04,102.63 207.06,102.68 207.07,102.73 207.07,102.79 207.06,102.85 207.04,102.9 207.02,102.95 206.99,103 206.95,103.04 206.91,103.07 206.86,103.1 206.81,103.12 206.76,103.14 206.7,103.14 206.64,103.14 206.59,103.13 206.54,103.11 206.49,103.09 206.44,103.06 206.4,103.02 206.37,102.97 206.34,102.92 206.32,102.87 206.31,102.82 206.3,102.76 186.65,102.76 186.72,102.84 196.86,102.84 197.41,103.4 206.94,103.4
+VGPU_CORE on BOTTOM (solid shape): outline of 5098 points within 174.33,109.75 188.93,139.28
+VGPU_CORE on IN1 (solid shape): outline of 2496 points within 174.58,109.37 187.91,137.7
+VGPU_CORE on SVCC (solid shape): outline of 456 points within 167.7,84.35 197.67,140.99
+VGPU_CORE on IN2 (solid shape): outline of 6291 points within 174.68,89.05 208.46,138.7
+WL_VDD on TOP (solid shape): 201.35,192.42 201.35,187.98 201.22,187.85 199.32,187.85 199.19,187.98 199.19,192.42 199.32,192.55 201.22,192.55
+WL_VDD on BOTTOM (solid shape): 201.48,192.3 201.48,188.36 201.22,188.11 199.95,188.11 199.7,188.36 199.7,190.9 199.5,191.1 197.8,191.1 197.8,191.15 197.8,191.15 197.8,191.35 197.8,191.4 199.35,191.4 199.35,191.6 197.8,191.6 197.8,191.65 197.8,192.42 197.92,192.55 201.22,192.55
+WL_VDD on BOTTOM (solid shape): 202.37,178.58 202.37,176.77 201.99,176.38 201.99,174.39 200.72,173.12 200.63,173.12 200.59,173.16 200.54,173.19 200.49,173.22 200.44,173.23 200.38,173.25 200.33,173.25 200.27,173.24 200.22,173.23 200.16,173.21 200.12,173.18 200.07,173.14 200.05,173.12 197.8,173.12 197.67,173.25 197.67,173.9 199.35,173.9 199.35,174.1 197.8,174.1 197.8,173.9 197.67,173.9 197.67,174.26 197.8,174.39 199.95,174.39 200.59,175.03 200.59,176.93 200.6,176.94 200.6,177.85 201.52,178.76 202.19,178.76
+WL_VDD on IN2 (solid shape): outline of 280 points within 199.07,176.42 202.75,191.41
ADOGND on SGND (solid shape): outline of 97 points within 196.91,9.93 212.53,44.98
ADOGND on SVCC (solid shape): outline of 97 points within 196.91,9.93 212.53,44.98
ADOGND on SGND1 (solid shape): outline of 97 points within 196.91,9.93 212.53,44.98
APS1 on TOP (solid shape): 164.9,100.73 164.9,99.97 164.78,99.84 162.49,99.84 162.36,99.97 162.36,100.73 162.49,100.86 164.78,100.86
APS3 on TOP (solid shape): 167.7,100.73 167.7,98.57 166.93,97.81 166.3,97.81 166.17,97.94 166.17,98.95 165.16,99.97 165.16,100.73 165.28,100.86 167.57,100.86
BAT-V on BOTTOM (solid shape): 168.15,176.63 168.15,173.32 167.34,172.51 165.26,172.51 164.7,171.95 163.18,171.95 162.85,171.62 158.55,171.62 158.2,171.98 158.17,171.98 158.04,172.1 158.04,175.71 158.4,176.07 159.16,176.07 159.19,176.09 159.23,176.09 161.68,176.09 161.96,176.37 163.28,176.37 163.29,176.36 164.19,176.36 164.24,176.31 166.69,176.31 167.06,176.68 168.1,176.68
CCD_PWR on TOP (solid shape): 118.23,169.86 118.23,169.85 118.3,169.75 118.4,169.68 118.41,169.68 118.8,169.29 119.21,169.29 119.31,169.18 119.31,168.35 119.29,168.33 118.27,168.33 118.14,168.21 118.14,168.19 116.49,168.19 116.36,168.32 116.36,168.63 116.4,168.66 116.4,169.2 116.64,169.44 117.18,169.44 117.67,169.93 118.15,169.93
CCD_PWR on BOTTOM (solid shape): 118.6,169.43 118.6,169.34 119.43,168.52 119.25,168.34 118.44,169.15 118.27,168.97 119.08,168.16 118.9,167.98 118.05,168.83 117.53,168.83 117.4,168.96 117.4,169.23 118.06,169.89 118.15,169.89
CFG_RCOMP on TOP (solid shape): 107.66,128.77 107.66,128.41 106.87,127.62 106.87,127.37 106.71,127.21 106.5,127.21 106.37,127.35 106.37,127.85 106.36,127.89 106.36,128.17 106.39,128.24 106.46,128.27 106.65,128.27 107.09,128.71 107.09,128.78 107.23,128.92 107.51,128.92
CRTVDD5 on TOP (solid shape): 13.26,83.79 13.26,83.1 13.23,83.06 13.18,83.07 13.16,83.08 11.33,83.08 11.07,82.82 9.58,82.82 9.45,82.95 9.45,83.84 9.58,83.97 13.08,83.97
CRTVDD5 on BOTTOM (solid shape): 12.38,84.86 12.38,84.22 12.88,83.71 13.65,83.71 14.28,83.08 14.28,80.28 14.15,80.16 13.65,80.16 13.57,80.24 13.55,80.26 13.55,80.28 13.57,80.46 13.52,80.63 13.52,80.64 13.52,82.21 13.52,82.22 13.47,82.76 13,83.01 12.52,83.01 12.34,82.82 9.58,82.82 9.45,82.95 9.45,83.7 9.78,84.02 10.15,84.12 10.25,84.49 10.87,85.11 12.12,85.11
CRTVDD5 on IN3 (solid shape): outline of 232 points within 7.68,79.39 13.26,83.97
DDI2_AUXP on TOP (solid shape): 98.6,127.76 98.6,127.72 98.57,127.69 98.57,127.2 98.38,127.01 97.59,127.01 97.49,127.11 97.49,127.43 98.1,128.04 98.6,128.04
DDR_VTTREF on TOP (solid shape): 42.33,58.99 43.76,58.99 44.06,58.68 44.06,57.7 44.05,57.67 44.01,57.65 43.82,57.65 43.69,57.78 43.69,58.03 43.44,58.29 42.7,58.29 42.45,58.03 42.45,57.22 42.6,57.07 42.67,57.07 42.67,57.06 43.65,57.06 43.67,57.04 43.67,56.92 43.65,56.88 43.62,56.87 42.37,56.87 41.15,58.08 41.15,59.02 41.28,59.15 42.17,59.15
DDR_VTTREF on TOP (solid shape): outline of 256 points within 143.95,39.64 149.41,57.68
DDR_VTTREF on IN1 (solid shape): 42.47,59.2 42.47,57.7 42.27,57.5 41.08,57.5 40.9,57.32 40.9,55.39 39.68,55.39 39.45,55.63 39.45,58.59 40.19,59.33 42.35,59.33
DDR_VTTREF on IN1 (solid shape): 78.65,48 78.68,47.99 79.14,47.53 79.14,47.19 83.1,43.23 83.1,42.18 82.26,41.34 81.41,41.34 76.76,45.99 78.07,45.99 78.07,45.94 78.08,45.89 78.1,45.84 78.13,45.79 78.16,45.75 78.2,45.72 78.25,45.68 78.29,45.66 78.35,45.65 78.4,45.64 78.45,45.64 78.5,45.65 78.55,45.66 78.6,45.68 78.65,45.72 78.69,45.75 78.72,45.79 78.75,45.84 78.77,45.89 78.78,45.94 78.78,45.99 78.78,46.05 78.77,46.1 78.75,46.15 78.72,46.19 78.69,46.24 78.65,46.27 78.6,46.3 78.55,46.33 78.5,46.34 78.45,46.35 78.4,46.35 78.35,46.34 78.29,46.33 78.25,46.3 78.2,46.27 78.16,46.24 78.13,46.19 78.1,46.15 78.08,46.1 78.07,46.05 78.07,45.99 76.76,45.99 76.58,46.17 76.58,48.03 76.9,48.34 78.31,48.34
DDR_VTTREF on IN3 (solid shape): outline of 1234 points within 80.51,37.01 149.65,43.29
EC_GND on BOTTOM (solid shape): 175.7,45.5 175.7,44.7 176.19,44.22 176.19,43.92 176.08,43.81 176.08,42.3 175.88,42.3 175.88,43.98 175.68,44.18 175.52,44.18 175.26,44.44 175.26,44.45 175.22,44.5 175.22,44.62 175.01,44.83 175.01,45.45 175.11,45.54 175.66,45.54
ECAGND on BOTTOM (solid shape): 170.08,34.19 170.11,34.15 170.62,33.64 170.62,33.14 170.66,33.1 172.28,33.1 172.28,32.9 170.78,32.9 170.25,32.9 170.01,32.65 169.28,32.65 169.26,32.65 169.24,32.66 169.09,32.81 169.09,33.33 169.07,33.35 169.07,33.37 169.07,33.42 168.68,33.8 167.06,33.8 166.3,33.04 166.3,31.97 166.3,31.96 166.28,31.94 166.17,31.71 166.23,31.47 166.25,31.43 166.29,31.39 166.3,31.35 166.3,31.18 166.13,31.01 166.13,29.56 166.53,29.17 166.62,29.17 166.68,29.1 168.33,29.1 168.59,28.85 168.59,27.71 168.49,27.61 168.46,27.6 168.43,27.61 168.18,27.68 167.94,27.58 167.67,27.58 167.44,27.66 167.21,27.58 166.55,27.58 166.3,27.83 166.3,28.34 165.41,29.23 165.41,33.42 166.55,34.56 169.7,34.56
EVDD10 on TOP (solid shape): 31.68,72.16 33.08,72.16 33.33,71.9 33.33,71.79 33.2,71.66 32.34,71.66 31.79,71.12 31.45,71.12 31.33,71.23 31.33,71.25 31.06,71.52 30.56,71.52 30.53,71.53 30.52,71.55 30.39,71.7 30.2,71.77 30.17,71.79 30.16,71.82 30.16,72.54 30.25,72.63 31.2,72.63 31.2,72.64
FB_PLLAVDD on TOP (solid shape): 183.57,139.59 183.57,139.21 183.44,139.08 182.96,139.08 182.71,138.83 182.71,136.77 182.33,136.39 181.79,136.39 181.67,136.52 181.67,137.77 181.67,137.94 181.41,138.2 181.41,138.52 181.82,138.52 181.82,138.47 181.83,138.41 181.85,138.36 181.88,138.31 181.92,138.27 181.96,138.23 182,138.2 182.05,138.17 182.1,138.15 182.16,138.14 182.21,138.14 182.27,138.15 182.32,138.16 182.37,138.18 182.42,138.21 182.46,138.25 182.5,138.29 182.53,138.33 182.56,138.38 182.57,138.44 182.58,138.49 182.58,138.55 182.57,138.6 182.56,138.66 182.53,138.71 182.5,138.75 182.46,138.8 182.42,138.83 182.37,138.86 182.32,138.88 182.27,138.9 182.21,138.9 182.16,138.9 182.1,138.89 182.05,138.87 182,138.85 181.96,138.81 181.92,138.78 181.88,138.73 181.85,138.68 181.83,138.63 181.82,138.58 181.82,138.52 181.41,138.52 181.41,139.29 181.41,139.29 181.41,139.58 181.58,139.74 181.6,139.75 181.64,139.79 181.68,139.83 181.71,139.87 181.74,139.92 181.76,139.98 181.77,140.02 182.05,140.3 182.87,140.3
FBA_DEBUG1 on TOP (solid shape): 178.32,145.54 178.9,145.54 178.97,145.51 179,145.44 179,145.16 178.97,145.09 178.9,145.06 178.6,145.06 178.18,144.65 178.18,144.64 177.87,144.64 177.72,144.8 177.72,145.62 177.78,145.69 178.17,145.69
G5335-BST on BOTTOM (solid shape): 218.22,173.4 217.42,173.4 217.42,173.37 217,173.37 216.85,173.22 216.64,173.22 216.16,172.74 215.3,172.74 215.22,172.82 215.22,173.6 215.27,173.65 218.22,173.65
G5335-BST-1 on BOTTOM (solid shape): 68.94,75.86 68.94,75.1 68.84,75 67.29,75 67.09,75.2 66.71,75.2 66.69,75.23 65.89,75.23 65.89,75.48 66.69,75.48 66.69,75.48 67.39,75.48 67.87,75.97 68.84,75.97
G5335-LX on BOTTOM (solid shape): 221.34,173.17 221.42,173.17 221.42,173.16 222.24,173.16 222.46,172.94 222.46,172.69 222.46,172.39 222.38,172.31 221.37,172.31 221.29,172.38 219.39,172.38 219.31,172.31 219.28,172.31 219.28,172.28 219.21,172.21 219.21,172.17 219.19,172.17 219.19,171.39 219.21,171.39 219.21,170.38 219.46,170.12 222.33,170.12 222.66,169.79 222.66,166.82 222.51,166.67 217.15,166.67 217.13,166.64 216.21,166.64 215.8,167.05 215.8,170 215.27,170.53 215.27,171.39 218.94,171.39 218.94,172.17 218.69,172.17 218.69,171.39 215.27,171.39 215.27,172.36 215.35,172.44 216.13,172.44 216.34,172.23 216.95,172.23 217.37,172.66 222.21,172.66 222.21,172.9 221.42,172.9 221.42,172.66 218.21,172.66 218.21,172.69 218.45,172.69 218.52,172.77 218.52,173.4 221.11,173.4
G5335-LX-1 on BOTTOM (solid shape): 66.91,85.26 66.91,81.02 66.93,81 66.93,78.81 67.14,78.61 67.14,76.52 66.83,76.22 66.69,76.22 66.69,76.23 65.9,76.23 65.78,76.11 65.77,76.1 65.59,75.92 65.59,75.53 65.56,75.51 62.97,75.51 62.76,75.73 61.64,75.73 61.38,75.98 62.69,75.98 62.69,76.23 61.9,76.23 61.9,75.98 61.38,75.98 60.13,77.24 60.13,79.78 62.26,79.78 62.26,77.08 62.87,76.47 64.73,76.47 64.92,76.66 64.92,76.71 65.42,76.71 65.42,77.5 65.17,77.5 65.17,76.71 64.92,76.71 64.92,77.5 64.88,77.53 64.88,79.63 64.45,80.06 62.53,80.06 62.26,79.78 60.13,79.78 60.13,85.34 60.41,85.62 66.55,85.62
G5335-VCC on BOTTOM (solid shape): 216.46,174.96 216.55,174.81 216.7,174.71 217.23,174.19 217.42,174.19 217.42,174.16 218.19,174.16 218.19,173.9 217.42,173.9 217.42,173.88 216.69,173.88 216.52,174.06 215.35,174.06 215.27,174.14 215.27,175.03 215.32,175.08 216.34,175.08
G5335-VCC-1 on BOTTOM (solid shape): 67.27,74.72 68.66,74.72 68.76,74.62 68.76,73.71 68.66,73.6 67.75,73.6 66.81,74.54 66.81,74.61 66.69,74.73 66.63,74.73 66.6,74.75 65.89,74.75 65.89,74.98 66.69,74.98 66.71,75 66.99,75
G5719LX2.5V on BOTTOM (solid shape): 166.45,48.18 166.45,45.94 165.79,45.28 165.25,45.28 164.82,45.71 163.45,45.71 163.25,45.92 163.25,48.31 163.35,48.41 166.22,48.41
HDMI_5V on TOP (solid shape): 18.34,57.42 18.34,56.28 17.33,55.26 15.8,55.26 14.66,54.12 11.36,54.12 11.29,54.19 11.29,55.32 11.74,55.77 13.26,55.77 14.15,56.66 16.31,56.66 16.57,56.92 16.57,57.42 16.69,57.55 18.22,57.55
ISL95857_COMP_B on BOTTOM (solid shape): 137.52,172.18 137.52,171.37 137.29,171.14 136.76,171.14 136.69,171.17 136.66,171.24 136.66,171.34 136.4,171.6 136.4,172.18 136.57,172.35 137.36,172.35
L_SPK+ on TOP (solid shape): 76.26,11.45 76.26,10.69 76.13,10.56 74.35,10.56 74.1,10.81 74.1,11.45 74.22,11.58 76.13,11.58
L_SPK+ on IN3 (solid shape): 77.53,10.56 77.4,10.43 74.1,10.43 73.97,10.56 73.97,11.45 74.1,11.58 77.53,11.58
L_SPK+ on IN3 (solid shape): 197.8,42.18 199.83,42.18 199.95,42.06 199.95,41.55 199.7,41.29 196.4,41.29 196.14,41.55 196.14,42.06 196.4,42.31 197.67,42.31
L_SPK+_1 on TOP (solid shape): 79.56,11.45 79.56,10.81 79.3,10.56 76.76,10.56 76.67,10.65 76.67,11.49 76.76,11.58 79.43,11.58
L_SPK+_1 on BOTTOM (solid shape): 78.8,10.84 78.8,10.66 78.92,10.54 80.52,10.54 80.57,10.48 80.57,9.72 80.5,9.65 78.7,9.65 77.65,10.69 77.65,11.45 77.78,11.58 78.06,11.58
L_SPK- on TOP (solid shape): 76.26,12.72 76.26,11.96 76.13,11.83 74.22,11.83 74.1,11.96 74.1,12.72 74.22,12.85 76.13,12.85
L_SPK- on IN3 (solid shape): 76.38,12.85 76.38,12.08 76.13,11.83 74.1,11.83 73.97,11.96 73.97,12.85 74.1,12.97 76.26,12.97
L_SPK- on IN3 (solid shape): 198.43,42.95 199.83,42.95 199.95,42.82 199.95,42.56 199.83,42.44 197.8,42.44 197.53,42.7 197.53,42.72 197.42,42.95 197.19,43.06 197.17,43.06 197.16,43.07 196.14,43.07 195.89,43.33 195.89,43.96 196.02,44.09 197.29,44.09
L_SPK-_1 on TOP (solid shape): 79.56,12.72 79.56,12.08 79.3,11.83 76.76,11.83 76.67,11.92 76.67,12.76 76.76,12.85 79.43,12.85
L_SPK-_1 on BOTTOM (solid shape): 78.75,12.14 78.75,12.01 78.97,11.78 80.5,11.78 80.57,11.7 80.57,10.99 80.47,10.89 78.97,10.89 78.03,11.83 77.78,11.83 77.65,11.96 77.65,12.72 77.78,12.85 78.03,12.85
LAN_MCT0 on TOP (solid shape): 24.25,89.41 24.25,87.76 24.01,87.52 22.94,87.52 22.33,88.13 22.33,89.28 23.01,89.96 23.69,89.96
LAN_MCT1 on TOP (solid shape): 24.23,86.41 24.23,84.97 23.98,84.73 22.91,84.73 22.31,85.33 22.31,86.19 22.75,86.62 24.02,86.62
LAN_MCT2 on TOP (solid shape): 24.25,83.23 24.25,81.72 24.11,81.58 22.91,81.58 22.34,82.15 22.34,83.01 22.77,83.45 24.04,83.45
LAN_MCT3 on TOP (solid shape): 24.23,80.21 24.23,78.73 24.06,78.56 22.89,78.56 22.31,79.13 22.31,79.57 23.17,80.42 24.02,80.42
LANVCC on TOP (solid shape): 45.01,82.32 45.01,80.92 44.89,80.79 43.62,80.79 43.24,81.17 41.2,81.17 40.82,81.55 40.82,82.82 41.33,83.33 44,83.33
LANVCC on TOP (solid shape): 37.69,66.61 37.75,66.62 37.78,66.58 37.78,66.55 38.53,66.55 38.55,66.56 38.66,66.44 38.66,65.7 38.66,64.03 38.79,63.9 38.79,63.77 39.03,63.42 39.44,63.5 39.46,63.52 39.48,63.52 39.92,63.52 39.95,63.51 39.97,63.49 40.32,63.27 40.66,63.49 40.67,63.5 40.7,63.52 41.08,63.9 41.08,64.79 41.42,65.14 42.65,65.14 42.65,65.14 42.68,65.17 42.73,65.17 42.86,65.3 42.86,65.81 43.36,66.31 45.01,66.31 45.14,66.19 45.14,63.22 45.05,63.13 44.42,63.13 43.67,62.38 38.41,62.38 37.39,63.39 37.39,65.59 37.42,65.62 37.42,66.34
LANVCC on TOP (solid shape): 41.59,78.38 41.59,78.35 41.66,78.2 41.81,78.13 41.84,78.13 42.09,77.87 42.09,76.28 41.75,75.94 41.75,74.97 41.6,74.81 41.58,74.79 41.56,74.78 41.54,74.77 40.49,74.77 40.44,74.82 40.44,75.91 40.5,76 40.61,75.99 41.13,76.09 40.96,76.6 40.9,76.65 40.9,76.73 40.84,77.08 40.5,77.2 40.48,77.21 40.46,77.22 40.19,77.49 40.19,78.63 40.29,78.73 41.23,78.73
LANVCC on TOP (solid shape): 36.25,78.25 36.25,77.51 36.24,77.48 36.2,77.46 36.15,77.46 36.11,77.45 36.03,77.46 35.98,77.52 35.28,77.59 35.73,77.05 35.81,77.04 35.86,76.99 35.95,76.84 36.1,76.76 36.13,76.74 36.14,76.71 36.25,76.59 36.25,76.32 36.2,76.27 36.2,75.25 36.18,75.23 36.05,75.23 36.02,75.24 36,75.28 36,76.26 36,76.26 36,76.32 35.88,76.44 34.89,76.44 34.09,77.24 34.09,78.25 34.22,78.38 36.12,78.38
LANVCC on IN2 (solid shape): outline of 133 points within 41.46,65.45 44,82.44
LCDVCC on TOP (solid shape): 115.12,162.45 115.12,161.56 116.01,160.67 117.28,160.67 117.37,160.59 117.37,159.68 117.21,159.53 114.5,159.53 114.49,159.54 113.98,159.54 112.96,160.55 112.96,162.58 113.05,162.67 114.9,162.67
LCDVCC on BOTTOM (solid shape): 112.07,161.06 115.63,161.06 116.01,160.67 117.15,160.67 117.28,160.55 117.28,159.74 117.07,159.53 115.88,159.53 115.37,160.04 111.05,160.04 110.93,160.17 110.93,160.93 111.31,161.31 111.82,161.31
LCDVCC_R on TOP (solid shape): 119.56,166.52 119.56,165.37 119.18,164.99 116.26,164.99 115.25,163.98 115.25,163.34 115.12,163.21 113.34,163.21 112.96,163.6 112.96,165.37 113.76,166.17 113.79,166.18 113.8,166.18 114.4,166.2 114.84,166.61 114.86,166.64 114.89,166.64 119.44,166.64
LCDVCC_R on BOTTOM (solid shape): 117.88,168.58 117.92,168.6 117.95,168.58 119.42,167.11 119.43,167.09 119.44,167.08 119.44,165.65 119.43,165.63 119.42,165.61 119.32,165.52 119.31,165.5 119.29,165.5 117.93,165.5 117.91,165.5 117.9,165.52 117.8,165.61 117.79,165.63 117.79,165.65 117.79,166.21 117.84,166.26 117.84,166.92 117.06,167.7 117.05,167.73 117.06,167.77 117.17,167.88 117.21,167.89 117.24,167.88 117.98,167.14 118.02,167.12 118.05,167.14 118.15,167.24 118.17,167.28 118.15,167.31 117.42,168.05 117.4,168.09 117.42,168.12 117.53,168.23 117.56,168.24 117.6,168.23 118.33,167.49 118.37,167.48 118.41,167.49 118.51,167.59 118.52,167.63 118.51,167.67 117.77,168.4 117.76,168.44 117.77,168.47
PD# on BOTTOM (solid shape): 193.24,44.86 196.67,44.86 196.78,44.75 196.78,44.49 196.78,44.43 196.77,44.41 196.44,44.09 190.19,44.09 189.99,44.29 189.99,45.34 190,45.37 190.04,45.39 192.71,45.39
PEX_PLLVDD on TOP (solid shape): 175.7,140.1 175.7,138.7 175.44,138.45 174.94,138.45 174.3,139.08 174.3,140.1 174.43,140.23 175.57,140.23
PEX_PLLVDD on BOTTOM (solid shape): 164.65,145.94 164.65,144.67 164.14,144.16 163.38,144.16 163.12,144.42 163.12,144.93 163,145.05 163,145.26 163.03,145.28 163.03,146.4 163.05,146.44 163.08,146.45 164.14,146.45
PEX_PLLVDD on IN1 (solid shape): outline of 266 points within 163.51,138.7 175.06,145.56
PLLVDD on TOP (solid shape): 176.71,124.86 176.71,123.97 176.46,123.72 175.06,123.72 174.55,124.23 174.55,125.11 174.81,125.37 176.21,125.37
POA_PWR on TOP (solid shape): 113.59,35.07 113.59,34.44 112.96,33.8 112.96,32.79 112.83,32.66 111.82,32.66 111.44,32.28 111.44,30.75 111.18,30.5 109.4,30.5 109.15,30.75 109.15,33.29 109.28,33.42 110.17,33.42 110.42,33.67 110.42,34.06 110.8,34.44 111.82,34.44 112.58,35.2 113.47,35.2
R_SPK+ on TOP (solid shape): 75.11,15.39 76.13,15.39 76.35,15.17 76.35,14.46 76.26,14.37 74.73,14.37 73.72,15.39 72.99,15.39 72.83,15.55 72.83,16.28 72.95,16.4 74.1,16.4
R_SPK+ on IN3 (solid shape): 73.97,17.23 73.97,15.58 73.84,15.45 72.83,15.45 72.7,15.58 72.7,17.23 72.83,17.36 73.84,17.36
R_SPK+ on IN3 (solid shape): 199.95,45.49 199.95,44.22 199.83,44.09 198.81,44.09 198.68,44.22 198.68,45.74 198.94,45.99 199.45,45.99
R_SPK+_1 on TOP (solid shape): 79.56,15.26 79.56,14.5 79.43,14.37 76.76,14.37 76.67,14.46 76.67,15.3 76.76,15.39 79.43,15.39
R_SPK+_1 on BOTTOM (solid shape): 78.83,14.75 78.83,14.47 79.03,14.27 80.52,14.27 80.7,14.09 80.7,13.66 80.52,13.48 78.9,13.48 77.65,14.73 77.65,14.98 77.81,15.14 78.44,15.14
R_SPK- on TOP (solid shape): 74.64,14.12 76.26,14.12 76.35,14.03 76.35,13.19 76.26,13.1 74.22,13.1 73.97,13.35 73.97,14.21 74.13,14.36 74.39,14.36
R_SPK- on IN3 (solid shape): 75.24,15.26 75.24,13.48 75.11,13.35 74.22,13.35 74.1,13.48 74.1,15.26 74.22,15.39 75.11,15.39
R_SPK- on IN3 (solid shape): 198.43,45.39 198.43,44.22 198.81,43.83 199.83,43.83 199.95,43.71 199.95,43.33 199.83,43.2 198.56,43.2 197.54,44.22 197.54,44.32 197.55,44.33 197.57,44.47 197.55,44.61 197.54,44.62 197.54,44.79 196.72,45.62 196.72,45.87 197.2,46.35 197.46,46.35
R_SPK-_1 on TOP (solid shape): 79.56,13.99 79.56,13.35 79.3,13.1 76.76,13.1 76.67,13.19 76.67,14.03 76.76,14.12 79.43,14.12
R_SPK-_1 on BOTTOM (solid shape): 79.13,13.02 80.5,13.02 80.5,12.24 80.47,12.21 78.9,12.21 78.01,13.1 77.78,13.1 77.65,13.23 77.65,13.99 77.78,14.12 78.03,14.12
REGOUT on TOP (solid shape): 40.38,70.24 41.33,70.24 41.95,69.62 43.22,69.62 43.47,69.37 43.47,68.72 43.62,68.57 44.02,68.57 44.25,68.35 44.25,66.82 44.13,66.69 42.86,66.69 42.6,66.95 42.6,67.03 42.62,67.06 42.7,67.47 42.37,67.71 42.35,67.71 42.09,67.96 41.46,67.96 40.7,68.73 40.32,68.73 40.01,69.03 40.01,70.15 40.1,70.24 40.38,70.24
RING2 on BOTTOM (solid shape): 204.81,26.72 204.81,24.68 204.68,24.56 203.92,24.56 203.79,24.68 203.79,25.93 204.02,26.16 204.02,26.69 204.17,26.84 204.68,26.84
RING2 on IN1 (solid shape): 204.53,27.96 204.53,26.44 204.65,26.31 204.65,24.81 204.4,24.56 203.92,24.56 203.51,24.96 203.51,28.09 203.64,28.21 204.27,28.21
RING2 on IN1 (solid shape): 210.24,44.22 210.24,43.33 210,43.08 208.6,43.08 208.59,43.07 208.34,42.82 208.34,40.91 208.21,40.79 207.45,40.79 207.32,40.91 207.32,43.96 207.7,44.34 210.11,44.34
RING2_R on BOTTOM (solid shape): 205.16,24.02 205.16,22.63 205.03,22.5 204.02,22.5 203.89,22.63 203.89,24.02 204.02,24.15 205.03,24.15
RING2_R on BOTTOM (solid shape): 210.4,13.8 211.42,13.8 211.59,13.63 211.59,13.55 211.57,13.51 211.54,13.5 210.4,13.5 210.4,13.3 211.54,13.3 211.57,13.29 211.59,13.25 211.59,13.05 211.57,13.01 211.54,13 210.4,13 210.4,12.8 211.54,12.8 211.57,12.79 211.59,12.75 211.59,12.57 211.52,12.5 210.4,12.5 210.4,12.49 210.14,12.49 210.06,12.42 209.02,12.42 208.72,12.72 208.72,13.48 208.9,13.66 209.81,13.66 209.96,13.81 210.4,13.81
RING2_R on IN1 (solid shape): 205.16,23.51 205.16,21.86 204.91,21.61 204.02,21.61 203.89,21.74 203.89,23.13 204.4,23.64 205.03,23.64
RING2_R on IN1 (solid shape): 209.99,13.48 209.99,12.59 209.86,12.47 208.21,12.47 208.08,12.59 208.08,13.48 208.21,13.61 209.86,13.61
SLEEVE on BOTTOM (solid shape): 206.3,26.69 206.3,24.66 206.18,24.53 205.42,24.53 205.16,24.78 205.16,26.69 205.29,26.82 206.18,26.82
SLEEVE on IN1 (solid shape): 210.62,41.93 210.62,41.04 210.5,40.91 209.73,40.91 208.72,41.93 208.72,42.58 208.88,42.74 209.81,42.74
