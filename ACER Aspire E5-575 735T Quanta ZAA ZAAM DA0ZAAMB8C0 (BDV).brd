# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TX5+: length 4.4
  BOTTOM w0.076: U35.A23 127.26,123.59 127.16,123.59 127.09,123.66 127.09,125.05 127.22,125.17 127.22,126.2 127.27,126.25 127.27,126.26
  BOTTOM w0.127: 127.27,126.26 127.27,127.02 127.38,127.14 C669.1
PCIE_TX5+_LAN: length 167.6
  TOP w0.127: v1(30.69,71.01) 30.97,70.73 31.93,70.73 32.49,71.29 33.35,71.29 33.65,71.59 34.03,71.59 34.1,71.66 U15.21
  IN1 w0.089: v1(127.25,128.66) 127.25,128.73 126.87,129.1 125.85,129.1 124.88,130.07 122.04,130.07 114.93,137.18 104.94,137.18 104.13,137.99 96.12,137.99 94.54,136.42 94.54,136.42 90.23,132.1 87.19,132.1 70.37,115.27 48.76,115.27 41.78,122.26 38.6,122.26 37.32,120.97 37.32,115.24 35.81,113.73 35.81,106.64 31.53,102.36 31.53,75.48 30.18,74.14 30.18,72.31 29.75,71.88 29.75,70.77 30.08,70.44 30.31,70.44 30.69,70.82 v1(30.69,71.01)
  BOTTOM w0.127: C669.2 127.56,127.66 127.42,127.66 127.25,127.84 v1(127.25,128.66)
PCIE_TX5-: length 4.4
  BOTTOM w0.076: 127.01,126.26 127.01,126.25 127.06,126.2 127.06,125.24 126.93,125.11 126.93,123.59 127.38,123.14 U35.B23
  BOTTOM w0.127: C668.1 127.01,126.93 127.01,126.26
PCIE_TX5-_LAN: length 167.6
  TOP w0.127: v1(30.69,70.25) 30.92,70.48 32.04,70.48 32.59,71.04 33.46,71.04 33.76,71.34 34.03,71.34 34.1,71.26 U15.22
  IN1 w0.089: v1(127.25,129.29) 125.93,129.29 124.96,130.26 122.12,130.26 115,137.37 105.02,137.37 104.21,138.18 96.04,138.18 94.47,136.61 90.15,132.29 87.12,132.29 70.29,115.46 48.84,115.46 41.86,122.45 38.52,122.45 37.13,121.05 37.13,115.32 35.62,113.81 35.62,106.72 31.34,102.44 31.34,75.56 29.99,74.22 29.99,72.39 29.56,71.96 29.56,70.7 30,70.25 v1(30.69,70.25)
  BOTTOM w0.127: C668.2 126.8,128.85 v1(127.25,129.29)
PCIE_TX6+: length 9
  BOTTOM w0.076: U35.C23 127.33,122.41 127.22,122.52 127.22,122.64 127.31,122.72 127.52,122.72 127.58,122.79 127.65,122.99 127.65,123.18 127.6,123.33 127.6,123.49 127.64,123.57 127.65,123.59 127.65,123.87 127.44,124.08 127.44,125.98 127.55,126.1 127.55,126.16 127.56,126.17
  BOTTOM w0.127: C649.1 127.76,130.06 128.33,129.49 128.33,126.94 127.56,126.17
PCIE_TX6+_WLAN: length 109.4
  IN3 w0.114: v1(127.56,131.72) 127.67,131.82 127.67,132.3 131.53,136.16 141.92,136.16 142.32,135.76 147.15,135.76 155.86,144.46 155.86,156.56 159.96,160.66 159.96,163.81 161.36,165.2 161.36,171.1 163.54,173.27 180.93,173.27 181.41,173.76 187.72,173.76 192.36,178.4 192.36,179.24 195.51,182.39 195.89,182.39 v1(196.02,182.52)
  BOTTOM w0.127: CN10.35 191.95,183.5 192.08,183.38 194,183.38 195,182.37 195.87,182.37 v1(196.02,182.52) ; C649.2 127.44,131.59 v1(127.56,131.72)
PCIE_TX6-: length 9.1
  BOTTOM w0.076: U35.D23 127.38,121.99 127.72,122.33 127.72,122.68 127.73,122.7 127.82,122.96 127.82,123.21 127.77,123.36 127.77,123.45 127.79,123.5 127.81,123.56 127.81,123.94 127.6,124.15 127.6,125.91 127.67,125.98 127.73,125.98 127.74,125.99
  BOTTOM w0.127: 127.74,125.99 127.83,126.08 127.83,126.08 128.58,126.83 128.58,129.59 128.45,129.72 C648.1
PCIE_TX6-_WLAN: length 109.4
  IN3 w0.114: v1(196.02,181.88) 196.02,181.93 195.8,182.15 195.59,182.15 192.59,179.15 192.59,178.3 187.81,173.53 181.51,173.53 181.02,173.04 163.63,173.04 161.59,171 161.59,165.11 160.19,163.71 160.19,160.56 156.09,156.46 156.09,144.37 147.25,135.53 142.23,135.53 141.82,135.94 131.63,135.94 127.89,132.2 127.89,132 128.17,131.72 v1(128.33,131.72)
  BOTTOM w0.127: v1(196.02,181.88) 195.79,182.12 194.9,182.12 193.89,183.12 192.07,183.12 191.94,183 CN10.37 ; C648.2 128.45,131.59 v1(128.33,131.72)
PCLK_TPM: length 45.1
  IN1 w0.089: v1(164.52,84.78) 164.52,84.6 163.68,83.76 163.68,78.46 166.22,75.92 166.22,74.45 v1(166.69,73.98)
  BOTTOM w0.127: U44.19 v1(166.69,73.98) ; R626.1 151.14,100.3 152,100.3 152.58,99.71 152.58,97.4 151.95,96.77 151.95,95.78 152.46,95.27 152.46,89.3 151.95,88.79 151.95,87.27 152.2,87.01 152.71,87.01 153.79,85.94 157.09,85.94 158.93,87.78 160.46,87.78 161.35,86.89 161.35,84.86 161.68,84.53 164.27,84.53 v1(164.52,84.78)
PD#: length 7.5
  TOP w0.203: v1(196.5,44.47) v1(197.37,45.34) 198.28,46.25 v1(199.8,46.25)
  BOTTOM w0.203: U23.47 201.13,43.98 200.84,44.27 200.84,44.39 199.73,45.51 199.73,46.17 v1(199.8,46.25)
PEG_RX0: length 30.8
  TOP w0.127: v1(160.33,123.94) 160.88,123.94 C4015.1
  IN3 w0.076: v3(134.04,120.04) 134.14,119.94 134.29,119.94 134.42,120.07 134.42,121.57 134.7,121.85 135.15,121.85
  IN3 w0.114: v1(160.33,123.94) 159.92,123.54 159.5,123.54 159.01,124.02 155.81,124.02 155.53,123.74 147.21,123.74 147.05,123.59 143.69,123.59 143.21,123.11 137.5,123.11 136.35,121.96 135.31,121.96 135.2,121.85 135.15,121.85
  BOTTOM w0.127: U35.G13 133.93,120.04 v3(134.04,120.04)
PEG_RX1: length 34.1
  TOP w0.127: C4017.1 164.74,124.71 164.54,124.71 162.41,122.57 161.35,122.57 160.97,122.19 159.95,122.19 159.19,122.96 157.28,122.96 v1(157.03,123.21)
  IN3 w0.114: v1(157.03,123.21) 156.75,122.93 153.69,122.93 153.31,122.55 146.77,122.55 146.55,122.32 144.91,122.32 144.28,121.69 139.7,121.69 139.37,122.02 138.49,122.02 137.68,121.2 137.34,121.2 137.06,120.92 136.39,120.92 135.37,119.91 135.1,119.91 v3(134.98,120.03)
  BOTTOM w0.127: U35.F11 134.81,120.03 v3(134.98,120.03)
PEG_RX2: length 34.6
  TOP w0.127: C4020.1 160.88,126.18 160.41,126.18 v1(160.33,126.26)
  IN3 w0.076: v3(132.24,119.95) 132.31,119.87 132.46,119.87 132.57,119.98 132.57,122.41 132.53,122.44 132.53,122.45
  IN3 w0.114: 132.53,122.45 132.53,122.83 132.89,123.18 133.63,123.18 133.86,122.96 134.4,122.96 134.99,123.54 135.85,123.54 137.48,125.17 140.14,125.17 141.08,126.11 145.57,126.11 145.79,125.88 155.31,125.88 155.69,126.26 157.54,126.26 157.84,125.95 160.03,125.95 v1(160.33,126.26)
  BOTTOM w0.127: U35.G16 131.98,119.69 v3(132.24,119.95)
PEG_RX3: length 34.6
  TOP w0.127: v1(157.05,125.37) 157.31,125.11 157.94,125.11 158.68,125.86 158.68,126.87 159.84,128.04 160.7,128.04 C4022.1
  IN3 w0.076: 134.61,122.39 134.6,122.39 134.57,122.36 133.85,122.36 133.49,122.01 133.49,119.84 133.41,119.76 133.25,119.76 133.12,119.89 v3(133.12,119.97)
  IN3 w0.114: 134.61,122.39 134.87,122.39 135.19,122.7 136.06,122.7 137.2,123.84 139.88,123.84 141.41,125.37 145.16,125.37 145.41,125.11 156.8,125.11 v1(157.05,125.37)
  BOTTOM w0.127: v3(133.12,119.97) 133.04,119.97 U35.F15
PEG_RX#0: length 30.7
  TOP w0.127: C4016.1 160.96,123.31 v1(160.33,123.31)
  IN3 w0.076: 135.31,121.64 135.3,121.62 135.14,121.62 135.09,121.67 135.07,121.67 135.05,121.69 134.77,121.69 134.59,121.51 134.59,119.96 134.17,119.55 134.17,119.55 v3(134.04,119.42)
  IN3 w0.114: 135.31,121.64 135.41,121.73 136.44,121.73 137.59,122.88 143.31,122.88 143.79,123.36 147.15,123.36 147.3,123.51 155.62,123.51 155.9,123.79 158.92,123.79 159.4,123.31 v1(160.33,123.31)
  BOTTOM w0.127: U35.H13 133.96,119.42 v3(134.04,119.42)
PEG_RX#1: length 34.1
  TOP w0.127: v1(157.03,122.57) 157.16,122.7 159.08,122.7 159.84,121.94 161.07,121.94 161.45,122.32 162.52,122.32 164.65,124.45 164.92,124.45 165.15,124.23 C4018.1
  IN3 w0.114: v3(134.98,119.42) 135.23,119.68 135.46,119.68 136.48,120.7 137.16,120.7 137.44,120.97 137.78,120.97 138.59,121.79 139.27,121.79 139.6,121.46 144.37,121.46 145.01,122.09 146.64,122.09 146.87,122.32 153.4,122.32 153.78,122.7 156.9,122.7 v1(157.03,122.57)
  BOTTOM w0.127: v3(134.98,119.42) 134.77,119.42 U35.G11
PEG_RX#2: length 34.6
  TOP w0.127: C4021.1 160.58,125.37 v1(160.33,125.62)
  IN3 w0.076: v3(132.24,119.31) 132.73,119.81 132.73,122.41 132.76,122.44 132.76,122.45
  IN3 w0.114: 132.76,122.45 132.76,122.73 132.98,122.96 133.53,122.96 133.76,122.73 134.5,122.73 135.08,123.31 135.95,123.31 137.57,124.94 140.24,124.94 141.18,125.88 145.47,125.88 145.7,125.65 155.4,125.65 155.78,126.03 157.44,126.03 157.75,125.72 160.23,125.72 v1(160.33,125.62)
  BOTTOM w0.127: U35.H16 131.96,119.04 v3(132.24,119.31)
PEG_RX#3: length 34.5
  TOP w0.127: C4023.1 160.7,127.78 159.95,127.78 158.93,126.77 158.93,125.75 158.04,124.86 157.31,124.86 v1(157.05,124.61)
  IN3 w0.076: v3(133.12,119.34) 133.38,119.6 133.48,119.6 133.66,119.78 133.66,121.94 133.91,122.19 134.57,122.19 134.6,122.16 134.61,122.16
  IN3 w0.114: v1(157.05,124.61) 156.77,124.89 145.32,124.89 145.07,125.14 141.5,125.14 139.98,123.62 137.29,123.62 136.15,122.48 135.28,122.48 134.97,122.16 134.61,122.16
  BOTTOM w0.127: v3(133.12,119.34) 133.02,119.34 U35.G15
PEG_RXN0_C: length 14.6
  TOP w0.127: C4016.2 162.15,123.42 162.52,123.42 164.72,125.62 167.19,125.62 168.2,126.64 168.71,126.64 169.09,127.02 v1(169.93,127.02) 169.93,127.81 170.06,127.93 170.06,128.49 170.49,128.92 171.49,128.92 172.01,129.45 172.01,129.78 v1(172.18,129.94)
  BOTTOM w0.127: U3002.AJ14 v1(172.18,129.94)
PEG_RXN1_C: length 11.2
  TOP w0.127: C4018.2 165.93,124.1 166.26,124.43 168.51,124.43 170.47,126.38 172.14,126.38 172.9,127.15 172.9,128.01 173.56,128.67 173.56,128.88 v1(173.83,129.14)
  BOTTOM w0.127: U3002.AG14 v1(173.83,129.14)
PEG_RXN2_C: length 13.3
  TOP w0.127: v1(172.18,130.8) 171.75,130.37 170.72,130.37 166.74,126.38 164.27,126.38 v1(163.76,125.88) 163.58,126.05 162.9,126.05 162.42,125.57 162.07,125.57 C4021.2
  BOTTOM w0.127: U3002.AJ15 172.18,130.74 v1(172.18,130.8)
PEG_RXN3_C: length 12
  TOP w0.127: v1(171.33,131.59) 170.87,131.13 170.28,131.13 169.85,130.7 168.66,130.7 168.41,130.45 165.66,130.45 164.22,129 v1(164.22,128.54) 163.66,128.54 162.72,127.6 162.07,127.6 C4023.2
  BOTTOM w0.127: U3002.AK16 v1(171.33,131.59)
PEG_RXP0_C: length 14.6
  TOP w0.127: C4015.2 161.89,123.89 162.11,123.67 162.41,123.67 164.62,125.88 167.08,125.88 168.1,126.89 168.61,126.89 169.03,127.32 v1(169.03,127.92) 169.68,127.92 169.8,128.04 169.8,128.6 170.39,129.18 171.38,129.18 171.76,129.56 171.76,129.76 171.58,129.94 v1(171.33,129.94)
  BOTTOM w0.127: U3002.AK14 v1(171.33,129.94)
PEG_RXP1_C: length 11.2
  TOP w0.127: v1(173.05,129.14) 173.21,129.14 173.31,129.04 173.31,128.77 172.65,128.11 172.65,127.25 172.04,126.64 170.36,126.64 168.41,124.68 165.97,124.68 165.83,124.83 165.83,125.01 C4017.2
  BOTTOM w0.127: v1(173.05,129.14) 173.05,129.17 U3002.AH14
PEG_RXP2_C: length 13.4
  TOP w0.127: C4020.2 161.66,126.18 161.66,125.94 161.78,125.83 162.31,125.83 162.79,126.31 162.92,126.31 v1(163.76,127.15) 164.27,126.64 166.63,126.64 170.62,130.63 171.15,130.63 v1(171.33,130.8)
  BOTTOM w0.127: v1(171.33,130.8) 171.33,130.74 U3002.AK15
PEG_RXP3_C: length 12
  TOP w0.127: v1(170.53,131.59) 170.38,131.59 169.74,130.96 168.56,130.96 168.3,130.7 165.56,130.7 164.3,129.44 v1(163.32,129.44) 163.32,128.56 162.61,127.86 161.83,127.86 161.69,128 161.69,128.24 C4022.2
  BOTTOM w0.127: U3002.AL16 v1(170.53,131.59)
PEG_TX0: length 40.9
  IN1 w0.089: v1(133.51,129.08) 133.68,128.91 133.68,128.7 133.91,128.47 135.62,128.47 137.22,130.07 148.17,130.07 149.41,128.82 153.14,128.82 154.31,127.65 160.08,127.65 160.76,126.97 165.06,126.97 165.62,127.52 v1(165.93,127.52)
  BOTTOM w0.127: v1(165.93,127.52) 165.99,127.58 166.21,127.8 166.38,127.8 166.6,127.58 167.75,127.58 168.44,128.26 168.74,128.26 168.91,128.09 168.91,127.55 169.03,127.43 169.21,127.43 169.33,127.55 U3002.AN12 ; v1(133.51,129.08) 133.86,128.72 133.86,128.5 C652.1
PEG_TX1: length 38.8
  IN1 w0.089: v1(166.93,128.92) 166.72,129.14 166.01,129.14 164.5,127.63 161.14,127.63 160.45,128.32 154.58,128.32 153.42,129.48 149.69,129.48 148.44,130.73 136.86,130.73 136.71,130.58 135.22,130.58 v1(134.71,131.09)
  BOTTOM w0.127: C655.1 135.31,130.51 135.18,130.64 134.84,130.64 134.71,130.78 v1(134.71,131.09) ; v1(166.93,128.92) 167.39,129.38 168.16,129.38 168.39,129.15 168.79,129.15 168.95,129.32 168.95,129.5 169.06,129.61 169.26,129.61 U3002.AN14
PEG_TX2: length 40.7
  IN1 w0.089: v1(163.79,131.26) 163.96,131.26 164.19,131.03 164.19,130.92 163.91,130.64 162.44,130.64 162.03,131.05 155.42,131.05 154.46,132.01 152.8,132.01 152.16,132.65 150.1,132.65 149.19,133.56 140.34,133.56 139.96,133.94 134.1,133.94 133.98,134.06 133.98,134.25 134.37,134.64 v1(134.6,134.64)
  BOTTOM w0.127: C662.1 134.25,133.68 134.25,134.29 v1(134.6,134.64) ; v1(163.79,131.26) 163.86,131.19 163.86,130.5 164.59,129.76 168.31,129.76 U3002.AP14
PEG_TX3: length 42.5
  IN1 w0.089: v1(166.35,131.39) 166.45,131.29 166.45,131.13 166.34,131.02 165.23,131.02 164.15,129.94 162,129.94 161.55,130.39 155.15,130.39 154.19,131.35 152.44,131.35 151.82,131.97 149.84,131.97 149.04,132.77 134.38,132.77 134.04,133.12 132.39,133.12 132.21,133.3 132.21,133.37 132.68,133.84 132.68,134.1 132.55,134.23 132.36,134.23 v1(132.14,134)
  BOTTOM w0.127: U3002.AN15 169.06,130.34 168.95,130.44 168.95,130.61 168.84,130.73 166.91,130.73 166.35,131.29 v1(166.35,131.39) ; C660.1 131.83,133.56 131.83,133.7 v1(132.14,134)
PEG_TX#0: length 40.9
  IN1 w0.089: v1(165.93,128.16) 165.93,128.11 164.99,127.16 160.84,127.16 160.16,127.85 154.39,127.85 153.22,129.01 149.49,129.01 148.25,130.26 137.14,130.26 135.54,128.66 133.99,128.66 133.87,128.78 133.87,128.91 134.04,129.08 v1(134.14,129.08)
  BOTTOM w0.127: v1(134.14,129.08) 134.14,128.83 C653.2 ; v1(165.93,128.16) 166.04,128.06 166.48,128.06 166.71,127.83 167.65,127.83 168.33,128.52 168.84,128.52 169.07,128.29 169.68,128.29 U3002.AM12
PEG_TX#1: length 38.9
  IN1 w0.089: v1(135.34,131.09) 135.66,130.77 136.63,130.77 136.78,130.92 148.52,130.92 149.77,129.67 153.5,129.67 154.66,128.51 160.53,128.51 161.22,127.82 164.42,127.82 165.93,129.33 167.16,129.33 v1(167.57,128.92)
  BOTTOM w0.127: v1(167.57,128.92) 167.77,129.13 168.05,129.13 168.28,128.9 168.89,128.9 169.09,129.1 169.69,129.1 U3002.AM14 ; C656.1 136.23,130.2 v1(135.34,131.09)
PEG_TX#2: length 40.7
  IN1 w0.089: v1(133.79,134.64) 133.79,133.98 134.02,133.75 139.88,133.75 140.26,133.37 149.11,133.37 150.02,132.46 152.09,132.46 152.72,131.82 154.39,131.82 155.34,130.86 161.95,130.86 162.36,130.45 163.99,130.45 164.38,130.84 164.38,131.12 v1(164.52,131.26)
  BOTTOM w0.127: C661.1 133.99,133.84 133.99,134.43 v1(133.79,134.64) ; v1(164.52,131.26) 164.12,130.86 164.12,130.6 164.7,130.02 168.48,130.02 168.58,130.12 168.58,130.29 U3002.AP15
PEG_TX#3: length 42.5
  IN1 w0.089: v1(131.5,134) 132.02,133.48 132.02,133.22 132.31,132.93 133.96,132.93 134.31,132.58 148.96,132.58 149.76,131.78 151.74,131.78 152.36,131.16 154.11,131.16 155.07,130.2 161.47,130.2 161.92,129.75 164.23,129.75 165.31,130.83 166.43,130.83 v1(166.99,131.39)
  BOTTOM w0.127: v1(166.99,131.39) 167.39,130.98 168.94,130.98 169.2,130.73 169.74,130.73 U3002.AM15 ; v1(131.5,134) 130.99,133.5 C654.1
PEGX_RST#: length 85.2
  TOP w0.127: v1(173.41,117.62) 173.41,116.48 173.16,116.22 Q4301.2
  IN1 w0.089: v1(173.41,117.62) 173.79,118 173.79,119.91 172.58,121.12 v1(172.58,126)
  IN3 w0.114: v1(220.91,106.83) 220.88,106.8 218.09,106.8 217.92,106.63 212.55,106.63 210.08,104.16 197.29,104.16 194.62,106.83 189.03,106.83 188.65,107.21 187.98,107.21 183.96,103.19 176.33,103.19 172.66,106.86 172.66,107.66 170.6,109.72 170.6,113.41 173.41,116.22 v1(173.41,117.62)
  BOTTOM w0.127: v1(220.91,106.83) 220.91,107.2 R4004.1 R4005.2 219,107.57 218.77,107.34 U4002.4 217.96,107.89 217.5,108.35 R4007.1 ; U3002.AJ12 172.17,127.44 172.17,126.73 172.58,126.33 v1(172.58,126)
PEX_CLKREQ#: length 28.9
  TOP w0.127: v1(166.93,117.14) Q4002.1
  IN1 w0.089: v1(166.93,117.14) 167.57,117.77 167.57,120.54 169.6,122.57 169.6,125.71 v1(171.32,127.44) 171.92,127.44 172.65,128.16 172.65,131.34 171.96,132.02 169.32,132.02 v3(168.92,132.43)
  BOTTOM w0.127: R4008.1 163.64,132.35 164.78,132.35 164.9,132.23 v1(165.41,132.23) 165.61,132.43 v3(168.92,132.43) ; U3002.AK12 v1(171.32,127.44)
PEX_PLLVDD: length 0.6
  BOTTOM w0.356: U3002.AG26 174.63,139.94 v1(174.63,139.97)
  vias: v1(164.01,145.03) v1(164.01,144.39) v1(164.39,145.69) v1(174.68,139.08)
PEX_TERMP: length 4.9
  BOTTOM w0.127: U3002.AP29 167.54,142.04 166.82,142.76 v1(164.65,142.76) R4009.2
PEX_TSTCLK: length 13.6
  IN1 w0.122: v1(162.09,142.76) 164.37,140.48 165.79,140.48 167.95,138.32 171.33,138.32 v1(172.15,139.14)
  BOTTOM w0.127: U3002.AJ26 172.18,139.14 v1(172.15,139.14) ; R4006.2 v1(162.09,142.76)
PEX_TSTCLK#: length 12.9
  IN1 w0.122: v1(162.09,143.54) 164.77,140.86 165.79,140.86 168.08,138.58 170.79,138.58 v1(171.33,139.11)
  BOTTOM w0.127: U3002.AK26 171.33,139.14 v1(171.33,139.11) ; R4006.1 v1(162.09,143.54)
PIRQA#: length 11.1
  BOTTOM w0.076: 136.96,99.59 135.94,100.61 135.74,100.61 135.41,100.93 135,100.93 134.85,101.09 U35.BB11
  BOTTOM w0.127: 136.96,99.59 138.36,99.59 138.72,99.23 144.17,99.23 R631.1 144.19,98.86 v1(144.56,98.5)
PLLVDD: length 11.6
  TOP w0.508: C4208.1 166.41,122.92 166.96,123.47 C4209.1 L4201.2 169.23,123.47 169.73,123.97 169.73,124.4 170.43,125.11 v1(174.12,125.11) C4211.2
  BOTTOM w0.305: v1(175.56,124.05) 175.59,124.05 U3002.AE8 ; v1(176.41,124.04) 176.43,124.04 U3002.AD7
PLTRST#: length 465.1
  TOP w0.127: R11261.1 34.73,63.01 v1(35.89,61.85) ; v1(174.05,91.97) 174.05,91.84 173.67,91.46 166.51,91.46 165.59,90.54 165.59,88.1 v1(165.14,87.65) 164.65,87.65 163.12,89.17 v1(163.12,91.71) ; v1(152.89,30.42) 158.65,24.66 167.44,24.66 172.78,19.32 185.48,19.32 187.64,21.48 187.64,23.24 187.89,23.49 187.89,25.55 188.65,26.31 188.65,31.52 v1(190.68,33.55)
  IN1 w0.089: v1(174.05,91.97) 174.05,95.4 173.61,95.83 173.61,102.89 176.61,105.88 185.42,105.88 186.62,107.08 195.26,107.08 195.55,106.78 205.04,106.78 206.1,107.85 v1(208.61,107.85) ; v1(35.89,61.85) 34.38,60.34 34.38,52.83 35.72,51.49 35.72,47.03 36.63,46.12 36.63,43.91 42.82,37.72 42.82,34.98 43.87,33.93 43.87,33.17 44.29,32.75 44.29,27.64 46.47,25.46 47.55,25.46 56.01,17 58.25,17 58.84,17.58 67.69,17.58 80.59,30.49 113.86,30.49 114.23,30.12 115.88,30.12 116.25,30.49 150.24,30.49 150.63,30.88 152.43,30.88 v1(152.89,30.42)
  IN3 w0.114: v1(201.86,183.53) 203,182.39 203,172.27 206.23,169.04 206.23,161.25 210.94,156.55 211.96,156.55 214.36,154.15 221.75,154.15 225.75,150.14 225.75,142.51 225.22,141.98 225.22,122.28 226.47,121.03 226.47,114.9 222.59,111.02 218.88,111.02 217.61,109.75 210.51,109.75 v1(208.61,107.85) ; v1(152.89,30.42) 153.6,31.13 154.49,31.13 159.73,36.38 159.73,42.65 159.17,43.21 159.17,64.58 160.76,66.17 160.76,68.56 159.56,69.76 159.56,72.52 160.97,73.93 160.97,74.31 161.6,74.95 162.95,74.95 v1(163.51,75.5) 163.16,75.85 163.16,81.9 165.18,83.93 165.18,87.61 v1(165.14,87.65)
  BOTTOM w0.127: R749.1 v1(190.68,33.55) ; R671.1 202.37,181.12 202.79,181.54 202.79,182.12 201.86,183.05 v1(201.86,183.53) ; v1(208.61,107.85) C4030.2 U4001.2 ; R742.1 165.66,75.46 165.42,75.7 163.7,75.7 v1(163.51,75.5) ; R960.2 v1(163.12,91.71) ; U14.4 164.41,86.49 164.65,86.25 165.29,86.25 R214.1 165.66,87.13 v1(165.14,87.65)
PLTRST#_EC: length 3.1
  BOTTOM w0.127: U45.22 188.13,33 188.6,32.53 C822.1 R749.2
PM_THRMTRIP#: length 13.3
  TOP w0.127: R10890.2 116.01,44.21 116.01,47.25 116.91,48.15 116.91,54.11 116.14,54.87 v1(116.14,55.45) R10921.2
PMON: length 33.1
  TOP w0.127: PR172.1 151.08,185.96 v1(150.58,186.46)
  TOP w0.203: PR25.2 136.03,172.98 v1(135.82,173.2)
  TOP w0.305: PC7.2 PR342.2 135.79,171.88 v1(136.07,172.15) 136.51,172.59 PR25.2
  IN1 w0.089: v1(135.82,173.2) 136.52,173.9 136.52,180.8 135.49,181.83 135.49,182.77 139.35,186.63 142.07,186.63 143.24,187.8 149.23,187.8 v1(150.58,186.46)
POA_AUTH_ERR: length 91.4
  IN1 w0.089: v1(179.51,29.23) 179.11,29.63 178.07,29.63 177.83,29.4 177.83,28.98 174.65,25.79 174.65,24.91 174.61,24.87 174.61,24.56 173.17,23.11 169.1,23.11 167.51,24.7 167.36,24.85 164.17,24.85 158.33,19.01 154.45,19.01 153.8,18.36 152.74,18.36 152.09,19.01 136.01,19.01 132.26,15.26 125.04,15.26 124.42,14.64 109.16,14.64 106,17.8 106,19.27 106.61,19.88 108.2,19.88 v1(108.77,19.32)
  BOTTOM w0.127: v1(179.51,29.23) 179.58,29.16 U45.48 ; R11294.2 108.64,19.19 v1(108.77,19.32)
POA_EN#: length 83.1
  IN1 w0.089: v1(111.28,19.32) 115.39,15.22 124.18,15.22 129.05,20.09 158.33,20.09 163.95,25.7 171.05,25.7 v1(171.2,25.55)
  BOTTOM w0.127: R11292.2 111.05,19.32 v1(111.28,19.32) ; v1(171.2,25.55) v1(171.2,27.04) 171.2,27.05 174.17,30.02 174.17,33.55 175.19,34.56 175.19,35.83 174.6,36.42 172.59,36.42 172.36,36.2 U45.83
POA_FP_PWREN#: length 70.5
  TOP w0.127: R2854.1 116.89,31.76 v1(117.86,30.79) v1(117.86,27.17)
  IN1 w0.089: v1(174.3,35.03) 173.79,35.54 173.79,36.09 173.41,36.47 172.53,36.47 171.19,35.14 170.47,35.14 168.84,33.51 165.11,33.51 163.45,31.85 163.13,31.85 158.85,27.58 118.27,27.58 v1(117.86,27.17)
  BOTTOM w0.127: v1(174.3,35.03) 172.66,33.4 U45.76
POA_POWERREQ: length 94.4
  IN1 w0.089: v1(106.79,18.7) 108.37,18.7 112.24,14.83 124.34,14.83 129.09,19.58 158.36,19.58 164.08,25.29 167.46,25.29 168.47,24.28 169.73,24.28 170.51,23.49 171.7,23.49 172.59,24.39 172.59,25.89 178.09,31.38 181.27,31.38 181.57,31.08 181.57,30.83 181.79,30.6 182.28,30.6 v1(182.68,31.01)
  BOTTOM w0.127: R11295.2 v1(106.79,18.7) ; v1(182.68,31.01) 182.68,31.64 184.84,33.8 U45.20
POA_PWR: length 9.8
  TOP w0.508: 109.51,31.77 107.02,29.28 v1(107.02,25.79)
  BOTTOM w0.508: R11289.1 106.2,24.18 106.2,25.42 106.57,25.79 v1(107.02,25.79)
  vias: v1(110.8,32.91)
POA_PWR_INT#: length 90.8
  IN1 w0.089: v1(109.4,19.32) 113.7,15.02 124.26,15.02 129.07,19.83 158.35,19.83 164.01,25.5 167.54,25.5 168.56,24.48 169.81,24.48 170.19,24.1 170.87,24.1 171.76,24.99 171.76,26.05 173.41,27.71 174.14,27.71 178.01,31.57 181.48,31.57 v1(182.05,31.01)
  BOTTOM w0.127: U45.19 184.73,34.2 182.05,31.52 v1(182.05,31.01) ; v1(109.4,19.32) 109.53,19.19 R11293.2
PROC_PWRGD: length 6.1
  BOTTOM w0.127: U35.A68 101.78,123.88 100.13,125.53 100.13,127.65 R554.1 R544.2
PROCHOT_EC: length 6
  BOTTOM w0.127: Q30.2 191.57,33.42 v1(191.3,33.69) 190.94,34.06 189.66,34.06 R380.2 188.42,34.56 187.99,35 U45.17
PS_FB_CLAMP: length 7
  BOTTOM w0.127: v1(197.8,114.8) 197.38,115.22 R4114.1 196.77,115.22 196.4,115.59 196.4,115.97 194.87,117.5 193.87,117.5 U3002.E1
PTP_PWR_EN#: length 75.7
  IN1 w0.089: v1(181.03,30.98) 177.96,30.98 173.79,26.82 173.79,24.78 172.31,23.3 169.18,23.3 167.44,25.04 164.09,25.04 158.25,19.2 132.39,19.2 129.47,16.28 v1(128.83,16.28)
  BOTTOM w0.127: v1(181.03,30.98) 181.03,31.26 181.51,31.74 181.51,32.94 181.03,33.43 181.03,37.94 184.38,41.29 U45.125 ; R754.1 129.59,16.28 v1(128.83,16.28)
PWM1_B: length 32.9
  TOP w0.203: PR27.1 v1(145.1,172)
  BOTTOM w0.203: v1(145.1,172) 145.22,171.89 145.22,168.55 142.55,165.88 136.61,165.88 v1(136.05,166.44) 125.99,166.44 125.18,165.63 120.73,165.63 119.72,164.61 119.72,164.43 119.22,163.94 PR228.1
PWM2_B: length 27.1
  TOP w0.203: PR29.1 145.32,173.96 146.06,173.22 146.06,168.42 143.06,165.42 135.97,165.42 135.46,164.92 134.67,164.92 134.51,165.07 131.33,165.07 131.11,164.84 v1(128.24,164.84) 128.1,164.84 127.62,164.36 v1(127.62,164.28)
  BOTTOM w0.254: PR233.1 127.43,164.09 v1(127.62,164.28)
PWM-VID: length 108.1
  IN1 w0.089: v1(186.44,122.33) 186.44,121.53 185.22,120.31 185.22,119.12 186.11,118.23 186.11,117.9 185.88,117.67 185.88,114.85 185.15,114.12 185.15,113.02 184.79,112.67 184.79,110.33 183.7,109.24 183.19,109.24 181.91,107.96 174.3,107.96 171.89,105.54 171.89,104.54 170.24,102.89 170.24,100.86 170.03,100.65 170.03,95.47 170.43,95.08 170.43,89.51 168.32,87.4 168.32,84.69 169.82,83.19 169.82,77.34 170.34,76.82 170.34,75.24 170.96,74.62 170.96,74 171.6,73.36 171.6,70.32 172.38,69.53 172.38,68.8 177.63,63.55 177.63,62.5 178.3,61.84 178.3,61.41 178.48,61.23 180.38,59.33 190.1,59.33 v1(190.18,59.25)
  IN3 w0.114: v1(205.16,58.19) 204.93,57.95 194.8,57.95 194.06,58.69 190.73,58.69 v1(190.18,59.25)
  BOTTOM w0.127: PR256.1 204.68,58.67 v1(205.16,58.19) ; U3002.M5 186.44,122.33 v1(186.44,122.33)
PWM_A: length 24.8
  IN1 w0.203: v1(139.17,164.21) 139.17,164.26 139.15,164.28 139.15,164.79 140.14,165.78 141.66,165.78 145.57,169.69 145.57,175.74 143.31,178 143.31,180.69 143.82,181.2 v1(144.1,181.2)
  BOTTOM w0.203: v1(144.1,181.2) 143.49,181.2 142.93,181.76 PR43.2
  BOTTOM w0.254: PR237.1 139.17,163.73 v1(139.17,164.21)
PWM_C: length 38.5
  TOP w0.203: v1(136.18,182.65) PR47.2
  IN1 w0.203: v1(150.27,165.35) 150.27,165.81 151.69,167.23 151.69,172.59 151.95,172.84 151.95,181.96 151.21,182.7 150.17,182.7 147.71,185.16 138.49,185.16 136.18,182.85 v1(136.18,182.65)
  BOTTOM w0.254: v1(150.27,165.35) 150.04,165.35 149.54,164.84 149.54,164.48 149.82,164.21 PR239.1
PWRLED#: length 159.9
  TOP w0.127: v1(54.41,11.26) v1(53.25,12.43) 52,13.68 52,18.06 R426.1 R436.1 R432.1
  IN1 w0.089: v1(185.6,32) 184.36,32 183.72,32.64 178.27,32.64 173.94,28.32 171.84,28.32 169.88,26.36 163.8,26.36 159.18,21.74 129.9,21.74 126.57,18.41 121.17,18.41 117.03,22.56 108.88,22.56 107.66,23.78 103.54,23.78 102.74,24.57 82.99,24.57 76.38,17.96 76.38,14.24 75.24,13.1 70.43,13.1 68.72,11.39 54.54,11.39 v1(54.41,11.26)
  BOTTOM w0.127: U45.24 185.8,32.2 v1(185.6,32)
R_SPK+: length 146.6
  IN3 w1.016: 199.21,45.49 196.8,47.9 192.74,47.9 190.33,45.49 187.45,45.49 183.16,41.2 183.16,40.81 180.14,37.79 180.14,33.99 179.29,33.13 179.29,33.12 177.41,31.25 176.5,31.25 175.86,30.61 169.21,30.61 168.45,29.86 158.54,29.86 157.6,28.91 119.38,28.91 119.1,29.19 115.23,29.19 113.74,30.68 93.18,30.68 82.33,19.83 76.69,19.83 73.68,16.82
  BOTTOM w0.203: U23.45 200.84,43.18 199.68,44.34 v1(199.57,44.34)
  BOTTOM w0.508: v1(198.94,44.34) v1(199.57,44.34)
  vias: v1(73.08,15.89) v1(73.72,15.89) v1(74.43,15.84)
R_SPK+_1:
  vias: v1(77.96,14.83) v1(78.44,15.26) v1(78.57,14.62)
R_SPK-: length 145.2
  IN3 w1.016: 74.61,14.5 74.61,16.15 77.15,18.69 82.86,18.69 93.73,29.55 113.27,29.55 114.76,28.06 118.63,28.06 118.91,27.78 158.15,27.78 159.06,28.7 168.9,28.7 169.68,29.48 176.33,29.48 176.97,30.12 177.88,30.12 181.29,33.52 181.29,37.34 184.28,40.34 184.28,40.72 187.9,44.34 190.79,44.34 193.21,46.77 196.33,46.77 197.87,45.23
  BOTTOM w0.203: U23.44 200.72,42.78 200.05,43.45 v1(199.57,43.45)
  BOTTOM w0.508: v1(198.94,43.45) v1(199.57,43.45)
  vias: v1(74.3,14.14) v1(74.35,13.51) v1(74.99,13.51)
R_SPK-_1:
  vias: v1(77.96,13.84) v1(78.39,13.35) v1(78.59,13.96)
RAM_ID1: length 13.1
  BOTTOM w0.076: U35.AP2 140.38,105.4 140.55,105.4 140.77,105.34 140.88,105.34 141,105.39 141.17,105.39 141.17,105.39 141.23,105.39 141.25,105.37 143.19,105.37 143.31,105.25 143.69,105.25
  BOTTOM w0.127: 143.69,105.25 143.71,105.24 148.59,105.24 R611.1 149.04,105 149.29,105.25 149.83,105.25 150.11,104.98 150.11,104.98 R610.2 150.32,104.79 150.91,105.38 v1(152.13,105.38)
RAM_ID2: length 6.1
  BOTTOM w0.076: 143.69,105.62 U35.AP1
  BOTTOM w0.127: R613.1 146.22,105.75 145.97,105.49 144.52,105.49 144.19,105.82 R612.2 143.87,105.62 143.69,105.62
RAM_ID3: length 7.5
  BOTTOM w0.076: 143.69,104.79 143.43,104.79 143.06,105.17 141.24,105.17 141.23,105.16 140.93,105.16 140.92,105.18 140.74,105.18 140.53,105.24 140.09,105.24 139.71,105.62 U35.AP3
  BOTTOM w0.127: 143.69,104.79 R614.2 144.24,104.79 144.68,104.35 145.96,104.35 146.22,104.62 R615.1
REGN6V: length 5.6
  TOP w0.127: PC122.1 159.81,179.49 v1(159.67,179.62)
  TOP w0.191: PU5.24 159.19,181.31
  TOP w0.203: PC122.1 160.56,180.61 159.89,181.28 159.21,181.28 159.19,181.31
  TOP w0.305: PR1.1 161.16,180.09 PC122.1
REGOUT:
  vias: v1(41.97,68.98)
RF_EN: length 226.5
  TOP w0.127: v1(180.97,63.85) 180.66,63.54 179.05,63.54 176.26,60.75 176.26,48.19 176.92,47.53 176.92,45.71 176.61,45.41 176.61,40.29 175.85,39.52 175.85,37.72 174.98,36.85 172.38,36.85 171.25,35.72 171.25,31.52 v1(167.7,27.96) 167.44,27.71 v1(167.44,27.27)
  IN1 w0.089: v1(200.08,178) 200.08,176.21 202.63,173.66 202.63,172.06 204.38,170.31 205.03,170.31 206.12,169.22 206.12,159.39 208.07,157.45 219.47,157.45 226.35,150.56 226.35,127.58 226.22,127.45 226.22,121.48 226.98,120.73 226.98,114.97 219.59,107.59 216.46,107.59 212.88,104 194.93,104 194.02,103.09 186.75,103.09 186.24,102.59 180.07,102.59 177.9,100.42 177.9,96.02 176.1,94.22 176.1,87.26 174.48,85.63 174.48,79.54 173.76,78.83 173.76,77.12 176.27,74.61 176.27,68.85 180.97,64.15 v1(180.97,63.85)
  BOTTOM w0.127: v1(167.44,27.27) 167.44,26.93 R774.2 ; v1(200.08,178) 199.83,178.25 CN10.56
RING2: length 18.9
  IN1 w1.016: 207.83,42.95 207.83,39.9 206.81,38.88 206.81,37.33 204.27,34.79 204.27,28.72 204.02,28.47 204.02,27.58
  BOTTOM w0.203: U23.17 208.43,42.78 v1(208.97,43.33)
  BOTTOM w0.508: v1(209.61,43.33) v1(208.97,43.33)
  vias: v1(204.4,25.93) v1(204.4,25.29)
RING2_R: length 10.9
  IN1 w1.016: 208.46,13.1 207.83,13.1 206.56,14.37 206.56,16.96 204.43,19.1 204.43,21.99
  vias: v1(204.91,23.39) v1(204.91,22.75) v1(208.97,12.85) v1(209.61,13.35) v1(209.61,12.72)
ROM_SCLK: length 11.5
  BOTTOM w0.127: v1(190.43,110.97) 190.43,111.13 190.9,111.6 190.9,111.96 190.87,111.99 190.87,112.71 190.4,113.19 R4307.1 R4315.2
  BOTTOM w0.14: R4315.2 190.81,114.95 190.81,116.22 189.72,117.31 189.72,120.74 U3002.H4
ROM_SI: length 9.1
  TOP w0.127: v1(189.74,121.54) 189.76,121.51 189.76,117.59 v1(189.76,117.58) 189.76,117.58 189.76,114.91 R4313.2 R4305.1
  BOTTOM w0.127: U3002.H5 189.74,121.55 v1(189.74,121.54)
ROM_SO: length 15.9
  TOP w0.127: R4306.1 R4314.2 196.4,114.95 196.4,116.1 194.75,117.75 v1(193.99,117.75) 192.84,117.75 190.94,119.65 190.94,122.18 191.02,122.26 191.02,123.3 190.72,123.6 190.16,123.6 v1(189.73,124.04)
  BOTTOM w0.14: U3002.H7 v1(189.73,124.04)
RSET: length 5.1
  TOP w0.203: U15.47 41.61,74.46 41.78,74.63
  TOP w0.254: 41.78,74.63 41.97,74.82 42.01,74.86 42.01,75.83 42.35,76.17 42.35,78.12 R11264.2
RSMRST#: length 82.7
  IN1 w0.089: v1(153.5,78.82) 153.5,78.56 152.92,77.98 152.92,66.07 153.94,65.05 153.94,60.74 156.8,57.88 156.8,54.86 159.44,52.22 159.44,51.07 160.02,50.5 162.93,50.5 163.2,50.77 164.07,50.77 164.65,50.18 172.4,50.18 173.03,49.55 173.03,49.04 174.3,47.77 174.3,45.99 174.68,45.61 175.42,45.61 176.24,44.79 176.24,43.51 177.95,41.8 v1(178.59,41.8)
  BOTTOM w0.127: R655.1 133.28,90.06 137.32,86.02 140.76,86.02 147.96,78.82 v1(153.5,78.82) ; U45.112 179.18,42.26 178.72,41.8 v1(178.59,41.8)
RST_MON#: length 5.4
  BOTTOM w0.127: U4001.4 213.27,107.85 213.29,107.83 R11108.1 213.8,108.48 v1(214.05,108.72) R4007.2
RTC_RST#: length 220.1
  TOP w0.127: v1(171.63,89.94) 171.51,90.06 169.87,90.06 167.7,87.89 167.7,87.33 164.08,83.71 162.24,83.71 161.17,84.78 161.17,86.3 160.31,87.17 v1(153.5,87.17) 151.67,87.17 150.55,88.28 144.5,88.28 143.37,89.41 143.01,89.41 142.62,89.8 140.38,89.8 138.23,91.95 138.23,92.97 136.71,94.49 136.71,96.03 133.66,99.08 132.52,99.08 131.6,99.99 131.6,100.98 133.13,102.51 133.13,103.06 132.64,103.54 132.64,106.67 v3(132.21,107.1) ; v1(77.91,34.06) 79.38,35.53 79.38,43.62 77.64,45.36 C380.1 77.27,46.63 76.89,47.01 R299.2
  IN1 w0.089: v1(153.5,87.17) 152.1,87.17 150.04,85.11 150.04,79.97 151.98,78.03 151.98,65.68 153,64.66 153,45.26 150.3,42.56 150.3,41.55 149.03,40.28 148.52,40.28 147.25,39.01 144.88,39.01 143.15,37.28 96.58,37.28 95.71,36.41 79.96,36.41 79.28,35.73 79.28,35.43 v1(77.91,34.06)
  BOTTOM w0.127: J1.1 78.4,33.56 v1(77.91,34.06) ; v1(171.63,89.94) R268.2 ; Q6060.3 153.9,86.76 v1(153.5,87.17) ; v3(132.21,107.1) 131.98,107.1 131.75,107.33 U35.AM16
RTC_X1: length 20.9
  IN1 w0.089: v1(139,95.41) 138.43,95.41 134.26,99.57 134.26,100.42 133.02,101.66 131.11,101.66 130.19,102.57 130.19,103.74 130.79,104.34 130.79,106.7 v1(131.24,107.15)
  BOTTOM w0.127: v1(131.24,107.15) 130.95,107.45 U35.AM18 ; v1(139,95.41) R255.1 C351.2 140.01,96.28 140.15,96.14 Y2.1
RTC_X2: length 21.8
  IN1 w0.089: v3(130.38,107.15) 129.98,106.75 129.98,104.29 129.72,104.03 129.72,102.38 130.91,101.19 132.82,101.19 133.79,100.22 133.79,99.38 138.52,94.64 v1(139,94.64)
  BOTTOM w0.127: v3(130.38,107.15) 130.22,107.15 U35.AM20 ; Y2.2 139.64,93.64 C362.2 R255.2 139.02,94.63 v1(139,94.64)
RTD_PIN11: length 2.2
  TOP w0.127: R11285.1 24.36,72.28 24.28,72.19 U13.11
RTD_PIN12: length 2.4
  TOP w0.127: R11286.1 23.88,72.18 U13.12
S5_ON: length 302.1
  TOP w0.127: v1(45.27,90.95) 44.51,91.71 39.68,91.71 v1(38.92,92.48) PR6299.1 ; PR6293.1 62.39,55.57 v1(62.72,55.24)
  TOP w0.254: PQ9.2 40.52,115.08 40.91,114.69 40.91,114.28 41.74,113.46 PQ13.2 41.74,112.26 v1(42.35,111.65)
  IN1 w0.089: v1(45.27,90.95) 45.67,90.55 45.67,79.69 49.22,76.13 49.22,74.52 48.5,73.79 48.5,67.74 45.34,64.57 45.34,62.36 44.77,61.8 41.12,61.8 39.3,59.98 39.3,53.87 40.27,52.9 40.27,51.42 40.89,50.8 51.86,50.8 52.64,51.58 57.18,51.58 57.69,52.09 59.57,52.09 v1(62.72,55.24) ; v1(173.79,47.52) 173.54,47.26 169.86,47.26 169.35,46.76 169.35,46.25 168.36,45.26 165.43,45.26 164.64,44.47 163.14,44.47 160.78,42.1 160.78,37.83 156.62,33.67 148.19,33.67 147.45,32.94 84.36,32.94 83.91,33.39 81.56,33.39 79.05,30.88 78.16,30.88 v1(77.91,30.63)
  IN3 w0.114: v1(173.79,47.52) 173.78,47.52 173.42,47.87 173.42,49.24 172.7,49.96 172.7,52.52 171.42,53.8 171.42,60.46 170.59,61.29 v1(170.59,62.62) ; v1(62.72,55.24) 63.05,55.57 65.59,55.57 66.55,54.6 71.96,54.6 77.15,49.42 77.15,41.68 76,40.53 76,32.53 v1(77.91,30.63) 76.13,30.63 67.75,22.24 v1(67.75,22.12)
  BOTTOM w0.127: v1(42.35,111.65) 48.82,105.18 48.82,100.73 47.68,99.59 47.68,93.36 v1(45.27,90.95) ; v1(67.75,22.12) 67.75,22.19 67.39,22.55 PR6285.1 ; v1(173.79,47.52) R741.1 173.3,48.27 172.97,47.94 172.97,44.53 173.16,44.34 173.54,44.34 173.87,44.01 174.17,44.01 174.38,43.81 U45.100 ; PR69.1 163.75,62.11 164.01,62.38 167.82,62.38 168.71,61.49 170.17,61.49 170.59,61.91 v1(170.59,62.62)
SATA_DEVSLP1: length 5.5
  BOTTOM w0.076: U35.J2 140.43,118.73 140.65,118.64 140.71,118.61 140.97,118.61 141.18,118.82
  BOTTOM w0.127: 141.18,118.82 141.35,118.99 141.64,118.99 142.78,120.14 144.42,120.14 R574.1
SATA_DEVSLP2: length 50.8
  IN1 w0.089: v1(165.41,91.71) 164.93,92.2 164.93,105.06 159.58,110.4 158.41,110.4 157.14,111.67 157.14,115.43 152.58,119.99 147.79,119.99 v1(147.68,119.88)
  BOTTOM w0.076: 141.13,118.44 140.68,118.44 140.65,118.46 140.48,118.53 140.32,118.59 139.8,118.6 U35.J3
  BOTTOM w0.127: 141.13,118.44 141.72,118.44 143.16,119.88 144.96,119.88 145.12,120.03 147.13,120.03 R575.1 147.68,120.5 v1(147.68,119.88) ; v1(165.41,91.71) 165.54,91.71 v1(166.1,92.27) 166.43,92.6 R956.2
SATA_RXN0: length 172.4
  IN3 w0.076: v3(129.47,120.04) 130.03,120.6 130.03,121.64 129.59,122.08 129.59,122.41 129.62,122.44 129.62,122.45
  IN3 w0.114: 129.62,122.45 129.62,124.2 130.36,124.94 130.36,125.98 132.32,127.93 135.36,127.93 137.17,129.74 144.76,129.74 145.12,130.09 148.55,130.09 148.93,129.71 153.02,129.71 153.26,129.95 161.72,129.95 163.57,128.11 163.57,125.11 164.88,123.8 164.88,122.18 165.09,121.96 165.09,120.67 164.88,120.45 164.88,116.89 166.22,115.54 166.22,108.1 167.34,106.98 167.34,104.11 172.4,99.06 172.4,91.46 176.08,87.78 176.08,67.48 179.15,64.41 181.51,64.41 184.21,61.71 184.21,60.43 188.99,55.65 192.9,55.65 193.89,54.66 195.41,54.66 196.33,53.74 208.14,53.74 210.93,50.95 211.51,50.95 212.5,49.96 212.5,49.25 215.07,46.69 215.07,44.98 220.79,39.26 221.17,39.26 v1(221.42,39.01)
  BOTTOM w0.127: v3(129.47,120.04) 129.77,120.34 U35.F20 ; C507.2 223.71,38.13 223.96,38.37 223.96,38.76 223.33,39.39 221.8,39.39 v1(221.42,39.01)
SATA_RXN0_C: length 9.5
  BOTTOM w0.127: C507.1 223.73,37.07 223.73,36.88 v1(223.22,36.37) 223.25,36.37 223.73,35.88 223.73,35.76 224.08,35.4 226.7,35.4 227.97,34.13 230.02,34.13 CN14.5
SATA_RXN1: length 141.9
  IN3 w0.076: v3(128.57,120.03) 128.04,120.56 128.04,121.49 127.53,122 127.53,122.41 127.49,122.44 127.49,122.45
  IN3 w0.114: v1(226.78,100.76) 226.11,100.09 220.53,100.09 219.41,101.21 214.27,101.21 211.99,103.5 191.35,103.5 190.18,102.33 176.26,102.33 169.68,108.91 169.68,114.09 169.09,114.68 169.09,122.57 168.26,123.41 168.26,129.2 166.9,130.55 165.91,130.55 165.28,131.18 165.28,132.07 164.29,133.07 159.43,133.07 158.65,133.85 153.45,133.85 152.53,132.94 141.8,132.94 141.62,132.76 133.58,132.76 132.42,131.59 131.48,131.59 126.57,126.68 126.57,123.44 127.49,122.52 127.49,122.45
  BOTTOM w0.127: v1(226.78,100.76) 226.9,100.63 226.9,100.17 228.04,99.03 229.33,99.03 C744.2 ; v3(128.57,120.03) 128.67,120.03 U35.G21
SATA_RXN1_C: length 4.8
  BOTTOM w0.127: C744.1 230.7,99.21 231.22,99.21 232.91,97.52 233.51,97.52 CN9.5
SATA_RXN3/PEG_RXN9_L0: length 75.3
  IN3 w0.076: 130.18,122.45 130.18,122.43 130.15,122.4 130.15,122.06 130.5,121.7 130.5,119.54 129.8,118.84 128.38,118.84 127.79,119.43 125.57,119.43 125.25,119.74 125.25,120.93 125.41,121.08 125.41,121.28 125.31,121.37 125.04,121.37 v3(124.94,121.27)
  IN3 w0.114: v1(164.83,114.42) 164.83,114.21 164.95,114.08 165.18,114.08 165.36,114.26 165.36,115.16 164.01,116.5 164.01,122.45 162.72,123.75 162.72,127.41 161.02,129.1 153.78,129.1 153.24,128.57 139.78,128.57 139.27,128.06 136.76,128.06 135.64,126.94 132.73,126.94 131.76,125.97 131.76,124.73 130.61,123.59 130.61,123.14 130.18,122.7 130.18,122.45
  BOTTOM w0.127: R959.2 167.86,106.54 167.86,111.27 168.46,111.86 168.46,113.18 167.37,114.27 164.98,114.27 v1(164.83,114.42) ; v3(124.94,121.27) 124.66,120.99 U35.E28
SATA_RXN3/PEG_RXN9_L0_N: length 2.3
  BOTTOM w0.127: CN23.29 167.75,104.41 167.65,104.52 167.65,105.12 R959.1
SATA_RXN3/PEG_RXN10_L1: length 70.8
  IN3 w0.076: 130.99,121.92 130.98,121.91 130.98,121.89 130.95,121.85 130.95,121.83 130.7,121.58 130.7,119.15 130,118.45 128.52,118.45 127.86,119.11 125.19,119.11 124.49,119.81 124.49,120.21 124.64,120.37 124.64,120.77 124.1,121.31 v3(124.1,121.34)
  IN3 w0.114: 130.99,121.92 131.3,122.23 131.3,122.42 131.27,122.45 131.27,123.3 132.42,124.45 132.42,125.72 133.01,126.31 136.06,126.31 137.17,127.43 139.84,127.43 140.35,127.93 154.32,127.93 154.86,128.48 160.75,128.48 162.1,127.13 162.1,123.44 163.38,122.16 163.38,108.67 163.66,108.39 v1(164.27,108.39)
  BOTTOM w0.127: v1(164.27,108.39) 163.63,107.76 163.63,107.18 164.01,106.8 R11062.2 ; v3(124.1,121.34) 124.09,121.34 123.74,120.99 U35.E30
SATA_RXN3/PEG_RXN10_L1_N: length 2.3
  BOTTOM w0.127: CN23.43 164.25,104.4 164.37,104.52 164.37,105.19 R11062.1
SATA_RXP0: length 172.4
  IN3 w0.076: 129.39,122.45 129.39,122.44 129.42,122.41 129.42,122.01 129.86,121.57 129.86,120.67 129.73,120.54 129.62,120.54 129.47,120.69 v3(129.47,120.69)
  IN3 w0.114: v1(221.42,39.64) 221.26,39.49 220.88,39.49 215.3,45.07 215.3,46.78 212.73,49.35 212.73,50.05 211.61,51.18 211.03,51.18 208.24,53.97 196.42,53.97 195.51,54.88 193.99,54.88 193,55.87 189.08,55.87 184.44,60.52 184.44,61.81 181.6,64.64 179.25,64.64 176.31,67.58 176.31,87.87 172.62,91.55 172.62,99.16 167.57,104.21 167.57,107.08 166.45,108.2 166.45,115.63 165.11,116.98 165.11,120.36 165.32,120.58 165.32,122.05 165.11,122.27 165.11,123.9 163.8,125.2 163.8,128.2 161.82,130.18 153.16,130.18 152.92,129.94 149.03,129.94 148.65,130.32 145.02,130.32 144.67,129.97 137.07,129.97 135.27,128.16 132.22,128.16 130.13,126.07 130.13,125.03 129.39,124.29 129.39,122.45
  BOTTOM w0.127: C504.2 224.21,38.38 224.21,38.87 223.44,39.64 v1(221.42,39.64) ; v3(129.47,120.69) 129.77,120.99 U35.E20
SATA_RXP0_C: length 9.5
  BOTTOM w0.127: C504.1 224.21,37.35 223.98,37.12 223.98,36.88 v1(224.49,36.37) 224.44,36.37 223.98,35.91 223.98,35.86 224.19,35.66 226.8,35.66 228.07,34.39 229.56,34.39 CN14.6
SATA_RXP1: length 141.8
  IN3 w0.076: v3(128.58,120.64) 128.48,120.54 128.3,120.54 128.2,120.64 128.2,121.56 127.69,122.07 127.69,122.4 127.72,122.43 127.72,122.45
  IN3 w0.114: 127.72,122.45 127.72,122.61 126.8,123.53 126.8,126.59 131.58,131.36 132.51,131.36 133.68,132.53 141.71,132.53 141.89,132.71 152.63,132.71 153.54,133.62 158.55,133.62 159.34,132.84 164.2,132.84 165.06,131.98 165.06,131.08 165.82,130.32 166.81,130.32 168.03,129.1 168.03,123.32 168.87,122.48 168.87,114.58 169.45,114 169.45,108.81 176.16,102.1 190.28,102.1 191.45,103.27 211.89,103.27 214.18,100.98 219.32,100.98 220.44,99.86 226.21,99.86 226.63,100.29 226.94,100.29 v1(227.41,100.76)
  BOTTOM w0.127: C743.2 229.54,99.48 229.34,99.28 228.15,99.28 227.16,100.27 227.16,100.5 v1(227.41,100.76) ; v3(128.58,120.64) 128.88,120.34 U35.F21
SATA_RXP1_C: length 4.8
  BOTTOM w0.127: CN9.6 233.51,97.77 233.01,97.77 231.32,99.46 230.7,99.46 C743.1
SATA_RXP3/PEG_RXP9_L0: length 75.4
  IN3 w0.076: 129.95,122.45 129.95,122.43 129.98,122.4 129.98,121.99 130.33,121.64 130.33,119.61 129.73,119.01 128.45,119.01 127.86,119.59 125.64,119.59 125.42,119.81 125.42,120.86 v3(125.86,121.3)
  IN3 w0.114: 129.95,122.45 129.95,122.8 130.38,123.23 130.38,123.69 131.53,124.83 131.53,126.07 132.63,127.17 135.55,127.17 136.66,128.29 139.18,128.29 139.69,128.8 153.15,128.8 153.68,129.33 161.12,129.33 162.95,127.5 162.95,123.84 164.24,122.55 164.24,116.6 165.59,115.25 165.59,114.16 165.28,113.85 165.02,113.85 v1(164.83,113.66)
  BOTTOM w0.127: v1(164.83,113.66) 165.18,114.02 167.26,114.02 168.2,113.07 168.2,111.97 167.61,111.37 167.61,106.51 167.43,106.33 R958.2 ; v3(125.86,121.3) 125.74,121.18 125.54,121.18 U35.E27
SATA_RXP3/PEG_RXP9_L0_N: length 2.3
  BOTTOM w0.127: CN23.31 167.25,104.35 167.39,104.49 167.39,105.22 R958.1
SATA_RXP3/PEG_RXP10_L1: length 70.7
  IN3 w0.076: 131.13,121.78 130.87,121.51 130.87,119.08 130.07,118.28 128.45,118.28 127.79,118.94 125.12,118.94 124.33,119.74 124.33,120.28 124.48,120.43 124.48,120.7 124.36,120.82 124.2,120.82 v3(124.05,120.67)
  IN3 w0.114: 131.13,121.78 131.5,122.15 131.5,123.21 132.64,124.35 132.64,125.62 133.1,126.08 136.15,126.08 137.27,127.2 139.93,127.2 140.44,127.71 154.41,127.71 154.96,128.25 160.66,128.25 161.87,127.04 161.87,123.35 163.15,122.07 163.15,108.58 163.56,108.17 163.86,108.17 v1(164.27,107.76)
  BOTTOM w0.127: v3(124.05,120.67) 123.72,120.34 U35.F30 ; R11061.2 164.55,106.33 164.47,106.4 164.47,106.7 163.89,107.28 163.89,107.61 164.03,107.76 v1(164.27,107.76)
SATA_RXP3/PEG_RXP10_L1_N: length 2.3
  BOTTOM w0.127: CN23.41 164.75,104.41 164.62,104.54 164.62,105.14 R11061.1
SATA_TXN0: length 176.8
  IN3 w0.114: v1(128.37,125.02) 129.07,125.02 129.47,125.42 129.47,126.29 132.69,129.51 133.71,129.51 134.14,129.94 136.15,129.94 136.81,130.6 143.97,130.6 144.35,130.98 154.08,130.98 154.26,130.8 162.09,130.8 164.42,128.47 164.42,125.48 165.74,124.16 165.74,122.73 165.94,122.53 165.94,120.11 165.74,119.91 165.74,117.29 167.14,115.89 167.14,113.87 167.65,113.36 167.65,108.05 168.2,107.49 168.2,104.47 173.31,99.37 173.31,96.13 174.71,94.74 174.71,90.55 176.99,88.26 176.99,67.87 179.41,65.45 181.77,65.45 185.12,62.1 185.12,61.14 189.6,56.66 193.15,56.66 193.89,55.93 197.42,55.93 198.05,55.3 203.73,55.3 204.02,55.01 208.78,55.01 213.39,50.39 213.39,49.66 216.24,46.81 216.24,45.52 219.19,42.56 219.89,42.56 222.21,40.25 222.21,34.41 222.89,33.73 223.93,33.73 224.24,34.03 v1(224.24,34.69)
  BOTTOM w0.114: U35.B21 128.42,123.37 128.42,123.89 128.61,124.08 128.61,124.77 v1(128.37,125.02)
  BOTTOM w0.127: v1(224.24,34.69) 224.08,34.54 224.08,34.19 C513.2
SATA_TXN0_C: length 9.4
  BOTTOM w0.127: CN14.3 229.61,30.63 228.89,30.63 228.18,31.34 224.06,31.34 223.96,31.44 223.96,31.62 224.41,32.07 v1(224.47,32.07) 223.96,32.58 223.96,32.79 224.2,33.03 C513.1
SATA_TXN1: length 149.2
  IN3 w0.114: v3(128.59,121.26) 128.59,121.43 129.01,121.85 129.01,122.65 127.72,123.95 127.72,126.11 131.04,129.43 131.37,129.43 132.31,130.37 132.76,130.37 134.07,131.68 136.53,131.68 136.74,131.46 143.51,131.46 143.89,131.85 153.41,131.85 154.23,132.66 158.05,132.66 158.74,131.97 162.14,131.97 165.27,128.84 165.27,126.2 167.09,124.39 167.09,118.29 168,117.37 168,114.23 168.51,113.72 168.51,108.48 171.79,105.21 171.79,103.91 174.46,101.24 212.33,101.24 213.47,100.1 215.76,100.1 216.87,98.99 216.87,96.01 218.5,94.38 218.5,89.43 224.44,83.48 228.24,83.48 228.76,84 228.76,84.81 228.45,85.11 v1(227.77,85.11)
  BOTTOM w0.127: U35.D21 128.73,121.4 v3(128.59,121.26) ; v1(227.77,85.11) 227.95,84.93 228.34,84.93 C749.2
SATA_TXN1_C: length 12.9
  BOTTOM w0.127: C749.1 229.91,85.01 230.68,85.01 230.82,85.14 230.82,85.36 v1(230.31,85.87) 230.82,86.38 230.82,88.52 232.34,90.04 232.34,93.37 232.89,93.92 233.47,93.92 CN9.3
SATA_TXN3/PEG_TXN9_L0: length 63.2
  IN1 w0.089: v1(167.19,111.91) 166.97,112.12 166.72,112.12 166.54,112.3 166.54,115.48 159.31,122.7 159.31,125.38 157.89,126.8 153.98,126.8 152.8,127.99 149.06,127.99 148.42,128.63 137.43,128.63 136.43,127.63 128.05,127.63 127.07,126.65 126.03,126.65 v1(125.79,126.41)
  BOTTOM w0.076: U35.D24 126.82,122.31 126.52,122.6 126.52,126.15 126.43,126.24 126.43,126.26
  BOTTOM w0.127: v1(167.19,111.91) 166.89,112.2 166.59,112.2 166.05,111.65 166.05,109.64 165.92,109.52 165.92,108.36 166.05,108.23 C1176.1 ; v1(125.79,126.41) 125.88,126.5 126.23,126.5 126.43,126.29 126.43,126.26
SATA_TXN3/PEG_TXN9_L0_N: length 4.2
  BOTTOM w0.127: CN23.35 166.25,104.38 166.1,104.53 166.1,107.12 C1176.2
SATA_TXN3/PEG_TXN10_L1: length 59.2
  IN1 w0.089: v1(125.91,125.24) 126.66,125.24 128.45,127.03 136.81,127.03 137.8,128.03 148.17,128.03 148.82,127.39 152.55,127.39 153.74,126.2 157.23,126.2 158.58,124.85 158.58,122.56 165.92,115.22 165.92,111.98 165.72,111.78 v1(165.08,111.78)
  BOTTOM w0.076: U35.A25 126.25,124.23 126.33,124.3 126.33,124.83 v1(125.91,125.24)
  BOTTOM w0.127: C4664.1 162.74,108.11 162.49,108.36 162.49,109.69 164.7,111.91 164.95,111.91 v1(165.08,111.78)
SATA_TXN3/PEG_TXN10_L1_N: length 4.7
  BOTTOM w0.127: CN23.47 163.25,104.34 163.13,104.47 163.13,104.61 163.12,104.61 163.12,104.8 162.62,105.31 162.62,105.66 v1(163.12,106.17) 162.62,106.67 162.62,106.94 C4664.2
SATA_TXP0: length 176.8
  IN3 w0.114: v1(223.6,34.69) 224.01,34.28 224.01,34.13 223.84,33.96 222.98,33.96 222.43,34.51 222.43,40.35 219.99,42.79 219.28,42.79 216.46,45.61 216.46,46.91 213.62,49.75 213.62,50.49 208.87,55.24 204.11,55.24 203.83,55.53 198.14,55.53 197.52,56.15 193.99,56.15 193.25,56.89 189.69,56.89 185.35,61.23 185.35,62.19 181.86,65.68 179.51,65.68 177.22,67.96 177.22,88.35 174.94,90.64 174.94,94.83 173.54,96.23 173.54,99.46 168.43,104.57 168.43,107.59 167.87,108.15 167.87,113.46 167.37,113.96 167.37,115.99 165.97,117.39 165.97,119.81 166.17,120.02 166.17,122.63 165.97,122.83 165.97,124.25 164.65,125.57 164.65,128.57 162.19,131.03 154.35,131.03 154.18,131.21 144.26,131.21 143.88,130.83 136.72,130.83 136.06,130.17 134.05,130.17 133.62,129.74 132.59,129.74 129.24,126.39 129.24,125.51 128.97,125.25 128.75,125.25 v1(128.35,125.65)
  BOTTOM w0.114: U35.A21 128.73,123.91 128.82,124 128.82,125.33 128.5,125.65 v1(128.35,125.65)
  BOTTOM w0.127: v1(223.6,34.69) 223.83,34.46 223.83,34.19 C522.2
SATA_TXP0_C: length 9.4
  BOTTOM w0.127: C522.1 223.7,32.78 223.7,32.58 v1(223.2,32.07) 223.7,31.57 223.7,31.34 223.96,31.08 228.07,31.08 228.78,30.37 229.72,30.37 229.72,30.37 229.97,30.37 CN14.2
SATA_TXP1: length 149.3
  IN3 w0.114: v1(227.77,84.47) 228.17,84.88 228.36,84.88 228.53,84.71 228.53,84.09 228.15,83.71 224.53,83.71 218.73,89.52 218.73,94.48 217.1,96.1 217.1,99.08 215.86,100.32 213.57,100.32 212.43,101.47 174.55,101.47 172.01,104.01 172.01,105.3 168.74,108.58 168.74,113.81 168.23,114.32 168.23,117.47 167.32,118.38 167.32,124.48 165.5,126.3 165.5,128.94 162.24,132.2 158.83,132.2 158.15,132.89 154.13,132.89 153.32,132.07 143.8,132.07 143.41,131.69 136.84,131.69 136.62,131.91 133.98,131.91 132.67,130.6 132.22,130.6 131.28,129.66 130.95,129.66 127.49,126.2 127.49,123.85 128.78,122.56 128.78,121.94 128.58,121.74 128.4,121.74 128.19,121.95 v3(128.19,122.23)
  BOTTOM w0.127: U35.C21 128.37,122.41 v3(128.19,122.23) ; C751.2 228.44,84.68 227.97,84.68 v1(227.77,84.47)
SATA_TXP1_C: length 12.9
  BOTTOM w0.127: C751.1 229.96,84.75 230.79,84.75 231.07,85.03 231.07,85.36 v1(231.58,85.87) 231.07,86.38 231.07,88.41 232.59,89.94 232.59,93.26 233,93.67 233.55,93.67 CN9.2
SATA_TXP3/PEG_TXP9_L0: length 63.2
  IN1 w0.089: v1(167.19,112.54) 166.96,112.31 166.8,112.31 166.73,112.38 166.73,115.55 159.51,122.78 159.51,125.45 157.97,126.99 154.06,126.99 152.87,128.18 149.14,128.18 148.5,128.82 137.35,128.82 136.35,127.82 127.97,127.82 126.99,126.84 125.99,126.84 v1(125.79,127.05)
  BOTTOM w0.076: 126.69,126.26 126.69,123.32 127.03,122.98 127.03,122.83 126.94,122.74 U35.C24
  BOTTOM w0.127: v1(167.19,112.54) 167.1,112.45 166.49,112.45 165.79,111.76 165.79,109.75 165.66,109.62 165.66,108.49 C1177.1 ; v1(125.79,127.05) 126.08,126.75 126.33,126.75 126.69,126.4 126.69,126.26
SATA_TXP3/PEG_TXP9_L0_N: length 4.2
  BOTTOM w0.127: CN23.37 165.75,104.41 165.84,104.51 165.84,107.02 C1177.2
SATA_TXP3/PEG_TXP10_L1: length 59.2
  IN1 w0.089: v1(125.91,124.61) 125.91,124.66 126.31,125.05 126.74,125.05 128.53,126.84 136.89,126.84 137.88,127.84 148.1,127.84 148.74,127.2 152.47,127.2 153.66,126.01 157.15,126.01 158.39,124.77 158.39,122.49 165.73,115.15 165.73,112.06 165.64,111.97 165.46,111.97 165.02,112.41 v1(164.85,112.41)
  BOTTOM w0.076: U35.B25 126.25,123.13 125.94,123.44 125.94,124.07 126.02,124.15 126.02,124.51 v1(125.91,124.61)
  BOTTOM w0.127: v1(164.85,112.41) 162.24,109.8 162.24,108.36 C4665.1
SATA_TXP3/PEG_TXP10_L1_N: length 4.7
  BOTTOM w0.127: CN23.49 162.75,104.34 162.87,104.47 162.87,104.56 162.87,104.56 162.87,104.69 162.36,105.2 162.36,105.66 v1(161.85,106.17) 162.36,106.67 162.36,106.94 C4665.2
SATAGP0: length 7.2
  BOTTOM w0.127: R568.2 R570.2 143.69,122.45 141.13,119.88 140.18,119.88 U35.H2
SATAGP1: length 9.6
  BOTTOM w0.127: U35.H3 139.57,119.16 140.76,119.16 142.65,121.05 143.19,121.05 144.1,121.97 145.88,121.97 146.06,122.14 v1(146.59,122.14) 146.86,121.87 R569.1
SB_ACDC: length 88.5
  IN3 w0.114: v1(166.04,81.35) 166.04,77.34 167.19,76.2 167.19,73.3 166.68,72.79 166.68,68.44 167.13,68 167.13,66.64 169.77,64 169.77,61.47 170.97,60.27 170.97,53.61 172.24,52.33 172.24,49.77 172.95,49.06 172.95,44.11 175.01,42.05 175.01,37.96 v1(174.43,37.37)
  BOTTOM w0.127: v1(166.04,81.35) 165.8,81.11 155.57,81.11 154.56,80.09 148.5,80.09 140.95,87.65 137.85,87.65 134.8,90.69 R676.1 ; v1(174.43,37.37) 173.73,36.67 172.47,36.67 172.4,36.6 U45.84
SD_CLK_R: length 2.3
  TOP w0.127: R11141.1 32.43,23.38 32.37,23.32 32.37,23.24 CN4.5
SEN_A0: length 8.4
  TOP w0.127: R4547.2 202.6,164.74 v1(202.49,164.84)
  IN1 w0.089: v3(196.93,161.75) 197.38,162.2 200.26,162.2 200.51,162.45 200.51,163.01 202.34,164.84 v1(202.49,164.84)
  BOTTOM w0.14: VRAM3000.J10 196.59,161.42 v3(196.93,161.75)
SEN_A1: length 7.5
  TOP w0.14: VRAM3004.J10 196.9,161.05 v3(196.91,161.03)
  IN1 w0.089: v1(202.47,161.89) 201.19,160.61 197.33,160.61 v3(196.91,161.03)
  BOTTOM w0.127: v1(202.47,161.89) 202.67,161.69 R4550.2
SEN_A2: length 8.8
  TOP w0.127: R4553.2 166.25,158.39 v1(166.33,158.47) 166.48,158.62 v1(167.01,158.62) ; VRAM3001.J10 172.12,161.02 v3(172.1,161.02)
  IN1 w0.089: v1(166.33,158.47) 166.45,158.47 168.57,160.59 171.66,160.59 v3(172.1,161.02)
