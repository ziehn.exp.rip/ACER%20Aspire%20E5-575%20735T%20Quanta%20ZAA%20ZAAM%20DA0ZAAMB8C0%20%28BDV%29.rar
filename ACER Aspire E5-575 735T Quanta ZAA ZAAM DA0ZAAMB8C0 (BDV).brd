# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ42: length 79.3
  IN1 w0.089: v1(122.9,92.72) 122.9,92.41 123.48,91.84 123.88,91.84 126.04,89.68 126.42,89.68 126.69,89.42 126.69,80.19 126.93,79.95 127.56,79.95 128.32,79.2 128.32,79.02 128.49,78.85 128.66,78.85 131.63,75.89 131.63,75.56 132.52,74.67 132.52,74.31 132.71,74.12 133.07,74.12 134.17,73.02 134.17,72.84 133.88,72.55 133.88,72.42 134.04,72.26 134.16,72.26 134.6,72.7 134.74,72.7 134.84,72.6 134.84,72.46 134.41,72.02 134.41,71.89 134.61,71.68 134.61,70.95 135.06,70.5 135.41,70.5 135.54,70.38 135.54,70.12 135.26,69.84 135.26,69.7 135.36,69.6 135.51,69.6 136.48,70.57 136.64,70.57 136.78,70.44 136.78,70.33 135.78,69.34 135.78,69.18 135.89,69.06 136.05,69.06 136.65,69.66 136.79,69.66 136.89,69.56 136.89,69.42 136.28,68.81 136.28,68.68 136.48,68.47 136.82,68.47 136.92,68.37 136.92,68.23 136.82,68.13 136.49,68.13 136.42,68.05 136.42,67.88 136.52,67.78 136.82,67.78 136.92,67.68 136.92,67.53 136.82,67.43 136.55,67.43 136.45,67.33 136.45,67.19 136.55,67.09 136.82,67.09 136.92,66.99 136.92,66.85 136.82,66.75 136.52,66.75 136.42,66.65 136.42,66.53 136.54,66.4 136.76,66.4 136.91,66.25 136.91,66.01 136.72,65.82 136.72,65.42 136.91,65.24 136.91,64.67 137.67,63.91 138.02,63.56 138.02,63.22 138.13,63.1 138.55,63.1 138.68,62.98 138.68,62.84 138.55,62.71 138.08,62.71 138.02,62.65 138.02,62 138.08,61.93 138.08,61.34 138.02,61.27 138.02,60.47 138.11,60.38 138.59,60.38 138.68,60.29 138.68,60.07 138.59,59.98 138.11,59.98 138.02,59.89 138.02,59.6 138.11,59.51 138.59,59.51 138.68,59.42 138.68,59.21 138.59,59.12 138.11,59.12 138.02,59.03 138.02,58.31 138.14,58.19 138.14,57.84 138.02,57.72 138.02,57.39 138.16,57.25 138.16,56.97 138.02,56.83 138.02,56.37 138.08,56.31 138.31,56.31 138.41,56.2 138.41,55.88 137.33,54.8 137.33,54.6 137.42,54.51 137.62,54.51 137.71,54.42 137.71,54.2 137.62,54.11 137.42,54.11 137.33,54.03 137.33,53.81 137.42,53.72 137.62,53.72 137.71,53.63 137.71,53.42 137.62,53.33 137.42,53.33 137.33,53.24 137.33,52.27 136.77,51.71 136.77,51.1 136.2,50.53 136.19,50.53 135.5,49.84 135.5,49.56 135.61,49.45 135.77,49.45 135.88,49.56 135.88,49.68 135.96,49.76 v1(136.2,49.76)
  BOTTOM w0.076: v1(122.9,92.72) 123.5,93.32 123.5,98.32 122.76,99.05 122.76,100.32 122.6,100.49 122.6,100.68 122.65,100.74 122.78,100.86 122.78,101.23 122.67,101.46 122.62,101.57 122.62,101.91 122.35,102.18 U35.AY33
  BOTTOM w0.127: JDIM1.207 136.22,50.18 136.2,50.16 v1(136.2,49.76)
M_A_DQ43: length 78.4
  IN1 w0.089: v1(136.2,48.49) 136.2,47.08 136.29,46.99 136.59,46.99 136.68,47.08 136.68,50.57 137.06,50.95 137.06,51.59 137.62,52.15 137.62,52.57 137.71,52.66 137.99,52.66 138.11,52.78 138.11,52.98 138,53.08 138,54.23 138.15,54.38 138.15,54.6 137.95,54.8 137.95,55.01 138.22,55.27 138.46,55.27 138.72,55.53 138.72,55.82 138.87,55.98 139.17,55.98 139.3,56.11 139.3,56.36 138.97,56.69 138.97,57.64 139.06,57.73 139.38,57.73 139.5,57.86 139.5,58 139.38,58.13 139.06,58.13 138.97,58.22 138.97,59.44 139.12,59.59 139.53,59.59 139.64,59.71 139.64,59.87 139.53,59.99 139.12,59.99 138.97,60.14 138.97,61.33 139.06,61.42 139.55,61.42 139.67,61.53 139.67,61.69 139.54,61.81 139.06,61.81 138.97,61.9 138.97,62.12 139.06,62.21 139.5,62.21 139.59,62.3 139.59,62.45 139.44,62.6 139.06,62.6 138.97,62.69 138.97,63.1 137.22,64.85 137.22,70.76 136.89,71.09 136.59,71.09 136.06,70.56 135.93,70.56 135.77,70.56 135.5,70.83 135.24,70.83 134.98,71.09 134.98,72.16 135.18,72.36 135.18,72.75 134.94,72.99 134.61,72.99 131.92,75.68 131.92,76.01 127.68,80.25 127.2,80.25 126.98,80.46 126.98,89.43 126.55,89.86 126.11,89.86 123.35,92.62 123.35,93.24 123.23,93.36 v1(122.9,93.36)
  BOTTOM w0.076: v1(122.9,93.36) 121.9,94.36 121.9,99.05 121.25,99.71 121.25,100.35 121.45,100.55 121.45,101.22 121.45,101.22 121.42,101.31 121.42,101.51 121.45,101.6 121.45,101.6 121.46,101.6 121.46,101.61 121.46,101.84 121.42,101.97 121.42,102.22 121.49,102.32 121.49,102.83 121.69,103.04 U35.AW33
  BOTTOM w0.127: v1(136.2,48.49) 135.77,48.49 135.03,49.22 135.03,50.21 135.22,50.4 JDIM1.203
M_A_DQ44: length 77.3
  IN1 w0.089: v1(131.73,44.65) 131.73,43.25 131.88,43.1 134.64,43.1 134.78,43.24 134.78,43.44 134.64,43.58 133.28,43.58 133.13,43.73 133.13,44.46 132.99,44.6 132.79,44.6 132.64,44.46 132.64,43.71 132.52,43.58 132.31,43.58 132.16,43.73 132.16,47.27 132.31,47.42 132.91,47.42 133.06,47.57 133.06,48.54 133.83,49.3 133.83,50.52 135.1,51.79 135.1,55.5 135.78,56.19 135.78,59.67 135.95,59.84 136.2,59.84 136.33,59.96 136.33,62.48 134.37,64.44 134.37,68.21 133.41,69.17 133.41,69.78 132.94,70.25 132.94,71.01 125.02,78.92 125.02,89.41 123.61,90.82 123.41,90.82 121.93,92.3 121.93,97.54 121.33,98.14 v1(121.15,98.14)
  BOTTOM w0.076: v1(121.15,98.14) 121.55,98.53 121.55,98.94 120.92,99.57 120.92,100.52 120.92,100.52 120.92,100.98 U35.BB35
  BOTTOM w0.127: JDIM1.190 131.97,44.4 v1(131.73,44.65)
M_A_DQ45: length 77.8
  IN1 w0.089: v1(136.2,44.68) 135.79,45.09 135.79,46.17 135.65,46.31 135.45,46.31 135.32,46.17 135.32,45.61 135.23,45.53 134.69,45.53 134.55,45.39 134.55,45.19 134.69,45.06 135.23,45.06 135.37,44.92 135.37,44.52 135.23,44.38 134.04,44.38 132.91,45.51 132.91,46.44 133.36,46.88 133.36,48.17 133.52,48.33 133.97,48.33 134.12,48.49 134.12,50.4 135.39,51.67 135.39,55.38 135.93,55.92 136.37,55.92 136.65,56.19 136.65,58.99 136.36,59.28 136.36,59.55 136.65,59.84 136.65,62.57 135.99,63.23 135.99,63.35 136.08,63.44 136.08,63.56 135.87,63.77 135.74,63.77 135.66,63.68 135.53,63.68 135.32,63.89 135.32,64.02 135.41,64.1 135.41,64.23 135.2,64.44 135.08,64.44 134.99,64.35 134.87,64.35 134.66,64.56 134.66,65.37 134.75,65.46 134.91,65.46 135.04,65.6 135.04,65.79 134.91,65.93 134.75,65.93 134.66,66.02 134.66,66.31 134.75,66.4 134.91,66.4 135.04,66.54 135.04,66.73 134.91,66.87 134.75,66.87 134.66,66.96 134.66,67.25 134.75,67.34 134.91,67.34 135.04,67.48 135.04,67.67 134.91,67.81 134.75,67.81 134.66,67.9 134.66,68.33 133.7,69.29 133.7,69.9 133.23,70.37 133.23,71.13 125.32,79.04 125.32,89.43 124.05,90.7 123.74,91 123.48,91 122.12,92.36 122.12,98.45 121.8,98.78 v1(121.15,98.78)
  BOTTOM w0.076: v1(121.15,98.78) 121.15,99.1 120.75,99.5 120.75,100.58 120.75,100.59 120.75,101.25 121.02,101.51 U35.BA35
  BOTTOM w0.127: JDIM1.208 136.47,44.4 v1(136.2,44.68)
M_A_DQ46: length 78.3
  IN1 w0.089: v1(136.2,45.95) 136.61,45.54 136.61,45.05 136.7,44.96 136.88,44.96 136.96,45.05 136.96,45.87 136.71,46.12 136.71,46.49 136.98,46.76 136.98,50.45 137.36,50.83 137.36,51.47 138.87,52.98 138.87,55.26 140.01,56.41 140.01,62.5 137.53,64.98 137.53,70.85 136.87,71.52 136.6,71.52 136.26,71.17 136.09,71.17 135.98,71.29 135.98,71.45 136.41,71.89 136.41,72.06 136.29,72.19 136.13,72.19 135.69,71.75 135.51,71.75 135.39,71.88 135.39,72.05 135.74,72.41 135.74,72.73 134.52,73.95 134.39,73.95 134.29,73.85 134.17,73.85 134.01,74.01 134.01,74.13 134.11,74.23 134.11,74.36 133.96,74.51 133.83,74.51 133.73,74.41 133.61,74.41 133.46,74.56 133.46,74.69 133.55,74.79 133.55,74.91 133.4,75.07 133.28,75.07 133.18,74.97 133.05,74.97 132.9,75.12 132.9,75.25 133,75.35 133,75.47 132.84,75.62 132.72,75.62 132.62,75.53 132.49,75.53 132.34,75.68 132.34,75.8 132.44,75.9 132.44,76.03 130.43,78.03 130.43,78.56 130.2,78.79 130.07,78.79 129.88,78.59 129.75,78.59 129.6,78.75 129.6,78.87 129.8,79.07 129.8,79.2 129.64,79.35 129.52,79.35 129.32,79.15 129.19,79.15 129.04,79.3 129.04,79.43 129.24,79.63 129.24,79.75 129.08,79.91 128.96,79.91 128.76,79.71 128.64,79.71 128.48,79.86 128.48,79.99 128.68,80.19 128.68,80.31 128.53,80.46 128.4,80.46 128.2,80.27 128.08,80.27 127.8,80.54 127.46,80.54 127.27,80.73 127.27,89.45 126.66,90.06 126.16,90.06 123.65,92.57 123.65,93.36 123.49,93.53 123.49,96.32 123.28,96.53 v1(122.9,96.53)
  BOTTOM w0.076: v1(122.9,96.53) 123.33,96.95 123.33,98.26 122.6,98.99 122.6,100.22 122.44,100.39 122.44,100.75 122.61,100.93 122.61,101.19 122.5,101.44 122.49,101.44 122.49,101.45 122.35,101.59 U35.BA33
  BOTTOM w0.127: JDIM1.204 135.47,45.22 v1(136.2,45.95)
M_A_DQ47: length 77.1
  IN1 w0.089: v1(122.9,97.8) 123.78,96.92 123.78,93.67 123.96,93.49 123.96,92.51 126.23,90.24 126.76,90.24 127.6,89.4 127.6,81.87 130.74,78.73 130.74,78.15 137.85,71.04 137.85,65.11 140.33,62.63 140.33,56.28 139.19,55.13 139.19,52.89 137.65,51.35 137.65,50.71 137.27,50.33 137.27,44.9 136.45,44.09 133.91,44.09 132.62,45.38 v1(132.62,46.86)
  BOTTOM w0.076: v1(122.9,97.8) 122.9,98.28 122.43,98.75 122.43,100.15 122.27,100.32 122.27,100.88 122.35,100.95 U35.BB33
  BOTTOM w0.127: v1(132.62,46.86) 132.11,47.37 132.11,50.34 132.22,50.45 JDIM1.191
M_A_DQ48: length 72.6
  IN1 w0.089: v1(124.81,92.97) 124.81,92.16 126.38,90.6 126.93,90.6 127.72,89.81 128.08,89.81 128.49,89.39 128.49,88.76 128.58,88.67 128.76,88.67 128.9,88.54 128.9,88.34 128.76,88.2 128.58,88.2 128.49,88.11 128.49,87.82 128.58,87.73 128.76,87.73 128.9,87.6 128.9,87.4 128.76,87.26 128.58,87.26 128.49,87.17 128.49,86.88 128.83,86.54 128.83,83.8 128.49,83.46 128.49,83 128.83,82.66 128.83,81.9 131.63,79.1 131.63,78.79 131.86,78.56 132.12,78.56 132.38,78.3 132.38,78.04 132.52,77.9 132.81,77.9 133.04,77.66 133.04,77.1 133.25,76.9 133.38,76.9 133.59,77.11 133.78,77.11 133.92,76.97 133.92,76.78 133.74,76.6 133.74,76.4 133.88,76.27 134.08,76.27 134.26,76.45 134.45,76.45 134.59,76.31 134.59,76.11 134.41,75.93 134.41,75.74 134.55,75.6 134.74,75.6 134.92,75.78 135.11,75.78 135.25,75.64 135.25,75.45 135.04,75.23 135.04,75.11 139.63,70.52 139.63,67.01 139.48,66.86 138.88,66.86 138.74,66.72 138.74,66.29 138.84,66.19 139.1,66.19 139.3,66.39 139.51,66.39 139.66,66.25 139.66,66.05 139.51,65.91 139.43,65.91 139.25,65.73 139.25,64.97 141.79,62.43 141.79,56.41 140.12,54.74 140.12,52.57 138.54,50.98 138.54,49.46 v1(137.89,48.81)
  BOTTOM w0.076: U35.AY31 123.65,102.18 123.38,101.92 123.38,101.63 123.22,101.22 123.22,100.76 123.23,100.75 123.23,99.86 123.66,99.42 123.66,94.13 124.81,92.98 v1(124.81,92.97)
  BOTTOM w0.127: JDIM1.211 137.22,49.47 v1(137.89,48.81)
M_A_DQ49: length 72.5
  IN1 w0.089: v1(137.89,50.1) 138.25,50.46 138.25,51.1 139.81,52.67 139.81,54.88 140.93,56 140.93,59.36 141.15,59.58 141.15,59.87 140.93,60.09 140.93,62.88 138.87,64.94 138.87,65.54 138.45,65.96 138.45,67.15 138.54,67.24 139.2,67.24 139.34,67.38 139.34,67.57 139.2,67.71 138.59,67.71 138.45,67.85 138.45,68.04 138.59,68.18 139.2,68.18 139.34,68.32 139.34,68.51 139.2,68.65 138.59,68.65 138.45,68.79 138.45,68.98 138.59,69.12 139.2,69.12 139.34,69.26 139.34,69.45 139.2,69.59 138.59,69.59 138.45,69.73 138.45,69.92 138.59,70.06 139.2,70.06 139.34,70.2 139.34,70.39 139.2,70.53 138.54,70.53 138.45,70.62 138.45,71.29 132.67,77.07 132.67,77.19 132.75,77.27 132.75,77.47 132.61,77.6 132.42,77.6 132.34,77.52 132.21,77.52 132,77.73 132,77.86 132.09,77.94 132.09,78.13 131.95,78.27 131.75,78.27 131.67,78.19 131.55,78.19 131.34,78.4 131.34,78.98 128.38,81.93 128.38,82.7 128.2,82.88 128.2,83.79 128.29,83.88 128.4,83.88 128.54,84.01 128.54,84.21 128.4,84.35 128.29,84.35 128.2,84.43 128.2,84.73 128.29,84.82 128.4,84.82 128.54,84.95 128.54,85.15 128.4,85.29 128.29,85.29 128.2,85.37 128.2,85.81 128.38,86 128.38,86.58 128.2,86.76 128.2,89.27 127.92,89.55 127.71,89.55 126.84,90.42 126.3,90.42 124.39,92.33 124.39,97.43 124.05,97.77 124.05,98.28 124.48,98.71 v1(124.81,98.71)
  BOTTOM w0.076: v1(124.81,98.71) 125.02,98.92 125.02,99.23 124.84,99.42 124.84,100.42 124.54,100.72 124.54,101.23 124.55,101.26 124.59,101.34 124.59,101.46 124.52,101.68 124.52,101.82 124.58,101.98 124.58,102.16 124.5,102.32 124.5,102.83 124.3,103.04 U35.AW31
  BOTTOM w0.127: v1(137.89,50.1) 138.22,50.44 JDIM1.215
M_A_DQ50: length 71.5
  IN1 w0.089: v1(124.81,98.07) 125.99,96.9 125.99,92.34 126.65,91.69 127.46,91.69 128.2,90.95 128.83,90.95 130.85,88.93 130.85,84.48 133.05,82.28 133.05,80.74 137.48,76.3 137.48,75.43 137.73,75.19 137.85,75.19 138.15,75.49 138.33,75.49 138.51,75.31 138.51,75.18 138.19,74.85 138.19,74.73 138.39,74.52 138.52,74.52 138.84,74.85 138.97,74.85 139.18,74.64 139.18,74.52 138.85,74.19 138.85,74.06 139.06,73.86 139.18,73.86 139.51,74.18 139.63,74.18 139.84,73.98 139.84,73.85 139.52,73.52 139.52,73.4 139.72,73.19 139.85,73.19 140.17,73.52 140.3,73.52 140.51,73.31 140.51,73.19 140.18,72.86 140.18,72.73 140.39,72.53 140.51,72.53 140.84,72.85 140.96,72.85 141.17,72.65 141.17,72.52 140.85,72.19 140.85,72.07 141.64,71.28 141.64,70.95 141.73,70.86 142.26,70.86 142.37,70.75 142.37,70.5 142.26,70.39 141.73,70.39 141.64,70.3 141.64,68.1 142.77,66.97 142.77,64.71 144.38,63.09 144.38,56.05 142.51,54.18 142.51,51.72 141.33,50.53 v1(141.33,50.01)
  BOTTOM w0.076: U35.AY29 124.77,102.29 124.77,102.03 124.7,101.81 124.7,101.68 124.76,101.45 124.76,101.31 124.71,101.19 124.71,100.79 125.01,100.49 125.01,99.48 125.21,99.29 125.21,98.47 v1(124.81,98.07)
  BOTTOM w0.127: v1(141.33,50.01) 140.95,50.01 140.72,50.23 JDIM1.225
M_A_DQ51: length 72.5
  IN1 w0.089: v1(126.4,94.91) 127.18,94.14 127.18,92.96 128.43,91.71 129.16,91.71 131.73,89.15 131.73,86 131.91,85.82 131.91,85.39 131.73,85.21 131.73,84.84 131.97,84.6 132.1,84.6 132.28,84.77 132.42,84.77 132.61,84.58 132.61,84.44 132.46,84.28 132.46,84.11 132.62,83.95 132.79,83.95 132.94,84.11 133.09,84.11 133.25,83.94 133.25,83.75 133.1,83.6 133.1,83.47 134.08,82.49 134.08,80.98 143.25,71.81 143.25,67.72 143.87,67.1 143.87,64.99 145.38,63.47 145.38,62.56 145.93,62.01 145.93,56.16 144.27,54.5 144.27,52.12 142.71,50.57 142.71,46.43 v1(141.37,45.08)
  BOTTOM w0.076: v1(126.4,94.91) 126.14,94.91 126.04,95.02 126.04,95.38 125.81,95.61 125.81,99.39 125.5,99.7 125.5,100.7 125.4,100.79 125.4,101.74 125.18,101.96 125.18,102.51 124.87,102.82 U35.AW29
  BOTTOM w0.127: v1(141.37,45.08) 141.47,44.98 JDIM1.228
M_A_DQ52: length 70.8
  IN1 w0.089: v1(124.81,94.87) 125.41,94.28 125.41,92.07 126.4,91.08 126.95,91.08 127.86,90.16 128.35,90.16 129.48,89.03 129.48,82.08 133.66,77.9 133.89,77.9 136.11,75.68 136.11,74.86 140.26,70.71 140.26,64.93 142.42,62.77 142.42,56.14 140.76,54.48 140.76,52.38 139.25,50.87 139.25,49.26 138.94,48.96 138.94,46.63 139.1,46.48 139.84,46.48 140.01,46.31 140.01,46.14 139.86,45.99 138.76,45.99 v1(138.54,45.77)
  BOTTOM w0.076: U35.BB31 123.65,99.99 123.99,99.64 123.99,95.69 v1(124.81,94.87)
  BOTTOM w0.127: JDIM1.212 137.47,45.31 137.93,45.77 v1(138.54,45.77)
M_A_DQ53: length 71.2
  IN1 w0.089: v1(138.54,44.5) 138.54,43.76 138.36,43.58 138.08,43.58 137.94,43.72 137.94,47.86 138.49,48.41 138.49,48.91 138.83,49.26 138.83,50.86 140.44,52.47 140.44,54.61 142.11,56.28 142.11,62.64 139.95,64.79 139.95,70.61 135.69,74.87 135.69,75.08 135.82,75.2 135.82,75.56 133.89,77.49 133.66,77.49 129.19,81.95 129.19,89.07 128.28,89.99 127.79,89.99 126.95,90.82 126.4,90.82 125.21,92.01 125.21,93.84 v1(124.81,94.24)
  BOTTOM w0.076: v1(124.81,94.24) 123.83,95.22 123.83,99.49 123.42,99.9 123.42,100.9 123.38,100.93 123.38,101.19 123.5,101.44 123.5,101.44 123.51,101.45 123.65,101.59 U35.BA31
  BOTTOM w0.127: v1(138.54,44.5) 138.47,44.44 JDIM1.216
M_A_DQ54: length 71.2
  IN1 w0.089: v1(126.4,94.28) 126.98,93.7 126.98,92.87 128.39,91.46 129.09,91.46 131.44,89.11 131.44,84.72 133.79,82.37 133.79,80.86 142.96,71.69 142.96,67.6 143.55,67 143.55,64.85 145.09,63.32 145.09,62.27 145.22,62.15 145.38,62.15 145.52,62.01 145.52,61.81 145.38,61.68 145.23,61.68 145.09,61.54 145.09,61.34 145.23,61.21 145.38,61.21 145.52,61.07 145.52,60.87 145.38,60.74 145.18,60.74 145.09,60.65 145.09,55.77 143.95,54.63 143.95,52.22 142.42,50.69 142.42,46.63 142.15,46.35 v1(141.37,46.35)
  BOTTOM w0.076: U35.BA29 124.97,101.51 125.24,101.24 125.24,100.72 125.34,100.63 125.34,99.62 125.62,99.33 125.62,95.56 125.88,95.31 125.88,94.42 126.02,94.28 v1(126.4,94.28)
  BOTTOM w0.127: v1(141.37,46.35) 141.01,46.35 140.47,45.81 JDIM1.224
M_A_DQ55: length 70.3
  IN1 w0.089: v1(141.33,48.74) 141.33,47.9 141.45,47.77 141.79,47.77 141.96,47.94 141.96,50.68 142.86,51.57 142.86,53.99 144.77,55.9 144.77,63.19 143.24,64.72 143.24,66.91 141.93,68.22 141.93,68.92 142.04,69.03 142.29,69.03 142.42,69.17 142.42,69.36 142.29,69.5 142.04,69.5 141.93,69.62 141.93,69.88 142.04,70 142.42,70 142.66,70.24 142.66,70.9 142.17,71.39 142.17,71.52 142.37,71.72 142.37,71.86 142.17,72.06 142.04,72.06 141.72,71.74 141.59,71.74 141.38,71.94 141.38,72.07 141.71,72.4 141.71,72.52 133.41,80.82 133.41,82.34 131.15,84.6 131.15,89.02 128.96,91.21 128.36,91.21 126.89,92.67 126.73,92.67 126.4,93 v1(126.4,93.01)
  BOTTOM w0.076: U35.BB29 124.97,100.76 125.17,100.56 125.17,99.55 125.43,99.29 125.43,95.52 125.71,95.24 125.71,94.13 125.99,93.85 125.99,93.42 v1(126.4,93.01)
  BOTTOM w0.127: JDIM1.229 141.72,50.29 141.96,50.06 141.96,49.38 v1(141.33,48.74)
M_A_DQ56: length 75.4
  IN1 w0.089: v1(147.02,49.78) 147.04,49.78 150.04,52.78 150.04,55.51 151.47,56.93 151.47,62.8 149.13,65.14 149.13,67.83 147,69.96 147,75.19 139.48,82.71 139.48,82.9 139.64,83.07 139.64,83.22 139.48,83.38 139.29,83.38 139.15,83.24 138.95,83.24 138.81,83.37 138.81,83.57 138.96,83.72 138.96,83.91 138.82,84.05 138.63,84.05 138.48,83.9 138.29,83.9 138.15,84.04 138.15,84.23 138.28,84.37 138.28,84.56 138.14,84.7 137.95,84.7 137.81,84.57 137.62,84.57 137.48,84.7 137.48,84.9 137.64,85.06 137.64,85.26 137.51,85.39 137.31,85.39 137.15,85.23 136.96,85.23 136.82,85.37 136.82,85.56 136.99,85.74 136.99,85.93 136.85,86.07 136.66,86.07 136.49,85.9 136.29,85.9 136.15,86.03 136.15,86.23 136.29,86.37 136.29,86.56 136.15,86.7 135.96,86.7 135.79,86.53 135.66,86.53 135.44,86.75 135.44,89.24 130.46,94.22 130.46,95.17 129.09,96.54 129.09,97.73 128.63,98.19 127.78,98.19 v1(126.41,96.83)
  BOTTOM w0.076: v1(126.41,96.83) 126.97,97.38 126.97,99.27 126.16,100.08 126.16,100.82 126.27,100.93 126.27,101.19 126.23,101.28 126.23,101.29 126.23,101.54 126.27,101.63 126.27,101.84 126.24,101.92 126.2,102.02 126.2,102.29 U35.AY27
  BOTTOM w0.127: v1(147.02,49.78) 146.12,49.78 145.72,50.18 JDIM1.245
M_A_DQ57: length 75.6
  IN1 w0.089: v1(145.65,44.55) 146.57,45.47 146.57,48.61 146.39,48.79 146.39,49.91 147.92,51.45 147.92,54.1 149.15,55.33 149.15,57.95 149.38,58.18 149.38,63.65 147.87,65.16 147.87,68.67 146.7,69.84 146.7,75.07 135.15,86.63 135.15,89.12 130.13,94.13 130.13,94.99 129.34,95.78 129.14,95.78 128.77,96.15 128.77,97.62 128.47,97.92 127.93,97.92 126.93,96.92 126.93,96.71 v1(126.41,96.19)
  BOTTOM w0.076: U35.AW27 126.1,102.85 125.78,102.52 125.78,101.98 125.57,101.77 125.57,100.86 125.67,100.77 125.67,99.86 126.01,99.52 126.01,99.21
  BOTTOM w0.102: v1(126.41,96.19) 126.01,96.6 126.01,99.21
  BOTTOM w0.127: JDIM1.246 145.97,44.22 v1(145.65,44.55)
M_A_DQ58: length 75.5
  IN1 w0.089: v1(128.37,93.14) 128.77,93.14 133.48,88.43 133.48,85.38 133.69,85.18 133.82,85.18 133.93,85.29 134.13,85.29 134.27,85.16 134.27,84.96 134.18,84.88 134.18,84.68 134.32,84.55 134.52,84.55 134.6,84.63 134.79,84.63 134.93,84.49 134.93,84.3 134.85,84.21 134.85,84.02 134.99,83.88 135.18,83.88 135.26,83.96 135.46,83.96 135.6,83.83 135.6,83.63 135.48,83.51 135.48,83.39 135.93,82.94 135.93,81.95 136.12,81.76 136.69,81.76 137.08,82.15 137.27,82.15 137.41,82.01 137.41,81.81 137.07,81.47 137.07,81.25 137.23,81.09 137.44,81.09 137.78,81.43 137.99,81.43 138.49,80.93 138.49,79.68 141.53,76.63 141.53,75.9 143.53,73.9 143.53,73.19 144.01,72.72 144.26,72.47 144.89,71.84 144.89,67.83 146.17,66.55 146.17,64.47 147.72,62.92 147.72,58.88 147.12,58.28 147.12,55.67 146.14,54.7 146.14,52.22 144.56,50.63 144.56,50.25 144.47,50.16 144.14,50.16 144,50.02 144,49.82 144.14,49.69 144.49,49.69 144.61,49.57 144.61,49.19 143.78,48.37 143.78,46.1 143.66,45.97 v1(143.17,45.97)
  BOTTOM w0.076: U35.AY25 127.33,102.18 127.6,101.91 127.6,101.57 127.65,101.46 127.81,101.13 127.81,100.13 128.03,99.91
  BOTTOM w0.127: JDIM1.232 142.47,45.28 v1(143.17,45.97) ; v1(128.37,93.14) 128.91,93.68 v1(128.91,96.79) 128.91,97.64 128.79,97.76 128.79,99.15 128.03,99.91
M_A_DQ59: length 76
  IN1 w0.089: v1(143.17,44.7) 144.07,45.61 144.07,48.15 144.95,49.03 144.95,50.43 146.46,51.94 146.46,54.6 147.41,55.55 147.41,58.16 148.01,58.76 148.01,63.07 146.49,64.6 146.49,68.09 145.18,69.4 145.18,71.96 143.83,73.32 143.83,74.02 141.83,76.02 141.83,76.75 141.08,77.5 141.08,77.85 141.37,78.14 141.37,78.34 141.24,78.47 141.04,78.47 140.67,78.1 140.48,78.1 140.34,78.24 140.34,78.44 140.71,78.81 140.71,79 140.57,79.14 140.38,79.14 140.01,78.77 139.81,78.77 139.67,78.91 139.67,79.1 140.04,79.47 140.04,79.67 139.91,79.8 139.71,79.8 139.34,79.43 139.15,79.43 139.01,79.57 139.01,80.82 133.77,86.06 133.77,88.55 128.61,93.71 v1(128.1,93.71)
  BOTTOM w0.076: U35.AW25 126.68,103.04 126.47,102.83 126.47,102.32 126.4,102.22 126.4,101.97 126.44,101.84 126.44,101.61 126.44,101.6 126.43,101.6 126.43,101.6 126.4,101.51 126.4,101.31 126.43,101.22 126.43,100.86 126.33,100.75 126.33,100.17 126.92,99.57
  BOTTOM w0.102: 126.92,99.57 127.16,99.33 127.16,94.65 v1(128.1,93.71)
  BOTTOM w0.127: v1(143.17,44.7) 143.17,44.7 143.36,44.7 143.47,44.59 JDIM1.236
M_A_DQ60: length 73.7
  IN1 w0.089: v1(126.41,98.1) 127.09,98.1 127.44,98.44 128.81,98.44 129.39,97.86 129.39,96.87 131.55,94.72 131.55,93.54 135.73,89.36 135.73,87.6 139.96,83.37 139.96,82.64 140.24,82.36 140.37,82.36 140.54,82.53 140.73,82.53 140.87,82.39 140.87,82.2 140.7,82.03 140.7,81.9 140.91,81.69 141.03,81.69 141.19,81.85 141.38,81.85 141.52,81.71 141.52,81.52 141.36,81.36 141.36,81.24 141.57,81.03 141.7,81.03 141.78,81.11 141.97,81.11 142.11,80.97 142.11,80.78 142.03,80.7 142.03,80.57 142.24,80.36 142.36,80.36 142.44,80.45 142.65,80.45 142.8,80.29 142.8,80.11 142.74,80.05 142.74,79.87 142.87,79.73 143.3,79.73 143.82,79.22 143.82,78.78 147.29,75.31 147.29,70.08 149.42,67.95 149.42,65.29 151.76,62.96 151.76,56.77 150.36,55.38 150.36,52.68 147.88,50.21 147.88,49.38 v1(147.02,48.51)
  BOTTOM w0.076: U35.BB27 126,101.08 126,100.01 126.81,99.2 126.81,98.49 v1(126.41,98.1)
  BOTTOM w0.127: v1(147.02,48.51) 147.36,48.51 147.58,48.73 147.58,49.93 147.23,50.28 146.86,50.28 146.72,50.41 JDIM1.249
M_A_DQ61: length 74.3
  IN1 w0.089: v1(126.41,98.73) 128.95,98.73 131.84,95.85 131.84,94.17 136.02,89.99 136.02,87.73 144.33,79.42 144.33,79.08 144.23,78.98 144.23,78.81 144.37,78.67 144.59,78.67 144.69,78.77 144.89,78.77 145.02,78.64 145.02,78.44 144.89,78.31 144.89,78.14 145.04,78 145.24,78 145.34,78.1 145.54,78.1 145.7,77.93 145.7,77.79 145.6,77.69 145.6,77.41 147.58,75.43 147.58,70.2 149.79,67.99 149.79,65.34 152.05,63.08 152.05,56.62 150.7,55.27 150.7,52.61 148.21,50.12 148.21,48.43 v1(147.02,47.24)
  BOTTOM w0.076: U35.BA27 126,101.51 125.74,101.25 125.74,100.93 125.83,100.83 125.83,99.92 126.41,99.34 v1(126.41,98.73)
  BOTTOM w0.127: v1(147.02,47.24) 147.02,45.66 146.97,45.61 JDIM1.250
M_A_DQ62: length 74
  IN1 w0.089: v1(128.14,97.52) 127.93,97.52 127.44,97.03 127.44,92.98 128.45,91.97 129.24,91.97 132.14,89.07 132.14,88.95 132.9,88.18 132.9,87.68 132.72,87.49 132.43,87.49 132.33,87.4 132.33,87.1 132.42,87.01 132.81,87.01 132.9,86.93 132.9,85.97 132.75,85.82 132.75,85.29 134.13,83.91 134.13,83.73 133.99,83.59 133.99,83.42 134.16,83.26 134.33,83.26 134.47,83.4 134.64,83.4 135.31,82.73 135.31,80.59 135.66,80.24 135.79,80.24 136.01,80.47 136.14,80.47 136.35,80.26 136.35,80.14 136.12,79.91 136.12,79.78 136.32,79.58 136.45,79.58 136.68,79.81 136.81,79.81 137.01,79.6 137.01,79.47 136.78,79.24 136.78,79.12 136.99,78.91 137.12,78.91 137.34,79.14 137.47,79.14 137.68,78.93 137.68,78.81 137.45,78.58 137.45,78.45 137.65,78.25 137.78,78.25 138.01,78.48 138.14,78.48 138.34,78.27 138.34,78.14 138.11,77.91 138.11,77.79 138.32,77.58 138.44,77.58 138.67,77.81 138.8,77.81 139.01,77.6 139.01,77.48 138.78,77.25 138.78,77.12 138.98,76.92 139.11,76.92 139.34,77.15 139.47,77.15 139.67,76.94 139.67,76.81 139.44,76.58 139.44,76.46 139.65,76.25 139.77,76.25 140,76.48 140.13,76.48 140.34,76.27 140.34,76.15 140.11,75.92 140.11,75.79 140.31,75.59 140.44,75.59 140.67,75.82 140.79,75.82 141,75.61 141,75.48 140.77,75.25 140.77,75.13 140.98,74.92 141.1,74.92 141.33,75.15 141.46,75.15 141.67,74.94 141.67,74.82 141.44,74.59 141.44,74.46 141.64,74.26 141.77,74.26 142,74.49 142.12,74.49 142.33,74.28 142.33,74.15 142.1,73.92 142.1,73.8 142.31,73.59 142.43,73.59 142.62,73.77 142.75,73.77 142.95,73.57 142.95,73.41 142.77,73.23 142.77,73.13 143.85,72.05 143.85,67.97 144.58,67.23 144.58,65.15 146.53,63.21 146.53,55.9 144.89,54.27 144.89,51.83 143.31,50.25 v1(143.31,49.98)
  BOTTOM w0.076: U35.BA25 127.33,101.59 127.48,101.44 127.63,101.12 127.63,99.97 127.76,99.84
  BOTTOM w0.102: 127.76,99.84 128.14,99.46 v1(128.14,97.52)
  BOTTOM w0.127: v1(143.31,49.98) 143.72,50.4 JDIM1.237
M_A_DQ63: length 73.2
  IN1 w0.089: v1(128.14,96.89) 127.91,96.89 127.69,96.67 127.69,93.03 128.53,92.2 129.3,92.2 133.19,88.31 133.19,85.26 135.6,82.85 135.6,81.27 135.75,81.12 136.03,81.12 136.36,81.45 136.56,81.45 136.69,81.32 136.69,81.12 136.4,80.82 136.4,80.63 136.53,80.49 136.73,80.49 136.96,80.72 137.15,80.72 137.29,80.58 137.29,80.39 137.03,80.12 137.03,80 137.23,79.79 137.43,79.79 137.54,79.9 137.73,79.9 137.87,79.76 137.87,79.57 137.76,79.46 137.76,79.26 137.9,79.13 138.09,79.13 138.2,79.23 138.39,79.23 138.53,79.09 138.53,78.9 138.43,78.79 138.43,78.6 138.56,78.46 138.76,78.46 138.89,78.59 139.08,78.59 139.22,78.45 139.22,78.26 139.09,78.13 139.09,77.93 139.23,77.8 139.42,77.8 139.54,77.91 139.73,77.91 139.87,77.77 139.87,77.58 139.76,77.46 139.76,77.27 139.89,77.13 140.09,77.13 140.26,77.3 140.45,77.3 140.59,77.16 140.59,76.97 140.42,76.8 140.42,76.6 140.56,76.47 140.75,76.47 140.9,76.61 141.04,76.61 141.23,76.42 141.23,76.28 141.05,76.1 141.05,75.97 143.24,73.78 143.24,73.07 143.8,72.52 144.14,72.18 144.14,71.59 144.58,71.14 144.58,70.95 144.44,70.81 144.28,70.81 144.14,70.67 144.14,70.48 144.28,70.34 144.44,70.34 144.58,70.2 144.58,69.98 144.47,69.87 144.28,69.87 144.14,69.73 144.14,68.17 145.85,66.46 145.85,64.33 147.4,62.78 147.4,58.97 146.82,58.39 146.82,55.78 145.83,54.79 145.83,52.32 143.71,50.2 143.71,49.12 v1(143.31,48.71)
  BOTTOM w0.076: U35.BB25 127.33,100.95 127.46,100.82 127.46,99.86 127.69,99.64
  BOTTOM w0.102: 127.69,99.64 127.72,99.61 127.72,97.31 v1(128.14,96.89)
  BOTTOM w0.127: JDIM1.233 142.72,48.86 142.87,48.71 v1(143.31,48.71)
M_A_DQS0: length 85.4
  IN1 w0.089: v1(94.72,108.39) 94.46,108.13 94.46,107.99 93.85,107.37 89.38,107.37 84.82,102.81 84.82,101.06 82.99,99.23 82.99,89.19 84.89,87.28 84.89,86.72 83.97,85.8 83.97,84.99 84.29,84.68 84.29,84.13 83.98,83.82 83.98,83.38 84.29,83.07 84.29,82.16 85.15,81.3 85.15,80.79 84.97,80.61 84.97,77.89 84.47,77.39 84.47,70.01 83.95,69.49 83.95,66.38 83.01,65.45 83.01,61.02 83.72,60.31 83.72,55.8 83.95,55.57 83.95,52.14 84.9,51.19 84.9,47.94 84.63,47.66 84.31,47.66 84.24,47.59 v1(84.24,47.27)
  BOTTOM w0.076: U35.AM69 101.23,107.54 101.16,107.6 100.81,107.6 100.59,107.7 100.44,107.7 100.28,107.64 99.8,107.64 99.73,107.7 97.85,107.7 97.82,107.74
  BOTTOM w0.114: 97.82,107.74 94.85,107.74 94.72,107.87 v1(94.72,108.39)
  BOTTOM w0.127: JDIM1.13 85.72,50.45 85.61,50.34 85.61,48.44 84.78,47.61 84.33,47.61 84.24,47.53 v1(84.24,47.27)
M_A_DQS1: length 77.8
  IN1 w0.089: v1(89.99,46.45) 89.99,45.84 89.91,45.75 89.57,45.75 89.3,46.03 89.3,48.18 89.48,48.36 89.48,78.35 89.38,78.45 89.38,88.14 86.71,90.81 86.71,96.91 91.58,101.78 92.96,101.78 94.26,103.09 95.13,103.09 95.41,103.37 95.79,103.37 96.55,104.13 98.25,104.13 98.48,104.36 98.48,104.7 v1(98.7,104.92)
  BOTTOM w0.076: U35.AT70 101.46,104.89 101.5,104.85 101.5,104.77 101.41,104.67 101.31,104.64 101.25,104.62 101.07,104.62 100.94,104.67 100.76,104.67 100.65,104.64 100.6,104.62 100.42,104.62 100.29,104.67 99.81,104.67 99.65,104.51 98.78,104.51 98.46,104.2 98.3,104.2 98.23,104.28 98.23,104.45 v1(98.7,104.92)
  BOTTOM w0.127: JDIM1.34 90.97,44.15 90.85,44.28 90.85,45.73 90.48,46.1 90.1,46.1 89.99,46.2 v1(89.99,46.45)
M_A_DQS2: length 74.3
  IN1 w0.089: v1(95.35,48.15) 95.35,48.48 95.27,48.57 94.99,48.57 94.72,48.84 94.72,72.46 97.16,74.9 97.16,77.41 95.94,78.63 95.94,79.82 97.16,81.04 97.16,81.34 97.01,81.49 96.27,81.49 96.02,81.74 96.02,82.18 96.27,82.44 97.01,82.44 97.16,82.59 97.16,82.89 97.01,83.04 96.27,83.04 96.02,83.29 96.02,83.73 96.27,83.99 97.01,83.99 97.16,84.14 97.16,84.43 97.01,84.59 96.27,84.59 96.02,84.84 96.02,85.28 96.27,85.54 97.01,85.54 97.16,85.69 97.16,85.98 97.01,86.14 96.27,86.14 96.02,86.39 96.02,86.83 96.27,87.09 97.01,87.09 97.16,87.24 97.16,87.53 97.01,87.69 96.27,87.69 96.02,87.94 96.02,88.38 96.27,88.64 97.07,88.64 97.16,88.73 97.16,91.28 98.48,92.6 98.48,95.37 98.94,95.83 99.17,95.83 v1(99.37,96.03)
  BOTTOM w0.076: U35.AY64 104.51,102.41 104.31,102.21 104.31,101.94 104.22,101.82 104.22,101.68 104.21,101.63 104.17,101.54 104.17,101.28 104.21,101.19 104.21,101.19 104.21,100.93 104.03,100.75 104.03,100.29 102.77,99.03 100.68,99.03 100.05,98.39 100.05,96.71 v1(99.37,96.03)
  BOTTOM w0.127: JDIM1.55 96.22,50.5 96.12,50.39 96.12,48.77 95.86,48.51 95.44,48.51 95.35,48.42 v1(95.35,48.15)
M_A_DQS3: length 66.1
  IN1 w0.089: v1(100.46,46.39) 101,45.84 101.28,45.84 101.61,46.17 101.61,49.35 101.1,49.86 101.1,65.71 101.39,66 101.39,73.67 102.39,74.66 102.39,92.83 103.32,93.75 103.32,95.91 103.97,96.57 104.36,96.57 v1(104.64,96.85)
  BOTTOM w0.076: v1(104.64,96.85) 105.13,96.35 105.22,96.35 105.32,96.44 105.32,98.22 106.74,99.64 106.74,99.76 107.31,100.33 107.31,100.74 107.19,100.86 107.19,101.22 107.24,101.36 107.24,101.47 107.19,101.6 107.19,101.87 107.23,101.95 107.23,102.17 107.17,102.3 107.12,102.34 107.03,102.34 106.96,102.27 U35.BA60
  BOTTOM w0.127: JDIM1.76 101.47,44.12 101.37,44.22 101.37,45.57 100.93,46.01 100.54,46.01 100.46,46.09 v1(100.46,46.39)
M_A_DQS4: length 67.8
  IN1 w0.089: v1(129.72,49.48) 129.42,49.18 129.42,48.91 129.52,48.81 130.14,48.81 130.23,48.9 130.23,51.58 131.08,52.43 131.08,59.97 131.37,60.27 131.93,60.27 132.06,60.4 132.06,62.74 131.86,62.94 131.17,62.94 130.43,63.67 130.43,68.52 130.1,68.85 129.22,68.85 128.43,69.64 128.43,70.23 125.84,72.82 125.35,72.82 124.42,73.76 124.42,74.72 121.77,77.37 121.77,89.39 119.96,91.19 119.96,95.97 119.74,96.19 v1(119.37,96.19)
  BOTTOM w0.076: U35.AY38 119.03,102.45 118.94,102.31 118.9,102.2 118.9,101.92 118.93,101.84 118.93,101.63 118.88,101.52 118.88,101.3 118.93,101.19 118.93,100.93 118.76,100.76 118.76,100.25 118.98,100.03 118.98,99.13 118.69,98.84 118.69,96.47 118.85,96.31 119.26,96.31 v1(119.37,96.19)
  BOTTOM w0.127: JDIM1.179 129.22,50.46 129.07,50.31 129.07,49.02 129.24,48.85 129.62,48.85 129.72,48.95 v1(129.72,49.48)
M_A_DQS5: length 79
  IN1 w0.089: v1(134.09,45.87) 134.09,46.32 134.18,46.41 134.71,46.41 135.54,47.24 135.54,47.92 134.91,48.56 134.91,50.09 136.18,51.36 136.18,51.96 136.73,52.52 136.73,55.14 137.42,55.82 137.42,63.32 135.82,64.92 135.82,68.29 134.5,69.61 134.5,70.22 134.02,70.71 134.02,71.44 132.92,72.53 132.92,72.67 133.11,72.85 133.11,73.21 132.8,73.53 132.43,73.53 132.25,73.34 132.12,73.34 131.7,73.76 131.7,73.89 131.9,74.08 131.9,74.45 131.58,74.76 131.22,74.76 131.02,74.56 130.9,74.56 130.6,74.86 130.6,74.98 131.01,75.39 131.01,75.66 130.61,76.06 130.34,76.06 129.93,75.66 129.8,75.66 129.51,75.95 129.51,76.08 129.91,76.49 129.91,76.76 129.51,77.16 129.24,77.16 128.83,76.75 128.71,76.75 128.41,77.05 128.41,77.18 128.82,77.58 128.82,77.86 128.42,78.26 128.14,78.26 127.74,77.85 127.61,77.85 127.31,78.15 127.31,78.27 127.72,78.68 127.72,78.95 127.32,79.35 127.05,79.35 126.64,78.95 126.51,78.95 126.09,79.37 126.09,89.37 123.96,91.51 123.48,91.51 122.48,92.5 122.48,94.8 122.53,94.85 122.69,94.85 v1(122.9,94.63)
  BOTTOM w0.076: U35.BA34 121.68,102.27 121.75,102.33 121.83,102.33 121.87,102.31 121.92,102.23 121.95,102.17 121.95,101.95 121.91,101.87 121.91,101.6 121.97,101.47 121.97,101.36 121.91,101.22 121.91,100.21 122.1,100.02 122.1,94.99 122.33,94.77 122.76,94.77 122.9,94.62 v1(122.9,94.63)
  BOTTOM w0.127: JDIM1.200 134.47,44.1 134.29,44.28 134.29,44.5 133.99,44.8 133.79,44.8 133.56,45.03 133.56,46.33 133.75,46.53 133.98,46.53 134.09,46.42 v1(134.09,45.87)
M_A_DQS6: length 71.7
  IN1 w0.089: v1(124.81,96.14) 125.21,96.14 125.61,95.75 125.61,92.12 126.4,91.33 127.31,91.33 128.05,90.6 128.56,90.6 130.08,89.07 130.08,82.56 136.71,75.93 136.71,75.11 140.86,70.96 140.86,67.77 141.99,66.64 141.99,64.39 143.6,62.77 143.6,56.37 141.74,54.5 141.74,52.04 140.54,50.84 140.54,48.34 140.32,48.11 139.69,48.11 139.55,48.25 139.55,48.43 v1(139.91,48.79)
  BOTTOM w0.076: U35.AY30 124.01,102.45 123.95,102.36 123.92,102.31 123.88,102.2 123.88,101.92 123.91,101.84 123.91,101.63 123.86,101.5 123.86,101.3 123.91,101.19 123.91,100.58 123.88,100.55 123.88,100.01 124.16,99.74 124.16,96.45 124.35,96.26 124.69,96.26 v1(124.81,96.14)
  BOTTOM w0.127: JDIM1.221 139.72,50.47 139.58,50.32 139.58,49.92 139.13,49.47 139.13,48.46 139.46,48.13 139.78,48.13 139.91,48.25 v1(139.91,48.79)
M_A_DQS7: length 75.1
  IN1 w0.089: v1(128.14,94.98) 128.35,95.19 128.66,95.19 128.89,94.97 128.89,94.28 134.37,88.8 134.37,86.31 142.64,78.03 142.64,76.08 142.96,75.77 143.32,75.77 143.66,76.11 143.93,76.11 144.11,75.93 144.11,75.71 143.73,75.33 143.73,74.97 145.93,72.77 145.93,69.52 147.1,68.35 147.1,64.84 148.61,63.33 148.61,58.5 148.01,57.9 148.01,55.29 147.12,54.4 147.12,51.76 145.6,50.23 145.6,48.81 144.86,48.07 144.86,46.76 145.12,46.51 145.51,46.51 145.66,46.35 v1(145.66,45.97)
  BOTTOM w0.076: U35.BA26 126.66,102.27 126.73,102.33 126.81,102.33 126.85,102.31 126.9,102.23 126.93,102.17 126.93,101.95 126.9,101.87 126.9,101.6 126.95,101.47 126.95,101.36 126.9,101.22 126.9,100.86 127.13,100.62 127.13,99.64 127.36,99.41 127.36,95.14 127.52,94.98 v1(128.14,94.98)
  BOTTOM w0.127: JDIM1.242 144.97,44.2 144.81,44.37 144.81,46.41 145.06,46.67 145.54,46.67 145.66,46.54 v1(145.66,45.97)
M_A_DQS8: length 5.1
  TOP w0.127: R10891.2 105.09,47.26 105.59,47.77 v1(105.59,47.77) 105.59,48.32 v1(106.05,48.78)
  BOTTOM w0.127: v1(106.05,48.78) 106.72,49.45 JDIM1.97
M_A_DQS#0: length 85.3
  IN1 w0.089: v1(84.24,48.54) 84.24,47.91 84.32,47.84 84.55,47.84 84.73,48.01 84.73,51.12 83.78,52.07 83.78,55.5 83.55,55.72 83.55,60.24 82.84,60.95 82.84,65.52 83.77,66.46 83.77,69.56 84.29,70.08 84.29,77.46 84.79,77.97 84.79,80.68 84.97,80.86 84.97,81.23 84.11,82.09 84.11,83 83.8,83.31 83.8,83.89 84.11,84.2 84.11,84.6 83.79,84.92 83.79,85.87 84.71,86.79 84.71,87.21 82.81,89.11 82.81,99.31 84.64,101.13 84.64,102.89 89.3,107.55 93.77,107.55 94.28,108.06 94.28,108.18 v1(94.08,108.39)
  BOTTOM w0.076: U35.AM70 101.16,107.37 101.1,107.44 100.77,107.44 100.56,107.54 100.48,107.54 100.31,107.47 99.73,107.47 99.66,107.54 97.79,107.54 97.78,107.53 97.76,107.53
  BOTTOM w0.114: v1(94.08,108.39) 94.52,107.94 94.52,107.78 94.77,107.53 97.76,107.53
  BOTTOM w0.127: JDIM1.11 85.22,50.44 85.37,50.29 85.37,48.54 84.68,47.85 84.38,47.85 84.24,47.99 v1(84.24,48.54)
M_A_DQS#1: length 77.8
  IN1 w0.089: v1(89.99,45.18) 89.99,45.49 89.91,45.58 89.5,45.58 89.12,45.96 89.12,48.25 89.3,48.43 89.3,78.28 89.2,78.38 89.2,88.07 86.53,90.74 86.53,96.98 91.51,101.96 92.88,101.96 94.19,103.27 95.06,103.27 95.33,103.55 95.72,103.55 96.48,104.31 98.18,104.31 98.3,104.44 98.3,104.68 v1(98.06,104.93)
  BOTTOM w0.076: U35.AT69 101.65,104.68 101.5,104.53 101.36,104.48 101.28,104.46 101.03,104.46 100.9,104.51 100.78,104.51 100.71,104.48 100.63,104.46 100.38,104.46 100.25,104.51 99.88,104.51 99.72,104.35 98.85,104.35 98.53,104.03 98.24,104.03 98.06,104.21 v1(98.06,104.93)
  BOTTOM w0.127: JDIM1.32 90.47,44.16 90.6,44.29 90.6,45.63 90.38,45.86 90.1,45.86 89.99,45.75 v1(89.99,45.18)
M_A_DQS#2: length 74.2
  IN1 w0.089: v1(95.35,49.42) 95.56,49.22 95.56,48.85 95.46,48.75 95.06,48.75 94.9,48.91 94.9,72.39 97.34,74.83 97.34,77.49 96.12,78.71 96.12,79.75 97.34,80.97 97.34,81.41 97.08,81.67 96.35,81.67 96.2,81.82 96.2,82.11 96.35,82.26 97.08,82.26 97.34,82.52 97.34,82.96 97.08,83.22 96.35,83.22 96.2,83.37 96.2,83.66 96.35,83.81 97.08,83.81 97.34,84.07 97.34,84.51 97.08,84.76 96.35,84.76 96.2,84.92 96.2,85.21 96.35,85.36 97.08,85.36 97.34,85.62 97.34,86.06 97.08,86.31 96.35,86.31 96.2,86.47 96.2,86.76 96.35,86.91 97.08,86.91 97.34,87.17 97.34,87.61 97.08,87.86 96.35,87.86 96.2,88.02 96.2,88.31 96.35,88.46 97.15,88.46 97.34,88.65 97.34,91.21 98.66,92.53 98.66,95.3 99.02,95.65 99.12,95.65 v1(99.37,95.4)
  BOTTOM w0.076: U35.BA64 104.38,101.76 104.38,101.66 104.37,101.59 104.36,101.57 104.34,101.51 104.34,101.31 104.37,101.22 104.37,100.86 104.2,100.69 104.2,100.22 102.84,98.86 100.75,98.86 100.21,98.32 100.21,96.64 99.79,96.22 99.79,95.82 v1(99.37,95.4)
  BOTTOM w0.127: JDIM1.53 95.72,50.48 95.88,50.33 95.88,48.87 95.76,48.75 95.47,48.75 95.35,48.86 v1(95.35,49.42)
M_A_DQS#3: length 66.1
  IN1 w0.089: v1(104.65,96.19) 104.45,96.39 104.04,96.39 103.49,95.84 103.49,93.68 102.57,92.75 102.57,74.59 101.57,73.59 101.57,65.93 101.28,65.64 101.28,49.93 101.78,49.42 101.78,46.09 101.35,45.66 101.01,45.66 v1(100.46,45.12)
  BOTTOM w0.076: v1(104.65,96.19) 105.29,96.19 105.48,96.38 105.48,98.15 106.9,99.57 106.9,99.69 107.48,100.26 107.48,100.81 107.36,100.93 107.36,101.19 107.41,101.3 107.41,101.52 107.36,101.63 107.36,101.84 107.39,101.92 107.39,102.21 107.3,102.39 107.06,102.64 U35.AY60
  BOTTOM w0.127: JDIM1.74 100.97,44.13 101.13,44.28 101.13,45.47 100.83,45.77 100.55,45.77 100.46,45.68 v1(100.46,45.12)
M_A_DQS#4: length 67.8
  IN1 w0.089: v1(119.37,96.83) 119.37,96.81 120.14,96.05 120.14,91.27 121.94,89.46 121.94,77.44 124.59,74.79 124.59,73.83 125.43,72.99 125.91,72.99 128.61,70.3 128.61,69.71 129.29,69.03 130.18,69.03 130.61,68.6 130.61,63.75 131.25,63.11 131.93,63.11 132.24,62.81 132.24,60.32 132.01,60.09 131.45,60.09 131.26,59.9 131.26,52.35 130.41,51.51 130.41,48.83 130.22,48.64 129.85,48.64 129.72,48.51 v1(129.72,48.21)
  BOTTOM w0.076: v1(119.37,96.83) 119.37,96.83 119.02,96.47 118.92,96.47 118.86,96.54 118.86,98.77 119.14,99.06 119.14,100.09 118.92,100.31 118.92,100.69 119.1,100.86 119.1,101.22 119.04,101.36 119.04,101.47 119.1,101.6 119.1,101.87 119.06,101.95 119.06,102.17 119.09,102.23 119.14,102.31 119.18,102.33 119.29,102.33 119.33,102.3 U35.BA38
  BOTTOM w0.127: v1(129.72,48.21) 129.72,48.5 129.61,48.61 129.14,48.61 128.83,48.92 128.83,50.34 128.72,50.44 JDIM1.177
M_A_DQS#5: length 79
  IN1 w0.089: v1(134.09,47.14) 134.09,46.68 134.18,46.59 134.64,46.59 135.36,47.31 135.36,47.85 134.73,48.48 134.73,50.16 136,51.43 136,52.04 136.56,52.59 136.56,55.21 137.24,55.9 137.24,63.24 135.64,64.84 135.64,68.22 134.32,69.54 134.32,70.15 133.84,70.63 133.84,71.36 132.74,72.46 132.74,72.74 132.93,72.93 132.93,73.14 132.72,73.35 132.51,73.35 132.32,73.16 132.05,73.16 131.52,73.69 131.52,73.96 131.72,74.16 131.72,74.37 131.51,74.58 131.29,74.58 131.1,74.38 130.83,74.38 130.42,74.78 130.42,75.06 130.83,75.46 130.83,75.59 130.53,75.89 130.41,75.89 130,75.48 129.73,75.48 129.33,75.88 129.33,76.15 129.74,76.56 129.74,76.69 129.44,76.98 129.31,76.98 128.91,76.58 128.63,76.58 128.23,76.98 128.23,77.25 128.64,77.66 128.64,77.78 128.34,78.08 128.22,78.08 127.81,77.67 127.54,77.67 127.14,78.07 127.14,78.35 127.54,78.75 127.54,78.88 127.25,79.18 127.12,79.18 126.71,78.77 126.44,78.77 125.91,79.3 125.91,89.3 123.88,91.33 123.4,91.33 122.31,92.43 122.31,94.87 122.46,95.02 122.66,95.02 v1(122.9,95.26)
  BOTTOM w0.076: U35.AY34 121.78,102.52 121.8,102.5 121.86,102.5 121.99,102.45 121.99,102.45 122.07,102.31 122.12,102.2 122.12,101.92 122.08,101.84 122.08,101.63 122.13,101.52 122.13,101.3 122.08,101.19 122.08,100.28 122.27,100.09 122.27,95.06 122.4,94.93 122.58,94.93 v1(122.9,95.26)
  BOTTOM w0.127: JDIM1.198 133.97,44.13 134.05,44.21 134.05,44.4 133.89,44.56 133.69,44.56 133.31,44.93 133.31,46.43 133.65,46.77 134.01,46.77 134.09,46.85 v1(134.09,47.14)
M_A_DQS#6: length 71.7
  IN1 w0.089: v1(124.81,96.8) 125.79,95.82 125.79,92.19 126.47,91.51 127.38,91.51 128.12,90.77 128.63,90.77 130.26,89.15 130.26,82.63 136.89,76.01 136.89,75.18 141.04,71.03 141.04,67.85 142.17,66.72 142.17,64.46 143.78,62.85 143.78,56.29 141.92,54.43 141.92,51.96 140.72,50.77 140.72,48.26 140.4,47.94 140,47.94 139.91,47.85 v1(139.91,47.52)
  BOTTOM w0.076: v1(124.81,96.8) 124.81,96.72 124.52,96.43 124.41,96.43 124.32,96.52 124.32,99.8 124.05,100.08 124.05,100.48 124.08,100.51 124.08,101.22 124.03,101.36 124.03,101.47 124.06,101.55 124.08,101.59 124.08,101.87 124.04,101.95 124.04,102.17 124.05,102.18 124.09,102.27 124.12,102.31 124.17,102.33 124.25,102.33 124.31,102.27 U35.BA30
  BOTTOM w0.127: v1(139.91,47.52) 139.91,47.75 139.77,47.89 139.36,47.89 138.89,48.36 138.89,49.57 139.34,50.02 139.34,50.32 139.22,50.43 JDIM1.219
M_A_DQS#7: length 75.2
  IN1 w0.089: v1(145.66,47.24) 145.66,46.87 145.47,46.68 145.19,46.68 145.04,46.84 145.04,48 145.78,48.74 145.78,50.16 147.3,51.68 147.3,54.33 148.19,55.21 148.19,57.83 148.79,58.43 148.79,63.41 147.28,64.92 147.28,68.42 146.11,69.59 146.11,72.84 143.91,75.04 143.91,75.26 144.29,75.64 144.29,76 144,76.29 143.59,76.29 143.24,75.94 143.03,75.94 142.82,76.15 142.82,78.11 134.55,86.38 134.55,88.87 129.06,94.36 129.06,95.04 128.73,95.37 128.38,95.37 v1(128.14,95.62)
  BOTTOM w0.076: U35.AY26 126.95,102.48 127.05,102.31 127.1,102.2 127.1,101.92 127.06,101.84 127.06,101.63 127.11,101.52 127.11,101.3 127.06,101.19 127.06,100.93 127.3,100.69 127.3,99.73 127.53,99.5 127.53,95.21 127.59,95.15 127.67,95.15 v1(128.14,95.62)
  BOTTOM w0.127: JDIM1.240 144.47,44.22 144.57,44.31 144.57,46.51 144.96,46.91 145.6,46.91 145.66,46.97 v1(145.66,47.24)
M_A_DQS#8: length 3.8
  TOP w0.127: v1(106.05,50.05) v1(105.23,49.23) 104.84,48.84 R10894.2
  BOTTOM w0.127: JDIM1.95 106.22,50.22 v1(106.05,50.05)
M_A_EVENT#: length 7.4
  TOP w0.127: v1(117.96,42.82) R10885.2 R10890.1 117.16,45.51 v1(116.61,46.05)
  BOTTOM w0.127: JDIM1.134 115.97,45.42 v1(116.61,46.05)
M_A_ODT0_DIMM: length 70.1
  IN1 w0.14: v1(115.78,105.18) 116.26,104.69 116.26,102.98 118.27,100.98 118.27,100.32 118.69,99.9 118.69,99.36 118.27,98.94 118.27,91.05 119.25,90.06 119.25,75.35 122.65,71.95 122.65,71.42 123.78,70.29 124.79,70.29 125.69,69.39 125.69,68.64 126.21,68.12 126.21,63.17 126.5,62.88 127.27,62.88 127.62,62.53 127.62,56.59 126.37,55.34 126.37,54.82 126.76,54.43 126.76,52.48 125,50.72 125,48.81 125.15,48.66 v1(125.62,48.66)
  BOTTOM w0.203: U35.AT45 v1(115.78,105.18) ; JDIM1.155 123.22,49.27 123.83,48.66 v1(125.62,48.66)
M_A_ODT1_DIMM: length 71.6
  IN1 w0.14: v3(116.7,104.53) 117.12,104.11 117.12,102.45 118.5,101.07 118.5,100.41 118.92,99.99 118.92,99.27 118.5,98.85 118.5,91.14 119.67,89.97 119.67,75.52 119.97,75.22 120.16,75.22 120.45,75.51 120.65,75.51 120.82,75.34 120.82,75.15 120.53,74.86 120.53,74.66 120.7,74.49 120.9,74.49 121.19,74.78 121.39,74.78 121.56,74.61 121.56,74.41 121.27,74.12 121.27,73.92 121.44,73.75 121.64,73.75 121.93,74.04 122.12,74.04 122.29,73.87 122.29,73.67 122.01,73.38 122.01,73.19 123.62,71.57 123.62,71.37 123.55,71.31 123.55,71.11 123.73,70.94 123.92,70.94 123.99,71.01 124.19,71.01 124.48,70.71 124.96,70.71 126.11,69.57 126.11,68.81 126.63,68.29 126.63,67.14 126.77,67 127.17,67 127.31,66.86 127.31,66.62 127.17,66.48 126.77,66.48 126.63,66.34 126.63,65.05 126.77,64.91 127.17,64.91 127.31,64.77 127.31,64.52 127.17,64.38 126.77,64.38 126.63,64.24 126.63,63.46 126.78,63.3 127.53,63.3 128.04,62.79 128.04,56.42 127.74,56.12 127.74,55.87 127.9,55.71 127.9,55.47 127.73,55.29 127.46,55.29 127.3,55.45 127.07,55.45 126.83,55.21 126.83,54.95 127.18,54.6 127.18,54.18 127.32,54.04 127.44,54.04 127.55,53.93 127.55,53.64 127.44,53.52 127.32,53.52 127.18,53.38 127.18,52.31 125.79,50.92 125.79,50.59 126.05,50.32 126.05,50.06 125.93,49.93 v1(125.62,49.93)
  BOTTOM w0.203: JDIM1.161 124.72,50.36 125.15,49.93 v1(125.62,49.93) ; U35.AT43 v3(116.7,104.53)
M_A_PARITY: length 64.4
  IN1 w0.14: v1(119.18,49.93) 119.39,49.93 119.51,50.06 119.51,50.87 119.13,51.25 119.13,51.58 119.51,51.96 119.51,52.47 119.12,52.86 119.12,59.71 119.59,60.18 119.59,63.68 119.24,64.03 118.93,64.03 118.44,64.52 118.44,64.99 118.74,65.29 118.74,66.8 118.52,67.02 117.89,67.02 117.73,67.17 117.73,67.39 117.89,67.54 118.65,67.54 118.79,67.68 118.79,68.16 115.66,71.29 115.66,71.82 114.72,72.76 114.72,90.58 114.51,90.8 114.51,98.93 113.11,100.32 113.11,101.09 110.7,103.5 110.7,104.11 v3(111.12,104.53)
  BOTTOM w0.203: U35.AT52 v3(111.12,104.53) ; v1(119.18,49.93) 118.52,49.93 118.22,50.23 JDIM1.143
M_A_RAS#: length 67.3
  IN1 w0.14: v1(122.47,46.63) 122.47,47.01 120.77,48.71 120.77,50.11 121.39,50.73 121.39,52.13 121.1,52.42 121.1,54.11 120.43,54.78 120.43,56.89 120.96,57.42 120.96,58.29 120.43,58.82 120.43,59.24 121.01,59.82 121.01,64.05 120.07,64.98 120.07,66.02 120.51,66.46 120.51,68.81 119.76,69.57 119.16,69.57 116.92,71.81 116.92,72.34 115.98,73.28 115.98,90.52 115.3,91.21 115.3,100.38 113.72,101.95 113.72,102.89 112.99,103.62 112.99,103.88 v3(112.99,103.88)
  BOTTOM w0.203: v1(122.47,46.63) JDIM1.152 ; U35.AU50 v3(112.99,103.88)
M_A_WE#: length 65.7
  IN1 w0.14: v1(122.71,50.05) 122.71,51.42 123.16,51.87 123.16,54.55 122.77,54.94 122.77,56.03 123.02,56.28 123.76,56.28 124.11,56.64 124.11,61.18 123.94,61.36 123.3,61.36 123.15,61.51 123.15,62.35 123.3,62.5 123.64,62.5 123.79,62.66 123.79,63.02 123.64,63.18 122.88,63.18 122.74,63.32 122.74,63.56 122.88,63.7 123.65,63.7 123.79,63.84 123.79,64.26 123.64,64.41 122.97,64.41 122.84,64.54 122.84,68.54 122,69.38 121.72,69.38 117.35,73.76 117.35,98.94 116.13,100.15 116.13,100.65 114.48,102.31 114.48,103.4 114.36,103.52 114.36,104.03 v3(114.85,104.53)
  BOTTOM w0.203: v3(114.85,104.53) U35.AT46 ; v1(122.71,50.05) 122.54,50.05 122.22,50.36 JDIM1.151
M_B_A0: length 59.9
  IN3 w0.191: v1(115.91,54.03) 114.89,54.03 114.74,54.18 114.74,54.6 114.89,54.76 115.67,54.76 115.96,55.04 115.96,56.13 115.68,56.41 115.21,56.41 114.74,56.88 114.74,57.55 115.03,57.84 115.03,59.1 114.75,59.38 114.75,63.62 114.52,63.86 114.52,66.8 113.94,67.38 113.94,68.81 114.23,69.1 114.68,69.1 115.08,69.5 115.08,73.64 114.64,74.09 114.36,74.09 113.74,74.71 113.74,74.98 113.3,75.42 113.3,76.14 112.21,77.23 112.21,78.49 111.54,79.17 111.54,88.99 111.97,89.42 111.97,90.23 112.68,90.94 v1(112.68,91.75)
  BOTTOM w0.076: U35.BA46 115.3,101.47 115.3,99.91 114.62,99.22 114.62,99.21
  BOTTOM w0.102: 114.62,99.21 114.62,98.58 114.23,98.19 114.23,93.3 v1(112.68,91.75)
  BOTTOM w0.203: v1(115.91,54.03) 116.62,53.31 118.12,53.31 118.47,53.67 JDIM2.144
M_B_A1: length 60.5
  IN3 w0.191: v1(112.68,93.68) 113.2,93.68 113.52,93.36 113.52,93.11 113.21,92.81 113.21,92.55 113.52,92.25 113.52,90.82 112.96,90.27 112.96,89.97 113.34,89.59 113.34,82.44 113.19,82.29 112.63,82.29 112.48,82.14 112.48,81.87 112.63,81.72 113.17,81.72 113.34,81.55 113.34,81.31 113.17,81.15 112.6,81.15 112.48,81.02 112.48,80.73 112.63,80.58 113.95,80.58 114.1,80.42 114.1,80.16 113.95,80 112.63,80 112.48,79.85 112.48,79.59 112.63,79.43 113.95,79.43 114.1,79.28 114.1,79.01 113.95,78.86 113.32,78.86 113.15,78.7 113.15,77.62 114.24,76.53 114.24,75.81 116.05,74.01 116.05,73.49 116.21,73.32 116.34,73.32 116.5,73.15 116.5,72.92 116.34,72.75 116.21,72.75 116.05,72.58 116.05,72.34 116.21,72.18 116.34,72.18 116.5,72.01 116.5,71.77 116.34,71.61 116.21,71.61 116.05,71.44 116.05,71.2 116.21,71.03 116.34,71.03 116.5,70.87 116.5,70.63 116.34,70.46 116.21,70.46 116.05,70.3 116.05,70.02 116.2,69.87 116.35,69.87 116.5,69.72 116.5,69.39 116.35,69.23 116.2,69.23 116.05,69.08 116.05,68.47 116.17,68.35 116.17,60.84 115.62,60.29 v1(115.49,60.29)
  BOTTOM w0.076: U35.AY46 114.81,102.26 114.81,101.95 114.75,101.79 114.75,101.7 114.8,101.55 114.83,101.49 114.83,101.31 114.77,101.19 114.77,100.93 114.95,100.75 114.95,100.03 114.2,99.28 114.2,99.02
  BOTTOM w0.102: v1(112.68,93.68) 113.85,94.85 113.85,98.42 114.2,98.78 114.2,99.02
  BOTTOM w0.203: v1(115.49,60.29) 116.49,60.29 117.02,60.83 117.02,61.36 115.72,62.66 JDIM2.133
M_B_A2: length 60.5
  IN3 w0.191: v1(112.68,94.32) 113.15,94.32 113.81,93.66 113.81,81.48 114.57,80.72 114.57,78.82 113.85,78.1 113.85,77.59 114.71,76.73 114.71,76.01 116.97,73.75 116.97,69.07 116.64,68.74 116.64,60.62 116.13,60.11 116.13,58.42 117.28,57.28 117.28,55.87 117.13,55.72 116.8,55.72 116.64,55.87 116.64,57.09 116.26,57.47 115.73,57.47 115.5,57.7 v1(115.5,58.31)
  BOTTOM w0.076: 114.01,99.08 114.01,99.32 114.79,100.1 114.79,100.68 114.6,100.86 114.6,101.23 114.62,101.26 114.65,101.34 114.65,101.46 114.59,101.68 114.59,101.82 114.64,101.98 114.64,102.41 U35.AY47
  BOTTOM w0.102: 114.01,99.08 114.01,98.86 113.66,98.5 113.66,95.29 v1(112.68,94.32)
  BOTTOM w0.203: v1(115.5,58.31) 116.11,58.31 116.26,58.16 116.26,57.64 116.06,57.44 115.77,57.44 115.65,57.55 115.17,57.55 115.02,57.4 115.02,56.7 115.17,56.55 115.33,56.55 115.47,56.41 JDIM2.132
M_B_A3: length 58.6
  IN3 w0.191: v1(115.5,61.57) 115.22,61.85 115.22,62.32 115.39,62.49 115.54,62.49 115.7,62.66 115.7,63.82 115.5,64.03 115.11,64.03 114.99,64.15 114.99,66.72 115.15,66.88 115.55,66.88 115.7,67.04 115.7,67.3 115.55,67.46 114.61,67.46 114.43,67.63 114.43,68.17 114.61,68.35 115.25,68.35 115.58,68.68 115.58,73.81 114.83,74.56 114.55,74.56 114.21,74.91 114.21,75.18 113.77,75.61 113.77,76.34 112.68,77.43 112.68,78.68 112.01,79.36 112.01,82.6 112.17,82.77 112.7,82.77 112.87,82.94 112.87,83.17 112.7,83.34 112.17,83.34 112.01,83.51 112.01,83.75 112.17,83.91 112.7,83.91 112.87,84.08 112.87,84.32 112.7,84.48 112.17,84.48 112.01,84.65 112.01,84.89 112.17,85.06 112.7,85.06 112.87,85.22 112.87,85.46 112.7,85.63 112.17,85.63 112.01,85.8 112.01,86.03 112.17,86.2 112.7,86.2 112.87,86.37 112.87,86.6 112.7,86.77 112.17,86.77 112.01,86.94 112.01,87.18 112.17,87.34 112.7,87.34 112.87,87.51 112.87,87.75 112.7,87.91 112.17,87.91 112.01,88.08 112.01,88.55 112.25,88.79 112.72,88.79 112.87,88.94 112.87,89.39 112.58,89.69 112.58,90.39 113.16,90.98 113.16,92.17 112.92,92.41 v1(112.68,92.41)
  BOTTOM w0.076: U35.BB46 115.12,101 115.12,99.96 114.39,99.23 114.39,99.04
  BOTTOM w0.102: v1(112.68,92.41) 114.04,93.77 114.04,98.35 114.39,98.7 114.39,99.04
  BOTTOM w0.203: JDIM2.131 115.22,62.33 115.38,62.17 115.78,62.17 116.71,61.24 116.71,61.02 116.49,60.8 116.27,60.8 v1(115.5,61.57)
M_B_A4: length 59.4
  IN3 w0.191: v1(112.68,95.59) 112.39,95.59 112.23,95.43 112.23,90.95 111.5,90.23 111.5,89.62 111.07,89.18 111.07,78.97 111.74,78.3 111.74,77.04 112.83,75.95 112.83,75.22 113.05,75 113.05,74.48 113.21,74.31 113.47,74.31 114.2,73.58 114.48,73.58 114.61,73.45 114.61,73.13 114.48,73 113.95,73 113.8,72.85 113.8,72.58 113.95,72.43 114.44,72.43 114.61,72.27 114.61,72.03 114.44,71.86 113.96,71.86 113.8,71.71 113.8,71.44 113.96,71.28 114.44,71.28 114.61,71.12 114.61,70.88 114.44,70.71 114.14,70.71 113.98,70.56 113.98,70.29 114.14,70.14 114.46,70.14 114.61,69.99 114.61,69.7 114.48,69.57 113.91,69.57 113.37,69.04 113.09,69.04 112.99,68.93 112.99,68.57 113.47,68.08 113.47,66.94 113.64,66.77 113.88,66.77 114.05,66.61 114.05,66.37 113.88,66.2 113.64,66.2 113.47,66.03 113.47,63.67 113.62,63.52 114.13,63.52 114.28,63.37 114.28,60.35 114.08,60.15 114.08,59.78 114.28,59.58 114.28,59.19 114.56,58.91 114.56,58.18 114.44,58.07 v1(113.99,58.07)
  BOTTOM w0.076: 113.82,100.2 113.82,100.5 114.14,100.82 114.14,101.22 114.14,101.22 114.11,101.31 114.11,101.51 114.14,101.6 114.14,101.6 114.15,101.6 114.15,101.61 114.15,101.84 U35.BA47
  BOTTOM w0.102: 113.82,100.2 113.82,98.94 113.46,98.58 113.46,96.37 v1(112.68,95.59)
  BOTTOM w0.203: v1(113.99,58.07) 113.99,58.83 114.13,58.97 114.46,58.97 114.61,58.82 114.61,57.93 114.71,57.83 114.71,57.3 114.47,57.06 JDIM2.128
