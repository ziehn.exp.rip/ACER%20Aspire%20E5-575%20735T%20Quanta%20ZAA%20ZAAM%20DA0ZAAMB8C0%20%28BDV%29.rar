# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
C_PEG_TX#2: length 12.8
  BOTTOM w0.076: U35.D17 130.92,122.06 130.92,122.37 130.83,122.46 130.83,122.79 130.81,122.84 130.76,122.95 130.76,123.2 130.8,123.28 130.8,123.5 130.77,123.56 130.77,125.23 131.72,126.18 131.72,126.24 131.74,126.26
  BOTTOM w0.127: 131.74,126.26 132.22,126.74 132.22,128.91 132.75,129.44 132.75,129.84 v1(132.24,130.35) 132.75,130.86 132.75,131.03 133.75,132.03 133.75,132.38 C661.2
C_PEG_TX#3: length 11
  BOTTOM w0.076: 129.64,126.26 129.64,126.24 129.69,126.19 129.69,124.36 129.37,124.04 129.37,123.42 129.59,123.21 129.71,123.21 U35.B19
  BOTTOM w0.127: C654.2 131.35,132.24 131.35,131.95 130.99,131.59 130.63,131.59 129.64,130.6 129.64,126.26
CATERR#: length 13.9
  TOP w0.127: TP65.1 105.09,121.33 v1(105.66,120.76) ; R788.2 v1(105.72,129.43)
  IN1 w0.089: v1(105.72,129.43) 106.74,128.42 107.37,128.42 108.01,127.78 108.01,127.02 107.75,126.77 107.75,123.21 105.66,121.12 v1(105.66,120.76)
  BOTTOM w0.127: v1(105.66,120.76) 105.66,121.18 U35.D63
CCD_PWR:
  vias: v1(117.02,169.18) v1(117.66,169.08) v1(118.12,169.56)
CFG4: length 10.8
  BOTTOM w0.127: v1(94.8,126.61) 94.8,126.41 95.03,126.18 96.35,126.18 96.81,126.64 R548.1 97.85,125.63 97.85,122.7 99.56,120.98 100.32,120.98 100.75,121.41 U35.E70
CFG_RCOMP: length 11.2
  TOP w0.508: R156.2 v1(106.61,127.4)
  IN2 w0.508: v1(106.61,127.4) 105.59,126.38 105.59,125.98 104.7,125.09 104.7,122.19 105.47,121.43 106.04,121.43 106.69,120.78 v3(106.69,120.02)
  BOTTOM w0.305: U35.E60 106.57,120.5 106.57,120.13 v3(106.69,120.02)
  vias: v1(107.35,128.67)
CHA_SA0: length 6.6
  TOP w0.127: R10872.2 R10882.1 148.01,38.88 v1(148.17,39.04) 148.44,39.31 148.44,39.82 149.03,40.41 v1(149.03,40.91)
  BOTTOM w0.127: JDIM1.256 148.47,42.18 148.67,41.99 148.67,41.27 v1(149.03,40.91)
CHA_SA1: length 8.7
  TOP w0.127: R10886.1 R10880.2 147.71,36.85 148.19,37.33 v1(148.19,37.38) 148.19,38.04 148.98,38.83 v1(148.98,39.39)
  BOTTOM w0.127: v1(148.98,39.39) 149.79,40.2 149.79,41.93 149.47,42.24 JDIM1.260
CHA_SA2: length 8.1
  TOP w0.127: v1(125.39,46.09) 125.8,46.5 126.16,46.5 126.92,47.26 127.56,47.26 R10877.1 R10889.2 128.83,47.98 v1(128.43,48.38)
  BOTTOM w0.127: v1(125.39,46.09) 125.97,45.51 JDIM1.166
CHB_SA0: length 11.2
  TOP w0.127: v1(155.3,56.38) 155.3,56.7 R10924.2 155.99,56.95 155.99,56.46 v1(156.01,56.43) 156.17,56.27 R10943.1
  BOTTOM w0.127: v1(156.01,56.43) 149.71,56.43 149.58,56.56 148.63,56.56 148.47,56.41 JDIM2.256
CHB_SA1: length 10.2
  TOP w0.127: R10940.2 155.77,55.52 v1(156.02,55.77) 156.38,55.4 R10937.1
  BOTTOM w0.127: v1(156.02,55.77) 156.01,55.77 155.48,55.24 152.69,55.24 151.29,53.84 v1(150.74,53.84) 149.82,53.84 149.47,54.18 JDIM2.260
CHB_SA2: length 8.3
  TOP w0.127: v1(128.58,53.87) 129.08,53.37 v1(130.58,53.37) R10923.2 R10927.1
  BOTTOM w0.127: JDIM2.166 125.97,54.44 126.55,53.87 v1(128.58,53.87)
CIIC_SCL: length 2.1
  TOP w0.127: R11189.1 24.28,64.58 U13.30
CIIC_SDA: length 2.1
  TOP w0.127: R11190.1 23.88,64.62 U13.29
CLK_PCI_EC: length 109.2
  IN1 w0.089: v1(184.97,60.6) 184.31,59.94 180.62,59.94 180.05,60.51 179.54,61.02 178.9,61.66 178.9,62.08 178.23,62.75 178.23,63.79 172.98,69.04 172.98,69.78 172.52,70.24 172.52,73.28 171.56,74.24 171.56,74.86 170.94,75.49 170.94,77.11 170.62,77.43 170.62,80.22 170.45,80.39 170.45,84.53 168.92,86.06 168.92,87.16 v1(170.38,88.62)
  IN3 w0.114: v1(147.63,101.34) 148.39,100.58 148.39,99.84 150.11,98.13 150.36,98.13 151.7,96.79 151.7,95.26 152.59,94.37 152.59,89.55 151.44,88.41 151.44,87.8 v1(150.65,87.01)
  BOTTOM w0.127: v1(150.65,87.01) 150.65,85.88 151.87,84.67 157.62,84.67 157.73,84.78 159.27,84.78 160.15,83.89 164.35,83.89 165.89,85.43 165.89,85.96 168.55,88.62 v1(170.38,88.62) ; v1(147.63,101.34) 147.61,101.37 R623.1 ; U45.13 188.15,36.6 188.27,36.72 R373.2 189.15,37.57 190.19,38.62 190.19,42.33 190,42.53 190,43.45 189.41,44.04 189.41,52.34 189.21,52.55 189.21,56.36 v1(184.97,60.6)
CLK_PCI_LPC: length 172
  TOP w0.127: v1(193.52,173.84) 193.61,173.93 R694.2
  IN1 w0.089: v1(193.52,173.84) 193.52,173.84 194.11,173.24 194.11,171.34 195.13,170.33 200.46,170.33 202.37,168.42 202.62,168.42 203.19,167.85 203.19,157.22 204.44,155.98 204.63,155.98 204.98,155.62 204.98,155.14 206.3,153.82 212.15,153.82 212.65,153.31 220.4,153.31 223.32,150.39 223.32,114.83 220.66,112.16 218.37,112.16 217.1,110.89 213.54,110.89 209.73,107.08 208.08,107.08 207.19,106.19 195.17,106.19 194.87,106.48 190.56,106.48 189.88,105.81 186.19,105.81 185.66,105.28 183.55,105.28 183.06,104.79 177.84,104.79 v1(174.03,100.98)
  BOTTOM w0.127: R627.1 149.37,101.04 149.96,101.04 C4723.1 150.29,101.15 150.6,100.83 152.05,100.83 152.79,101.57 152.79,104.46 154.13,105.81 157.79,105.81 158.81,104.79 158.81,102.38 159.78,101.4 169,101.4 169.47,101.87 170.39,101.87 171.28,100.98 v1(174.03,100.98)
CLK_PCI_LPC_C: length 3.3
  TOP w0.127: v1(192.21,174.5) 192.36,174.64 R694.1 193.33,175.14 193.33,175.71 v1(193.43,175.81)
  BOTTOM w0.127: CN10.71 v1(192.21,174.5)
CLK_PCIE_LAN_REQ#: length 231.4
  TOP w0.127: v1(153.83,100.86) 153.32,101.37 R229.1 ; v1(32.57,60.34) 32.44,60.47 R281.2 31.43,60.97 31.17,61.23 Q25.3 31.78,63.9 32.28,64.4 R276.2
  IN3 w0.114: v1(153.83,100.86) 153.09,100.12 153.09,98.44 154.53,97.01 154.53,87.56 152.39,85.43 152.39,83.78 151.43,82.81 151.43,65.44 152.74,64.13 152.74,43.1 149.66,40.02 149.66,39.31 147.55,37.19 123.67,37.19 123.2,37.66 107.54,37.66 106.27,36.39 88.26,36.39 81.48,29.61 77.01,29.61 68.25,20.85 66.25,18.85 58.75,18.85 57.64,19.97 54.02,19.97 45.34,28.65 39.38,28.65 37.32,30.7 37.32,34.83 33.84,38.31 33.84,59.07 v1(32.57,60.34)
CLK_PCIE_LANN: length 130.8
  TOP w0.127: U15.24 34.46,70.46 v1(33.86,69.87)
  IN3 w0.114: v1(118.59,125.62) 118.73,125.76 118.73,125.99 118.49,126.22 117.9,126.22 115.8,124.12 114.64,124.12 110.07,128.7 102.65,128.7 101.4,129.94 99.88,129.94 99.42,130.4 96.65,130.4 95.99,129.74 85.14,129.74 69.34,113.94 59.18,113.94 52.1,106.86 52.1,105.79 37.65,91.33 37.65,84.09 33.94,80.39 33.94,76.95 35.49,75.4 35.49,72.16 34.3,70.96 34.3,70.3 v1(33.86,69.87)
  BOTTOM w0.076: v1(118.59,125.62) 118.59,125.07 117.62,124.1 117.4,124.1 117.18,123.87 117.18,123.35 U35.B40
CLK_PCIE_LANP: length 130.7
  TOP w0.127: U15.23 34.12,70.86 33.86,70.61 v1(33.86,70.5)
  IN3 w0.114: v1(33.86,70.5) 34.07,70.71 34.07,71.06 35.26,72.25 35.26,75.31 33.71,76.85 33.71,80.48 37.42,84.19 37.42,91.43 51.87,105.88 51.87,106.95 59.09,114.17 69.25,114.17 85.05,129.97 95.9,129.97 96.56,130.63 99.52,130.63 99.97,130.17 101.5,130.17 102.74,128.92 110.17,128.92 114.74,124.35 115.71,124.35 117.81,126.45 118.58,126.45 v1(119.3,125.74)
  BOTTOM w0.076: v1(119.3,125.74) 118.75,125.19 118.75,125 117.72,123.97 117.72,123.52 117.65,123.44 117.54,123.44 117.47,123.52 U35.A40
CLK_PCIE_REQ0#: length 21.2
  TOP w0.127: R235.2 152.04,100.76 v1(151.75,100.76) 150.82,100.76 R234.1 150.29,99.96 149.98,99.65 145.84,99.65 145.78,99.71 139.63,99.71 136.71,102.64 136.71,103.14 136.29,103.56 136.29,104.68 v3(135.87,105.1)
  BOTTOM w0.127: U35.AR10 135.47,105.5 v3(135.87,105.1)
CLK_PCIE_REQ1#: length 17.1
  TOP w0.127: v3(137.7,104.54) 138,104.24 138.92,104.24 140.14,103.02 143.57,103.02 143.88,102.7 146.55,102.7 v1(146.87,103.02) 147.06,103.21 147.74,103.21 148.06,102.89 149.92,102.89 150.29,103.26 R215.1 150.75,103.86 151.99,103.86 R11111.2
  BOTTOM w0.127: U35.AT7 137.39,104.85 v3(137.7,104.54)
CLK_PCIE_REQ2#: length 13.5
  TOP w0.127: v1(136.78,104.53) 136.85,104.53 138,103.37 139.02,103.37 140.39,102 142.04,102 142.32,101.72 146.34,101.72 146.91,102.29 148.17,102.29 R227.1
  BOTTOM w0.127: v1(136.78,104.53) U35.AT8
CLK_PCIE_REQ3#: length 20.1
  TOP w0.127: v3(135.88,104.48) 135.88,104.37 136.06,104.19 136.06,102.27 139.25,99.08 142.61,99.08 143.06,98.63 149.85,98.63 150.29,99.07 150.29,99.21 ; 150.29,99.21 150.81,98.69 TP22.1 ; 150.29,99.21 R618.1
  BOTTOM w0.127: U35.AT10 135.51,104.85 v3(135.88,104.48)
CLK_PCIE_REQ4#: length 18.6
  TOP w0.127: v3(136.78,103.88) 137.39,103.27 137.6,103.27 140.52,100.35 144.58,100.35 144.96,100.73 148.52,100.73 148.65,100.6 v1(149.28,100.6) 149.54,100.86 149.78,100.86 R228.1 150.73,101.81 152,101.81 R229.2
  BOTTOM w0.127: v3(136.78,103.88) U35.AU8
CLK_PCIE_REQ5#: length 17.8
  TOP w0.127: R224.2 151.94,102.89 150.8,102.89 R223.1 150.29,102.25 149.97,101.93 149.43,101.93 149.12,101.62 v1(148.52,101.62) 148.01,101.62 147.85,101.78 147.12,101.78 146.52,101.19 144.4,101.19 144.2,100.98 140.61,100.98 v3(138.69,102.91)
  BOTTOM w0.127: U35.AU7 137.95,103.49 137.95,103.34 138.15,103.14 138.45,103.14 v3(138.69,102.91)
CLK_PCIE_VGA: length 72.7
  IN1 w0.089: v1(119.56,133.5) 119.56,133.6 119.7,133.74 119.89,133.74 122.16,131.46 124.5,131.46 125.83,130.13 128.9,130.13 129.98,131.21 133.03,131.21 133.56,131.74 136.56,131.74 136.73,131.57 148.79,131.57 149.41,130.94 151.31,130.94 151.93,130.32 153.76,130.32 154.72,129.36 160.78,129.36 161.68,128.47 164.14,128.47 165.65,129.98 168.09,129.98 169.14,128.92 171.39,128.92 171.74,128.58 171.74,128.42 171.61,128.29 v1(171.33,128.29)
  BOTTOM w0.076: 116.81,126.26 116.81,126.24 116.77,126.19 116.77,125.37 116.39,124.99 116.39,124.68 116.07,124.36 116.07,123.59 116.1,123.53 116.1,123.24 116.06,123.17 116.06,122.98 116.11,122.86 116.11,122.65 116.06,122.5 116.06,122.28 116.29,122.04 116.51,122.04 116.62,122.15 116.62,122.31 116.51,122.41 U35.C42
  BOTTOM w0.127: U3002.AL13 v1(171.33,128.29) ; v1(119.56,133.5) 119.44,133.62 118.93,133.62 117.94,132.63 117.94,129.28 117.25,128.59 117.25,126.99 116.81,126.56 116.81,126.26
CLK_PCIE_VGA#: length 72.7
  IN1 w0.089: v1(172.13,128.29) 171.93,128.49 171.93,128.66 171.47,129.12 169.22,129.12 168.17,130.17 165.57,130.17 164.06,128.66 161.76,128.66 160.86,129.55 154.8,129.55 153.84,130.51 152.01,130.51 151.39,131.13 149.49,131.13 148.87,131.76 136.81,131.76 136.64,131.93 133.48,131.93 132.95,131.4 129.9,131.4 128.82,130.32 125.91,130.32 124.58,131.66 122.24,131.66 119.97,133.93 119.77,133.93 v1(119.56,134.13)
  BOTTOM w0.076: 116.56,126.26 116.56,126.24 116.6,126.19 116.6,125.44 116.22,125.06 116.22,124.75 115.9,124.43 115.9,123.56 115.9,123.56 115.93,123.49 115.93,123.28 115.9,123.2 115.9,122.95 115.94,122.83 115.94,122.68 115.89,122.52 115.89,122.21 U35.D42
  BOTTOM w0.127: 116.56,126.26 116.56,126.66 117,127.1 117,128.7 117.68,129.39 117.68,132.74 118.82,133.88 119.31,133.88 v1(119.56,134.13) ; U3002.AK13 v1(172.13,128.29)
CLK_PCIE_WLANN: length 127.2
  IN3 w0.114: v3(117.57,121.24) 118.07,121.74 118.78,121.74 119.21,122.17 120.29,122.17 121.09,121.37 121.09,121.18 121.72,120.54 123.05,120.54 123.46,120.95 123.46,121.84 124.05,122.43 124.05,128.91 125.9,130.75 128.49,130.75 129.88,132.14 129.88,133.57 131.6,135.3 139.29,135.3 140.08,134.51 148.32,134.51 153.75,139.94 153.75,141.21 156.62,144.08 156.62,156.4 160.61,160.39 160.61,163.54 162.01,164.94 162.01,170.83 163.31,172.13 174.58,172.13 175.06,172.61 176.02,172.61 176.53,172.1 187.44,172.1 193.96,178.63 194.09,178.75 v1(194.09,179.37)
  BOTTOM w0.127: v3(117.57,121.24) 117.62,121.29 117.87,121.29 118.04,121.12 U35.E40 ; CN10.49 191.94,180 192.19,180.25 194.25,180.25 194.6,179.9 194.6,179.75 194.21,179.37 v1(194.09,179.37)
CLK_PCIE_WLANP: length 127.2
  IN3 w0.114: v3(118.42,121.31) 118.63,121.1 118.83,121.1 118.93,121.2 118.93,121.56 119.31,121.94 120.2,121.94 120.86,121.28 120.86,121.08 121.63,120.31 123.15,120.31 123.69,120.85 123.69,121.74 124.28,122.34 124.28,128.82 125.99,130.53 128.58,130.53 130.1,132.05 130.1,133.48 131.7,135.07 139.2,135.07 139.99,134.28 148.42,134.28 153.98,139.85 153.98,141.12 156.85,143.99 156.85,156.31 160.84,160.29 160.84,163.44 162.24,164.84 162.24,170.73 163.4,171.9 174.67,171.9 175.16,172.38 175.93,172.38 176.43,171.88 187.53,171.88 194.12,178.46 194.32,178.66 194.32,178.84 v1(194.85,179.37)
  BOTTOM w0.127: U35.E38 118.63,121.31 v3(118.42,121.31) ; CN10.47 194.35,180.5 194.85,180 v1(194.85,179.37)
CLK_PCIE_XDPN: length 1.5
  TOP w0.127: v1(115.74,119.94) 115.74,119.41 TP93.1
  BOTTOM w0.127: v1(115.74,119.94) 115.96,120.16 116.03,120.16 U35.F43
CLK_PCIE_XDPP: length 1.7
  TOP w0.127: v1(115.74,120.6) 116.7,120.6 TP94.1
  BOTTOM w0.127: U35.E43 116.13,120.99 v1(115.74,120.6)
CLK_PEGA_REQ#: length 27
  TOP w0.127: R235.1 153.23,100.22 153.73,99.71 155.63,99.71 v1(157.35,101.43) 158.3,102.38 158.3,107.36 157.54,108.12 157.54,115.44 159.21,117.11 161.47,117.11 162.11,116.48 Q4002.3
CLK_SCLK: length 375.5
  TOP w0.127: v1(35.62,56.92) 35.13,56.43 32.29,56.43 30.41,58.31 27.74,58.31 24.06,62 24.06,63 R11189.2
  IN1 w0.089: v1(148.64,46.6) 147.5,45.46 147.5,41.76 146.27,40.53 145.22,40.53 142.8,38.12 96.24,38.12 95.36,37.24 78.05,37.24 74.73,33.93 74.73,28.96 68.99,23.22 59.97,23.22 57.84,21.09 55.53,21.09 47.05,29.57 47.05,30.71 46.65,31.11 46.65,34.66 45.33,35.98 45.33,39.96 37.51,47.78 37.51,51.55 36.51,52.56 36.51,56.01 35.62,56.9 v1(35.62,56.92) ; v1(150.32,123.08) 150.54,122.86 150.54,122.12 150.86,121.8 153.36,121.8 157.93,117.23 157.93,112 158.65,111.27 159.84,111.27 166.06,105.05 166.06,101.89 165.84,101.67 165.84,93.95 166.43,93.36 166.43,90.52 165.92,90.01 165.92,83.97 165.08,83.13 165.08,80.4 166.74,78.74 166.74,77.68 168.09,76.33 168.09,73.67 170.11,71.65 170.11,69.21 175.74,63.58 175.74,63.15 v1(175.55,62.96) 175.55,62.94 175.74,62.75 175.74,62.1 176.38,61.45 176.38,60.74 179.18,57.94 182.95,57.94 183.63,57.27 185.41,57.27 185.83,57.69 192.29,57.69 192.83,57.15 211.06,57.15 216.49,51.72 223.69,51.72 227.25,55.28 227.25,60.06 226.72,60.59 226.13,60.59 v1(225.86,60.85)
  IN3 w0.114: v1(148.64,46.6) 148.9,46.6 149.05,46.75 149.05,48.38 148.51,48.93 148.51,52.33 149.4,53.22 149.4,57.03 150.55,58.19 v1(150.55,58.31)
  BOTTOM w0.127: v1(150.32,123.08) 149.86,122.63 148.72,122.63 147.25,124.1 147.25,124.71 Q32.1 145.84,124.97 145.46,124.6 R572.1 ; R329.1 v1(225.86,60.85) ; JDIM2.253 147.72,62.64 148.44,61.92 148.44,60.04 150.17,58.31 v1(150.55,58.31) 150.78,58.08 156.72,58.08 157.44,57.37 157.44,55.49 159.06,53.87 160.09,53.87 161.21,52.75 167.71,52.75 173.78,58.82 173.78,61.98 174.33,62.53 175.48,62.53 175.63,62.68 175.63,62.88 v1(175.55,62.96) ; JDIM1.253 147.72,50.45 148.64,49.53 v1(148.64,46.6)
CLK_SDATA: length 376.7
  TOP w0.127: v1(35.62,56.15) 32.17,56.15 30.29,58.03 27.63,58.03 23.78,61.88 23.78,63.28 23.55,63.51 R11190.2
  IN1 w0.089: v1(35.62,56.15) 36.02,56.15 36.26,55.91 36.26,52.46 37.27,51.45 37.27,47.68 45.09,39.86 45.09,35.88 46.41,34.56 46.41,31.01 46.81,30.61 46.81,29.47 55.43,20.85 57.94,20.85 60.07,22.98 69.09,22.98 74.97,28.86 74.97,33.83 78.15,37 95.46,37 96.34,37.88 142.9,37.88 145.32,40.29 146.37,40.29 147.74,41.66 147.74,45.36 148.35,45.97 v1(148.64,45.97) ; v1(151.08,123.08) 150.91,123.08 150.78,122.96 150.78,122.22 150.96,122.04 153.46,122.04 158.17,117.33 158.17,112.1 158.75,111.51 159.94,111.51 166.3,105.15 166.3,101.79 166.08,101.57 166.08,94.05 166.67,93.46 166.67,90.42 166.16,89.91 166.16,83.87 165.32,83.03 165.32,80.5 166.99,78.84 166.99,77.78 168.33,76.43 168.33,73.77 170.35,71.75 170.35,69.31 175.98,63.68 175.98,63.19 v1(176.21,62.96) 175.98,62.73 175.98,62.2 176.62,61.55 176.62,60.84 179.28,58.19 183.05,58.19 183.73,57.51 185.31,57.51 185.73,57.93 192.39,57.93 192.93,57.39 211.16,57.39 216.59,51.96 223.59,51.96 226.15,54.52 226.15,54.65 225.86,54.93 225.86,55.11 226.02,55.26 226.2,55.26 226.48,54.98 226.61,54.98 227.01,55.38 227.01,55.88 226.92,55.97 226.59,55.97 226.5,56.06 226.5,56.35 226.59,56.44 226.92,56.44 227.01,56.53 227.01,56.82 226.92,56.91 226.59,56.91 226.5,57 226.5,57.29 226.59,57.38 226.92,57.38 227.01,57.47 227.01,57.76 226.92,57.85 226.59,57.85 226.5,57.94 226.5,58.23 226.59,58.32 226.92,58.32 227.01,58.41 227.01,58.7 226.92,58.79 226.59,58.79 226.5,58.88 226.5,59.17 226.59,59.26 226.92,59.26 227.01,59.35 227.01,59.96 226.62,60.34 226.24,60.34 v1(225.86,59.96)
  IN3 w0.114: v1(148.64,45.97) 149.32,46.64 149.32,48.49 148.77,49.04 148.77,52.22 149.66,53.11 149.66,56.92 150.29,57.55 v1(150.55,57.55)
  BOTTOM w0.127: v1(148.64,45.97) 148.44,46.17 148.27,46.17 147.77,45.67 147.77,45.43 147.96,45.23 148.13,45.23 148.67,44.69 148.67,44.37 148.57,44.27 148.42,44.27 148.09,44.6 147.91,44.6 147.77,44.45 147.77,44.28 147.97,44.08 JDIM1.254 ; Q32.4 150.29,126.27 R576.1 150.8,126.01 151.08,125.73 v1(151.08,123.08) ; v1(176.21,62.96) 176.21,62.86 175.6,62.25 174.44,62.25 174.06,61.87 174.06,58.71 167.82,52.47 161.09,52.47 159.98,53.59 158.94,53.59 157.16,55.38 157.16,57.26 156.61,57.8 150.81,57.8 v1(150.55,57.55) 150.55,57.17 150.45,57.07 150.02,57.07 149.92,57.17 149.92,57.45 149.75,57.62 149.59,57.62 149.37,57.83 149.21,57.83 149.1,57.73 149.1,57.25 148.93,57.07 148.65,57.07 148.39,57.32 148.09,57.32 147.97,57.21 JDIM2.254 ; R336.1 v1(225.86,59.96)
CLKRUN#: length 99.2
  IN1 w0.089: v1(163.17,66.95) 162.92,66.69 162.36,66.69 161.49,67.56 161.49,68.72 159.64,70.57 159.64,75.9 158.49,77.05 158.49,83.5 v1(158.64,83.65)
  IN3 w0.114: v1(163.17,66.95) 163.17,65.15 160.86,62.83 160.86,56.89 161.52,56.23 161.52,54.25 162.28,53.49 167.06,53.49 168.59,51.96 168.59,51.13 169.2,50.52 169.2,45.97 168.71,45.49 168.71,43.45 169.6,42.56 170.29,42.56 v1(172.95,39.9)
  BOTTOM w0.076: 138.31,97.94 138.31,98.5 137.72,99.08 136.5,99.08 135.36,100.22 134.8,100.22 134.26,100.77 134.26,101.71 134.36,101.81 134.36,102.64 134.64,102.92 U35.AW11
  BOTTOM w0.127: R743.2 162.3,69.36 162.35,69.31 C807.2 162.35,68.34 162.1,68.08 162.1,67.11 162.39,66.81 163.04,66.81 v1(163.17,66.95) ; v1(158.64,83.65) 156.9,83.65 156.52,84.03 149.61,84.03 142.21,91.42 140.17,91.42 R630.2 139.06,91.84 138.41,92.5 138.41,96.8 138.31,96.9 138.31,97.94 ; U45.93 172.65,40.2 v1(172.95,39.9)
CLR_CMOS: length 73.9
  IN1 w0.089: v1(161.89,53.19) 160.55,54.53 158.86,56.22 158.86,63.38 156.65,65.59 156.65,67.21 155.13,68.73 155.13,71.6 155.82,72.28 155.82,81.57 154.87,82.52 154.87,86.76 v1(153.98,87.65)
  IN3 w0.114: v1(170.36,34.44) 171.25,35.33 171.25,41.27 170.21,42.31 169.53,42.31 168.48,43.36 168.48,45.58 168.97,46.06 168.97,50.43 168.08,51.32 168.08,51.96 167.19,52.85 162.23,52.85 v1(161.89,53.19)
  BOTTOM w0.127: v1(153.98,87.65) 154.54,87.65 154.87,87.98 Q6060.2 154.87,89.56 154.99,89.68 R786.1 155.48,89.69 157.93,89.69 158.68,88.95 Q6059.2 ; v1(170.36,34.44) 170.53,34.6 U45.79
CODEC_VREF: length 3
  BOTTOM w0.102: v1(205.97,37) 206.34,37.37 C535.2
  BOTTOM w0.203: C535.2 206.69,37.54 205.78,38.44 U23.28
CPU_DRAMRST#: length 34.8
  TOP w0.127: v3(134.04,104.53) 134.45,104.12 134.45,103.47 134.93,102.99 134.93,101.39 134.68,101.14 134.68,100.22 137.72,97.17 138.74,97.17 139.71,96.21 139.71,92.27 140.91,91.07 143.18,91.07 143.57,90.68 143.89,90.68 144.64,89.94 148.53,89.94 150.93,92.34 150.93,93.36 151.69,94.13 v1(152.33,94.13) 153.07,94.13 153.47,93.72 R670.2 153.84,93.37 R679.2
  BOTTOM w0.127: v3(134.04,104.53) U35.AT13
CPU_THRMTRIP#: length 8.5
  TOP w0.127: v1(104.83,126.11) 104.7,126.23 v1(104.7,127.02) 104.7,127.9 R530.2 104.83,128.04 104.39,128.48 104.39,129.75 104.7,130.06 R529.2
  BOTTOM w0.076: U35.C63 105.21,122.54 105.21,122.67 105.36,123 105.36,123.08 105.3,123.31 105.3,123.5 105.36,123.67 105.36,124.38 105.02,124.73
  BOTTOM w0.089: v1(104.83,126.11) 105.02,125.92 105.02,124.73
CRT_11: length 3.9
  TOP w0.127: CN7.11 9.28,72.41 TP75.1
CRT_AUXN: length 111.1
  TOP w0.127: C343.1 28.73,66.57 28.81,66.64 29.39,66.64 29.66,66.38 29.66,66.07 v1(29.83,65.91)
  IN3 w0.114: v1(98.86,129.33) 97.97,128.44 96.58,128.44 96.02,129 85.55,129 69.37,112.82 59.87,112.82 53.02,105.96 53.02,105.67 38.41,91.06 38.41,83.67 36.76,82.02 36.76,81.99 35.24,80.47 35.24,79.52 34.85,79.14 34.85,77.24 37.01,75.08 37.01,72.47 35.24,70.69 35.24,70.2 32.77,67.74 31.77,67.74 30.81,66.77 30.38,66.77 29.83,66.22 v1(29.83,65.91)
  BOTTOM w0.127: v1(98.86,129.33) 98.86,129.19 R10847.2
CRT_AUXP: length 111.1
  TOP w0.127: C341.1 28.39,65.87 28.91,66.39 29.29,66.39 29.4,66.27 29.4,66.07 29.24,65.91 v1(29.19,65.91)
  IN3 w0.114: v1(29.19,65.91) 30.28,67 30.71,67 31.68,67.96 32.68,67.96 35.01,70.29 35.01,70.78 36.79,72.56 36.79,74.98 34.63,77.14 34.63,79.24 35.01,79.62 35.01,80.56 36.53,82.09 36.53,82.11 38.18,83.76 38.18,91.16 52.79,105.76 52.79,106.06 59.78,113.05 69.27,113.05 85.45,129.23 96.11,129.23 96.67,128.67 97.88,128.67 98.23,129.02 v1(98.23,129.33)
  BOTTOM w0.127: v1(98.23,129.33) 98.53,129.03 98.53,128.86 R10848.2
CRT_B1: length 9.5
  TOP w0.114: L5.2 13.02,75.84 12.88,75.7 C319.2 11.64,75.7 11.63,75.7 U38.5 U38.6 9.85,75.7 v1(9.45,76.09) 7.42,78.12 6.75,78.12 CN7.3
CRT_BLU: length 13.3
  TOP w0.114: L5.1 15.42,75.84 15.81,76.23 C320.2 R213.1 17.57,76.23 18.09,75.71 18.09,75.33 v1(18.47,74.95) 18.88,74.54 18.88,69.64 20.37,68.15 U13.21
CRT_CLK: length 3.8
  TOP w0.127: v3(137.76,116.35) 138.72,116.35 139.38,117.01 139.38,117.12 R577.1
  BOTTOM w0.127: v3(137.76,116.35) 137.76,116.48 U35.N7
CRT_DATA: length 5.8
  TOP w0.102: v3(136.47,116.37) 136.85,116.75 138.75,116.75 139.12,117.11
  TOP w0.127: R152.1 140.14,118.89 139.78,118.54 139.78,117.88 139.12,117.22 139.12,117.11
  BOTTOM w0.127: U35.N8 136.47,116.48 v3(136.47,116.37)
CRT_G1: length 9.2
  TOP w0.114: CN7.2 6.58,76 7.51,76 v1(8.49,75.03) 9.32,74.2 U38.9 U38.2 12,74.2 12,74.2 C333.2 12.75,74.2 13.14,73.81 L6.2
CRT_GRE: length 12
  TOP w0.114: L6.1 15.42,73.81 15.81,74.2 C334.2 R219.1 17.98,73.55 v1(17.98,72.66) 17.98,69.27 19.5,67.75 U13.22
CRT_HPD: length 196.8
  TOP w0.114: v1(151.09,134.79) 146.74,130.44 146.74,127.65 145.22,126.14 144.36,126.14 143.06,124.84 R10846.2 ; U13.32 v1(25.08,65.3)
  IN1 w0.127: v1(58.22,118) 70.82,118 86.54,133.73 89.44,133.73 95.54,139.82 105.12,139.82 105.88,139.07 114.36,139.07 118.68,143.38 122.09,143.38 124.6,140.87 124.6,139.26 125.63,138.23 129.8,138.23 130.91,137.12 141.07,137.12 141.39,136.8 144.71,136.8 145.62,135.88 149.99,135.88 v1(151.09,134.79)
  IN3 w0.127: v1(25.08,65.3) 26.35,66.56 26.35,72.41 28.25,74.31 30.46,74.31 31.43,75.28 31.43,96.41 35.24,100.22 40.19,100.22 57.97,118 v1(58.22,118)
CRT_R1: length 9.8
  TOP w0.114: CN7.1 6.53,75.38 7.47,75.38 9.16,73.7 U38.10 U38.1 11.32,73.7 11.61,73.4 v1(11.61,73.04) C336.2 12.14,72.16 12.53,71.77 L7.2
CRT_RED: length 11.4
  TOP w0.114: L7.1 14.66,71.77 14.8,71.91 C337.2 R222.1 16.81,71.91 17.07,71.65 v1(17.07,69.87) 17.07,68.98 19.21,66.85 20.25,66.85 20.75,67.35 U13.23
CRT_TXN0: length 125.1
  TOP w0.127: v1(29.09,69.62) 28.51,69.62 C331.1
  IN3 w0.114: v1(29.09,69.62) 29.37,69.34 29.55,69.34 29.93,69.71 29.93,70.66 29.51,71.08 29.51,71.84 30.09,72.41 31.24,72.41 31.75,71.9 33.71,71.9 34.25,72.44 34.25,74.42 33.43,75.23 33.43,76.09 32.98,76.55 32.98,90.54 36.54,94.1 38.95,94.1 50.86,106.01 50.86,107.1 60.46,116.71 70.7,116.71 85.36,131.36 100.05,131.36 100.38,131.03 110.11,131.03 110.29,131.21 v1(110.29,131.52)
  BOTTOM w0.127: v1(110.29,131.52) 110.29,131.26 109.99,130.96 109.99,130.41 R10843.2
CRT_TXN1: length 120.9
  TOP w0.127: C315.1 28.51,71.65 v1(29.09,71.65)
  IN3 w0.114: v1(109.4,132.73) 108.97,132.3 108.92,132.3 108.62,132 107.99,132 107.63,132.35 99.12,132.35 98.1,133.37 95.81,133.37 94.8,132.35 85.6,132.35 70.74,117.49 60.64,117.49 49.46,106.32 49.46,105.3 38.92,94.76 36.38,94.76 32.44,90.82 32.44,75.08 30.82,73.45 28.83,73.45 28.25,72.87 28.25,71.37 28.38,71.24 28.71,71.24 29.09,71.62 v1(29.09,71.65)
  BOTTOM w0.127: R10845.2 109.53,132.61 v1(109.4,132.73)
CRT_TXP0: length 125.1
  TOP w0.127: v1(29.09,68.98) 28.51,68.98 C335.1
  IN3 w0.114: v1(29.09,68.98) 29.22,69.11 29.65,69.11 30.16,69.62 30.16,70.76 29.74,71.17 29.74,71.74 30.18,72.18 31.15,72.18 31.65,71.67 33.81,71.67 34.47,72.34 34.47,74.51 33.66,75.32 33.66,76.19 33.2,76.64 33.2,90.44 36.63,93.87 39.05,93.87 51.09,105.91 51.09,107 60.56,116.48 70.8,116.48 85.45,131.13 99.95,131.13 100.29,130.8 110.21,130.8 110.39,130.99 v1(110.67,130.99)
  BOTTOM w0.127: R10842.2 110.36,130.2 110.24,130.32 110.24,130.85 110.38,130.99 v1(110.67,130.99)
CRT_TXP1: length 120.9
  TOP w0.127: C329.1 28.51,71.01 v1(29.09,71.01)
  IN3 w0.114: v1(108.77,132.73) 108.77,132.47 108.76,132.46 108.52,132.23 108.08,132.23 107.73,132.58 99.21,132.58 98.2,133.6 95.72,133.6 94.7,132.58 85.5,132.58 70.64,117.72 60.54,117.72 49.23,106.41 49.23,105.4 38.82,94.99 36.28,94.99 32.21,90.92 32.21,75.17 30.72,73.68 28.74,73.68 28.02,72.96 28.02,71.27 28.28,71.01 v1(29.09,71.01)
  BOTTOM w0.127: R10844.2 108.64,132.61 v1(108.77,132.73)
CRTHSYNC: length 12.2
  TOP w0.114: v1(10.22,76.85) 10.23,76.86 R11269.2 R11268.2 ; v1(12.25,79.27) 12.87,79.27 C718.1 12.62,79.78 11.49,79.78 11.22,80.05 U36.1 U36.10 8.02,80.05 CN7.13
  BOTTOM w0.114: v1(10.22,76.85) 12.25,78.89 v1(12.25,79.27)
CRTHSYNC_B: length 11.7
  TOP w0.114: R11268.1 v1(12.63,77.49) ; v1(20.02,73.3) 20,73.27 R11267.2
  IN3 w0.127: v1(12.63,77.49) 12.63,76.35 13.49,75.48 17.43,75.48 19.09,73.82 19.5,73.82 v1(20.02,73.3)
CRTVDD5: length 4.3
  TOP w0.203: U36.2 U36.9 v1(9.07,80.55)
  IN3 w0.762: CN7.9 8.3,80.3
  vias: v1(9.84,83.08) v1(10.47,83.08) v1(11.11,83.08) v1(11.82,83.31)
CRTVSYNC: length 11.7
  TOP w0.114: CN7.14 8.2,81.44 8.3,81.55 U36.7 U36.4 12.88,81.55 C716.1 12.66,81.09 v1(12.36,81.09) ; R11271.2 R11272.2 10.23,79.13 v1(10.22,79.14)
  BOTTOM w0.114: v1(12.36,81.09) 11.53,81.09 10.22,79.78 v1(10.22,79.14)
CRTVSYNC_B: length 13.1
  TOP w0.114: R11271.1 v1(12.63,78.51) ; R11270.2 20.48,72.44 20.48,73.48 v1(20.02,73.93)
  IN3 w0.127: v1(20.02,73.93) 19.74,74.21 19.26,74.21 18.34,75.13 18.34,75.53 17.89,75.99 13.87,75.99 13.14,76.73 13.14,78 v1(12.63,78.51)
CTL2: length 4
  TOP w0.127: U22.7 16.32,25.3 15.55,24.53 v1(15.55,23.96) 15.55,22.99 R360.2
CTL3: length 3.1
  TOP w0.127: U22.8 16.58,24.8 16.31,24.53 16.31,23.57 v1(16.62,23.26) 16.95,22.93 R356.2
D/C#: length 2
  TOP w0.305: PR171.1 151.23,187.33 TP4366.1
  TOP w0.381: PR171.1 151.56,187.32 PC6.2
DC-DET: length 5.2
  BOTTOM w0.127: v1(204.22,49.45) 203.68,48.91 R344.1 203.13,48.52 203.13,47.01 203.27,46.87 R350.2 203.64,45.99 203.78,45.85 U23.4
DCPRTC: length 9.9
  BOTTOM w0.076: 137.01,100.48 136.07,101.41 U35.BB10
  BOTTOM w0.127: C732.1 143.69,100.22 143.19,99.71 138.99,99.71 138.59,100.12 137.36,100.12 137.01,100.48
DDCCLK: length 26.4
  TOP w0.114: U13.15 22.68,71 21.95,71.72 21.95,73.83 17.61,78.17 13.98,78.17 v1(13.68,78.48) ; v1(12.38,82.06) 12.62,82.06 C714.2 12.93,82.52 11.56,82.52 11.09,82.05 U36.5 U36.6 8.8,82.05 CN7.15
  IN1 w0.127: v1(12.38,82.06) 13.44,81 13.44,78.71 v1(13.68,78.48)
  BOTTOM w0.114: C714.2 12.76,82.44 v1(12.38,82.06)
DDCDAT: length 26.6
  TOP w0.114: v1(13.68,77.59) 14.02,77.93 17.51,77.93 21.71,73.73 21.71,71.62 22.28,71.06 U13.16 ; C724.1 v1(12.38,80.41) ; CN7.12 7.62,76.86 9.28,75.2 U38.7 U38.4 v1(11.79,75.2)
  IN1 w0.127: v1(11.79,75.2) 13.14,76.54 13.14,77.05 v1(13.68,77.59) 13.14,78.12 13.14,79.65 v1(12.38,80.41)
  BOTTOM w0.114: C724.1 v1(12.38,80.41)
DDI2_AUXN: length 23.5
  TOP w0.127: R533.2 v1(99.37,127.15)
  IN3 w0.114: v1(99.37,127.15) 99.37,126.94 99.22,126.79 98.99,126.79 98.81,126.97 98.81,127.28 99.44,127.91 109.78,127.91 112.32,125.37 112.32,124.54 113.49,123.37 113.49,121.15 113.34,120.99 113.14,120.99 113.04,121.1 v3(113.04,121.24)
  BOTTOM w0.127: U35.E48 113.29,120.99 v3(113.04,121.24) ; R533.2 v1(99.37,127.15)
DDI2_AUXP: length 23.5
  TOP w0.127: R532.1 v1(98.35,127.15)
  IN3 w0.114: v3(113.04,120.6) 113.2,120.76 113.44,120.76 113.72,121.05 113.72,123.46 112.55,124.63 112.55,125.46 109.88,128.14 99.35,128.14 v1(98.35,127.15)
  BOTTOM w0.127: v1(98.35,127.15) R532.1 ; U35.F48 113.2,120.6 v3(113.04,120.6)
  vias: v1(97.72,127.27)
DDI2_TXN0: length 8.9
  BOTTOM w0.076: U35.C50 112.39,122.41 112.3,122.51 112.3,122.64 112.39,122.73 112.59,122.73 112.74,122.88 112.8,123 112.8,123.08 112.73,123.31 112.73,123.5 112.79,123.67 112.79,125.95 112.7,126.04 112.7,126.05 112.68,126.07 112.62,126.07 112.62,126.06 112.6,126.08
  BOTTOM w0.127: 112.6,126.08 111.82,126.86 111.82,127.29 110.62,128.48 110.62,128.75 110.22,129.15 110.06,129.15 R10843.1
DDI2_TXN1: length 10.8
  BOTTOM w0.076: U35.C52 111.38,122.16 111.3,122.08 111.17,122.08 111.09,122.16 111.09,122.42 111.14,122.57 111.15,122.62 111.15,122.86 111.1,122.98 111.1,123.17 111.14,123.24 111.14,123.53 111.11,123.59 111.11,123.89 110.71,124.29 110.71,125.44 110.33,125.82 110.33,126.19 110.38,126.24 110.38,126.26
  BOTTOM w0.127: 110.38,126.26 110.38,126.81 110.09,127.1 110.09,127.86 109.58,128.37 109.58,128.9 109.16,129.32 109.16,130.96 R10845.1
DDI2_TXP0: length 8.9
  BOTTOM w0.076: 112.78,126.26 112.85,126.19 112.85,126.14 112.87,126.12 112.87,126.11 112.96,126.02 112.96,123.64 112.9,123.47 112.9,123.33 112.96,123.1 112.96,122.97 112.91,122.84 112.91,122.16 U35.D50
  BOTTOM w0.127: R10842.1 110.57,129.32 110.57,129.16 110.88,128.86 110.88,128.59 112.07,127.39 112.07,126.97 112.78,126.26
DDI2_TXP1: length 10.8
  BOTTOM w0.076: U35.D52 111.23,121.91 111.11,121.91 110.93,122.09 110.93,122.45 110.98,122.62 110.99,122.64 110.99,122.83 110.94,122.95 110.94,123.2 110.97,123.28 110.97,123.49 110.95,123.56 110.95,123.56 110.95,123.82 110.55,124.23 110.55,125.37 110.17,125.75 110.17,126.19 110.12,126.24 110.12,126.26
  BOTTOM w0.127: R10844.1 108.91,131.06 108.91,129.21 109.33,128.79 109.33,128.26 109.84,127.75 109.84,126.99 110.12,126.7 110.12,126.26
DDR3_DRAMRST#: length 112.9
  TOP w0.127: C1317.2 110.29,54.51 v1(109.84,54.05) 110.55,53.34 110.55,47.32 v1(108.97,45.75) 109.65,45.08 C1258.2 ; v1(151.82,92.09) 152.32,92.59 C750.1 R670.1
  IN3 w0.114: v1(151.82,92.09) 151.19,91.46 151.19,89.81 149.66,88.28 149.66,64.66 151.49,62.83 151.49,46.81 149.09,44.41 146.12,44.41 144.68,42.97 110.65,42.97 109.66,43.96 109.66,45.07 v1(108.97,45.75)
  BOTTOM w0.127: JDIM2.108 109.47,54.42 v1(109.84,54.05) ; v1(108.97,45.75) 109.47,45.25 JDIM1.108
DDR4_SUSON_2V5: length 17.5
  IN1 w0.089: v1(171.58,44.6) 172.52,44.6 175.47,41.65 v1(175.47,40.69)
  BOTTOM w0.127: v1(175.47,40.69) 176.76,39.39 179.25,39.39 180.78,40.91 182.53,40.91 183.18,41.56 U45.122 ; PR307.1 171.25,44.93 v1(171.58,44.6)
DDR_VTT_CTRL: length 11.4
  BOTTOM w0.076: U35.AW67 102.38,103.13 101.7,103.13 101.57,103 101.57,102.75 101.39,102.57 101.11,102.57 100.93,102.75 100.63,102.75 100.49,102.61 100.36,102.61 100.26,102.51 99.47,102.51 98.86,101.9 97.47,101.9 96.93,102.43 95.63,102.43
  BOTTOM w0.127: v1(94.19,101.16) 93.88,101.47 Q35.1 93.96,102.23 94.74,103.01 R621.2 95.63,102.43
DDR_VTTREF: length 50.2
  IN1 w1.397: 50.73,54.25 49.36,52.88 43.17,52.88 40.26,55.78 40.26,56.1
  IN1 w1.524: 50.73,54.25 53.9,57.42 57.46,57.42 57.94,56.94 67.47,56.94 70.67,53.74 75.75,53.74 77.91,51.58 77.91,47.77
  BOTTOM w0.203: v1(148.65,54.1) 148.97,54.42 JDIM2.258 ; JDIM1.258 148.97,41.98 v1(149.15,41.8)
  vias: v1(81.08,42.74) v1(81.59,42.29) v1(82.1,41.8) v1(148.16,54.86) v1(148.21,41.8) v1(148.21,41.17) v1(148.47,42.49) v2(42.02,57.78)
DDR_VTTT_PG_CTRL: length 87.6
  TOP w0.127: v1(89.72,103.15) 83.36,103.15 82.48,104.03 v1(78.03,104.03) ; v1(45.78,62.76) 45.86,62.67 PR6302.2
  IN1 w0.089: v1(45.78,62.76) 46.94,62.76 47.46,63.28 47.61,63.28 49.64,65.3 49.64,69.22 48.79,70.06 48.79,73.67 49.52,74.4 49.52,76.67 45.98,80.21 45.98,92.46 57.59,104.07 68.17,104.07 69.91,105.81 76.26,105.81 v1(78.03,104.03)
  BOTTOM w0.127: v1(89.72,103.15) 89.85,103.03 R682.2 90.99,103.03 91.12,102.89 Q35.3
DEVSLP0: length 144.7
  IN1 w0.089: v1(223.69,41.16) 223.33,41.16 220.91,43.58 220.91,46.46 215.42,51.95 214.63,51.95 214.24,52.34 214.24,52.8 210.68,56.36 192.5,56.36 192.19,56.67 183.38,56.67 182.73,57.32 177.62,57.32 177.03,57.91 177.03,58.89 175.6,60.32 175.6,61.12 174.68,62.04 174.68,62.67 174.21,63.14 174.21,63.88 173.38,64.71 172.77,64.71 171.38,66.1 171.38,66.81 170.74,67.45 170.5,67.45 169.12,68.83 169.12,71.51 167.3,73.33 167.3,75.97 165.55,77.73 165.55,78.68 164.28,79.96 164.28,83.47 165.12,84.31 165.12,86.29 164.38,87.02 164.38,88.54 164.9,89.06 164.9,90.32 164.74,90.48 164.74,104.98 159.5,110.21 158.33,110.21 156.95,111.59 156.95,115.35 153.03,119.27 147.63,119.27 147.1,119.8 145.45,119.8 144.65,120.61 v1(143.96,120.61)
  BOTTOM w0.127: R573.1 144.58,121.43 143.96,120.81 v1(143.96,120.61) 142.74,120.61 141.9,119.77 141.7,119.77 U35.J1 ; R351.1 v1(223.69,41.16)
DEVSLP0_R: length 7.3
  BOTTOM w0.127: R351.2 v1(225.36,40.41) 226.69,40.41 CN14.9
DEVSLP_N1: length 3.9
  BOTTOM w0.127: v1(167.16,93.7) 167.1,93.75 R956.1 R957.2 165.41,94.38 165.5,94.47 CN23.38
DGPU_D: length 26.6
  TOP w0.508: v1(197.41,107.21) 196.36,107.21 194.37,105.22 194.37,105.16 192.61,103.4 189.16,103.4 187.76,102 182.07,102 180.52,100.45 180.52,100.1 v1(180,99.57) 179.89,99.46 PQ19.2
  BOTTOM w0.508: v1(197.41,107.21) 197.03,106.83 PQ16.3 196.14,107.16 196.69,107.7 PR161.2 PC113.2
DGPU_EVENT#: length 57.5
  TOP w0.127: v1(188.8,106.32) 188.65,106.47 177.27,106.47 174.2,103.4 160.97,103.4 v1(159.82,104.54) ; v1(156.9,105.3) v1(156,105.3) 155.4,105.3 153.12,107.59 151.19,107.59 150.93,107.33 149.59,107.33 149.34,107.08 148.63,107.08 147.93,106.38 147.44,106.38 146.3,105.24 143.45,105.24 143.29,105.4 140.04,105.4 139.64,105.8 139.59,105.8 139.58,105.8 139.04,105.8 139.04,105.8 137.79,105.8 v1(137.74,105.85)
  IN1 w0.089: v1(156.9,105.3) 157.41,105.3 158.17,104.54 v1(159.82,104.54)
  BOTTOM w0.127: R4335.2 189.66,107.58 188.8,106.73 v1(188.8,106.32) ; v1(137.74,105.85) 137.85,105.85 U35.AP5
DGPU_HOLD_RST#: length 91.8
  TOP w0.127: v1(159.82,103.14) 160.08,102.89 176.18,102.89 179.46,106.17 187.94,106.17 188.26,105.85 189.71,105.85 v1(190.01,106.15) 190.81,106.95 194.38,106.95 195.39,107.97 200.21,107.97 201.63,106.55 v1(209.38,106.55) ; R208.1 149.73,108.21 149.23,107.72 148.3,107.72 148.11,107.53 147.44,107.53 146.3,106.38 145.08,106.38 144.73,106.03 144.71,106.03 144.6,105.91 140.29,105.91 139.63,106.57 139.02,106.57 138.89,106.7 138.86,106.7 138.85,106.71 138.51,106.71 138.5,106.7 137.88,106.7 v1(137.66,106.48)
  IN1 w0.089: v1(137.66,106.48) 137.94,106.48 138.61,105.81 144.71,105.81 145.22,105.3 152.2,105.3 152.98,104.52 153.69,104.52 154.44,103.78 158.81,103.78 159.44,103.14 v1(159.82,103.14)
  BOTTOM w0.127: v1(137.66,106.48) 137.57,106.48 U35.AP7 ; U4001.1 v1(209.38,106.55)
DGPU_OPP#: length 106.3
  TOP w0.127: Q4301.3 172.4,117.37 v1(172.65,117.62) ; v1(167.26,31.64) 167.91,32.29 168.47,32.29 169.02,32.84 169.02,34.74 172.01,37.74 172.01,38.68 172.73,39.39 173.92,39.39 v1(174.22,39.69) 174.94,40.41 174.94,45.26 175.27,45.59 175.27,47.92 175.34,48 175.34,58.29 v1(174.94,58.69)
  IN2 w0.114: v1(174.94,58.69) 173.69,58.69 170.16,62.22 170.16,67.54 170.62,67.99 170.62,74.76 169.17,76.21 169.17,81.36 169.6,81.8 169.6,83.47 168.31,84.77 168.31,87.75 170.03,89.48 170.03,94.33 172.7,97 172.7,103.91 173.25,104.45 173.25,108.08 172.4,108.93 172.4,117.11 172.65,117.37 v1(172.65,117.62)
  BOTTOM w0.127: U45.68 170.11,30.2 169.78,29.86 R382.1 168.98,29.36 166.6,29.36 166.33,29.64 166.33,30.93 166.6,31.21 166.83,31.21 v1(167.26,31.64)
DGPU_OTP#: length 115.4
  TOP w0.127: Q4301.6 169.84,115.57 169.73,115.46 169.73,115.34 v1(170.24,114.83)
  IN1 w0.089: v1(166.77,30.74) 167.19,31.16 168.45,31.16 171.93,34.63 174.55,34.63 175.63,35.72 177.62,35.72 177.9,36.01 183.69,36.01 184.41,36.73 184.41,38.2 184.97,38.75 184.97,42.41 v1(183.17,44.22) 181.27,46.11 180.49,46.11 179.33,47.26 177.95,47.26 177.04,48.17 177.04,50.15 172.98,54.22 172.98,54.36 172.64,54.7 v1(172.45,54.7)
  IN2 w0.114: v1(172.45,54.7) 172.61,54.7 172.88,54.97 172.88,59.18 169.93,62.13 169.93,67.63 170.35,68.05 170.35,74.7 168.94,76.11 168.94,81.46 169.37,81.89 169.37,83.38 168.08,84.67 168.08,87.9 169.8,89.63 169.8,94.42 172.47,97.09 172.47,104 173.02,104.55 173.02,107.98 171.76,109.24 171.76,113.3 v1(170.24,114.83)
  BOTTOM w0.127: R740.1 166.8,30.72 v1(166.77,30.74) ; v1(183.17,44.22) 183.7,44.22 183.98,43.93 U45.124
DGPU_PGOK-1: length 6.8
  BOTTOM w0.127: R4205.1 C4202.1 161.72,133.61 162.16,134.06 v1(162.16,134.31) 162.16,134.74 163.23,135.81 Q4202.2 163.23,137.15 163.63,137.56 Q4203.3
DGPU_POK2: length 3.3
  BOTTOM w0.127: v1(163.63,141.04) 163.88,141.29 R4207.1 C4203.1 162.88,141.37 162.62,141.11 162.62,140.35
DGPU_PSI: length 100.6
  IN1 w0.089: v1(187.64,61.23) 187.64,60.6 188.44,59.8 191.64,59.8 193.45,57.99 202.6,57.99 v1(204.98,60.37) ; v1(180.14,110.26) 180.73,110.84 180.73,112.11 181.79,113.18 183.06,113.18 183.46,113.58 183.46,115.7 v1(183.3,115.86)
  IN2 w0.114: v1(180.14,110.26) 180.14,108.85 179.3,108.01 179.3,105.15 178.32,104.17 178.32,93.47 179.86,91.93 179.86,84.57 176.25,80.96 176.25,75.08 176.81,74.52 176.81,66.69 178.42,65.09 178.42,63.6 180.78,61.23 v1(187.64,61.23)
  BOTTOM w0.127: v1(204.98,60.37) 205.29,60.68 PR101.2 ; U3002.M4 186.83,120.88 186.39,120.44 186.39,119.39 186.19,119.19 186.19,117.93 185.46,117.2 184.42,117.2 183.3,116.08 v1(183.3,115.86) 183.19,115.75 R4324.2
  BOTTOM w0.305: PR104.2 PR101.2 ; PR104.2 204.64,59.68 PR255.1 ; PR104.2 205.69,58.69 PR102.1
DGPU_PW_CTRL#: length 11.7
  BOTTOM w0.076: U35.BA5 138.36,101.77 138.74,101.39 139.16,101.39 139.39,101.16 139.39,100.87 139.81,100.44
  BOTTOM w0.127: 139.81,100.44 142.77,100.44 143.67,101.34 144.89,101.34 v1(145.05,101.51) 145.36,101.81 146.43,101.81 R127.2 147.13,102.25 148.13,102.25 R115.1
DGPU_PWR_EN: length 210.6
  TOP w0.127: v1(135.81,106.46) 136.33,105.94 136.33,105.68 137.06,104.95 138.56,104.95 140.24,103.27 144.11,103.27 144.43,102.95 145.03,102.95 v1(145.49,103.41) 145.73,103.65 v1(147.63,103.65) 148,103.65 R257.2 148.89,104.03 149.54,104.03 150.29,104.79 R256.1 ; PR160.1 v1(51.76,71.82)
  IN3 w0.114: v1(51.76,71.82) 52.21,72.26 56.85,72.26 58.63,70.48 69.06,70.48 71.09,68.45 77.5,68.45 80.13,65.82 80.13,45.61 83.24,42.5 83.24,41.93 84.64,40.53 106.36,40.53 107.17,41.35 118.97,41.35 119.84,42.22 124.4,42.22 125.28,41.35 144.14,41.35 146.46,43.66 149.4,43.66 152.24,46.5 152.24,63.14 150.41,64.97 150.41,83.46 151.44,84.49 151.44,86.25 153.22,88.03
  IN3 w0.127: v1(147.63,103.65) 147.38,103.65 147,103.27 147,102.25 147.25,102 148.27,102 149.54,100.73 150.17,100.73 152.33,98.57 152.33,95.52 153.22,94.63 153.22,88.03
  BOTTOM w0.127: U35.AP8 136.11,106.15 v1(135.81,106.46)
DGPU_PWROK: length 73
  TOP w0.127: R110.1 148.26,108.05 147.99,107.78 147.33,107.78 146.19,106.64 144.98,106.64 144.62,106.28 144.61,106.28 144.49,106.17 140.42,106.17 139.76,106.83 139.25,106.83 138.97,107.11 v3(137.7,107.11)
  IN1 w0.089: v3(137.7,107.11) 138.11,106.7 139.76,106.7 140.01,106.45 148.01,106.45 148.9,105.56 152.37,105.56 153.09,104.84 153.75,104.84 154.55,104.03 159.57,104.03 v1(159.82,103.78)
  IN2 w0.114: v1(164.67,133.7) 163.96,133.7 162.49,132.23 162.49,123.08 159.31,119.91 159.31,111.91 160.33,110.89 160.33,104.29 v1(159.82,103.78)
  BOTTOM w0.127: v3(137.7,107.11) 137.7,107.24 137.92,107.45 U35.AM5 ; Q4202.3 163.89,134 163.26,133.38 R4204.1 R4206.2 164.26,133.28 v1(164.67,133.7)
DMIC_CLK: length 1.9
  BOTTOM w0.127: U23.3 203.38,45.84 202.62,46.6 R370.2
DMIC_CLK0_R: length 11.1
  BOTTOM w0.076: 140.09,117.23 139.41,117.23 139.16,117.48 139.16,117.67 138.97,117.86 138.78,117.86 138.53,118.12 138.53,118.62 138.15,118.99 U35.H5
  BOTTOM w0.127: TP4372.1 146.61,118.89 143.19,118.89 141.52,117.23 140.09,117.23
DMIC_CLK_L: length 180.2
  TOP w0.127: v1(80.45,78) 78.91,78 R11047.2
  IN3 w0.114: v1(80.45,78) 79.94,77.49 79.94,77.11 80.5,76.55 80.5,75.89 79.94,75.33 79.94,70.81 81.08,69.67 81.08,67.95 v1(80.57,67.44) ; v1(201.86,49.3) 201.43,49.73 201.43,51.18 200.85,51.77 192.86,51.77 192.29,52.34 188.45,52.34 184.97,55.82 184.37,55.82 181.72,58.48 179.85,58.48 179,59.33 v1(179,60.12)
  BOTTOM w0.127: v1(179,60.12) 179,61.96 176.67,64.28 172.52,64.28 171.39,63.15 171.39,57.75 167.3,53.66 163.38,53.66 162.26,54.78 159.44,54.78 158.43,55.8 158.43,57.68 157.44,58.67 157.44,59.13 156.7,59.86 154.59,59.86 153.73,60.73 153.73,62.88 140.52,76.09 105.34,76.09 95.17,65.92 93.37,65.92 90.87,68.42 87.41,68.42 86.43,67.44 v1(80.57,67.44) ; R11186.2 86.81,83.2 81.6,78 v1(80.45,78) ; v1(201.86,49.3) 202.25,48.91 C488.1 R370.1
DMIC_CLK_L1: length 10.2
  TOP w0.127: v1(134.8,81.3) 134.9,81.3 135.63,82.03 135.63,84.69 135.06,85.26 134.47,85.26 134.04,84.82 U16.3
  BOTTOM w0.127: v1(134.8,81.3) 134.3,81.81 C378.1 D4.1 R11179.2 134.05,78.75 134.07,78.73 v1(134.07,78.71)
DMIC_CLK_L2: length 195.7
  TOP w0.127: v1(94.04,37.99) 94.67,37.36 116.83,37.36 120.65,33.54 148.7,33.54 153.66,38.5 155.19,38.5 155.89,39.2 155.89,40.21 156.37,40.7 156.37,43.24 157.05,43.92 157.05,45.26 157.5,45.7 157.5,53.35 157.64,53.49 157.64,59.11 156.9,59.85 156.9,61.87 157.41,62.38 157.41,64.64 156.34,65.71 153.2,65.71 149.94,68.97 149.94,75.07 152.47,77.59 165.39,77.59 166.68,78.89 168.59,78.89 169.86,80.16 172.4,80.16 v1(172.78,79.78) ; U4512.3 171.55,84.82 172.27,85.54 v1(172.27,85.67) ; R11182.1 v1(78.42,74.06)
  BOTTOM w0.127: v1(78.42,74.06) 78.01,73.65 78.01,66.55 79.41,65.15 79.41,61.14 78.14,59.87 78.14,47.91 78.9,47.15 78.9,45.71 78.14,44.95 78.14,41.4 80.63,38.91 86.9,38.91 88.32,37.48 93.78,37.48 94.04,37.74 v1(94.04,37.99) ; v1(172.78,79.78) 173.69,80.69 173.69,84.59 D4013.1 172.61,85.67 v1(172.27,85.67) 171.8,85.67 C4737.1
DMIC_CLK_L_R0: length 5.9
  TOP w0.127: U17.3 83.97,84.82 84.49,85.34 v1(85.38,85.34)
  BOTTOM w0.127: D2.1 86.03,86.6 86.04,86.61 v1(86.04,86.68) ; D2.1 C357.1 R11186.1 ; D2.1 85.91,85.87 v1(85.38,85.34)
DMIC_CLK_L_R1: length 69.8
  TOP w0.127: R11181.2 v1(79.43,76.09) R270.1
  IN3 w0.114: v1(80.55,68.09) 80.55,69.07 79.56,70.07 79.56,75.97 v1(79.43,76.09)
  BOTTOM w0.127: R11179.1 133.27,78.37 131.37,76.47 104.89,76.47 94.7,66.29 93.59,66.29 91.18,68.7 87.29,68.7 86.68,68.09 v1(83.37,68.09) v1(80.55,68.09)
DMIC_DAT: length 2.4
  BOTTOM w0.127: U23.2 202.98,45.89 202.49,46.37 202.1,46.37 R371.2
DMIC_DAT_L: length 177.4
  TOP w0.127: v1(80.45,77.24) 80.18,77.5 R270.2
  IN3 w0.114: v1(80.57,66.8) 81.35,67.57 81.35,69.78 80.21,70.92 80.21,75.22 80.83,75.84 80.83,76.85 v1(80.45,77.24) ; v1(201.86,48.66) 201.16,49.36 201.16,51.05 200.71,51.5 192.75,51.5 192.18,52.07 188.34,52.07 184.87,55.54 184.28,55.54 181.61,58.21 179.74,58.21 178.54,59.41 v1(178.54,60.57)
  BOTTOM w0.127: v1(201.86,48.66) 201.86,48.28 201.61,48.03 R371.1 ; v1(80.45,77.24) 79.94,77.74 79.94,78.12 80.26,78.44 80.63,78.44 80.96,78.77 80.96,82.65 81.89,83.58 R11185.2 ; v1(80.57,66.8) v1(85.02,66.8) 86.18,66.8 87.53,68.14 90.76,68.14 93.26,65.64 95.28,65.64 105.46,75.81 140.4,75.81 153.45,62.77 153.45,60.61 154.47,59.58 156.58,59.58 157.16,59.01 157.16,58.55 158.15,57.56 158.15,55.68 159.32,54.5 162.15,54.5 163.26,53.39 167.42,53.39 171.72,57.69 171.72,63.09 172.64,64 176.56,64 178.54,62.02 v1(178.54,60.57)
DMIC_DAT_L1: length 8.6
  TOP w0.127: v1(131.25,82.82) 130.64,83.43 130.64,85.01 130.89,85.26 131.6,85.26 132.04,84.82 U16.4
  BOTTOM w0.127: v1(130.41,79.47) 131.19,79.47 R11180.2 C379.1 D5.1 131.24,82.81 v1(131.25,82.82)
DMIC_DAT_L2: length 195
  TOP w0.127: v1(78.54,73.43) 79.43,74.31 R11181.1 ; v1(172.78,80.41) 172.75,80.44 169.74,80.44 168.47,79.17 166.56,79.17 165.27,77.87 152.35,77.87 149.66,75.18 149.66,68.85 153.09,65.43 156.22,65.43 157.13,64.52 157.13,62.49 156.62,61.98 156.62,59.74 157.36,59 157.36,53.74 157.21,53.59 157.21,46.37 156.77,45.94 156.77,44.04 156.09,43.35 156.09,40.81 155.61,40.33 155.61,39.31 155.07,38.78 153.55,38.78 148.58,33.81 120.77,33.81 116.95,37.64 95.15,37.64 v1(94.8,37.99) ; U4512.4 169.51,84.82 v1(168.87,85.47)
  BOTTOM w0.127: v1(78.54,73.43) 78.29,73.17 78.29,66.67 79.69,65.27 79.69,61.02 78.42,59.75 78.42,48.03 79.18,47.26 79.18,45.6 78.42,44.84 78.42,41.52 79.62,40.32 79.65,40.32 80.78,39.19 87.43,39.19 v1(88.19,38.42) 92.69,38.42 92.89,38.63 94.16,38.63 v1(94.8,37.99) ; v1(172.78,80.41) 172.98,80.61 172.98,82.14 172.45,82.67 171.56,82.67 171.15,83.08 C4736.1 D4012.1 170.37,84.67 170.06,84.98 169.35,84.98 v1(168.87,85.47)
DMIC_DAT_L_R0: length 6.4
  TOP w0.127: v1(80.7,86.25) 80.7,86.15 82.03,84.82 U17.4
  BOTTOM w0.127: v1(80.7,86.25) 81.08,86.63 v1(81.36,86.63) D3.1 C374.1 82.35,85.48 R11185.1
DMIC_DAT_L_R1: length 68.6
  TOP w0.127: R11182.2 v1(78.42,76.09) R11047.1
  IN3 w0.114: v1(79.97,69.06) 79.28,69.74 79.28,74.72 78.42,75.58 v1(78.42,76.09)
  BOTTOM w0.127: R11180.1 v1(132.02,78.51) 132.02,77.75 131.12,76.85 104.87,76.85 94.58,66.57 93.71,66.57 91.29,68.98 87.18,68.98 86.98,68.78 80.24,68.78 v1(79.97,69.06)
DMIC_DATA0_R: length 1.5
  TOP w0.127: TP4373.1 137.22,121.81 v1(136.81,121.41)
  BOTTOM w0.127: U35.D7 137.17,121.76 v1(136.81,121.41)
DNBSWON#: length 87.2
  IN1 w0.089: v1(181.16,40.42) 181.16,40.41 180.52,41.04 180.52,42.06 179.51,43.07 178.24,43.07 177.22,44.09 177.22,45.16 175.69,46.68 175.69,49.37 173.47,51.6 168.68,51.6 168.2,51.12 165.04,51.12 164.37,51.8 161.77,51.8 157.92,55.65 157.92,62.12 155.54,64.5 155.54,66.79 154.19,68.13 154.19,77.7 154.88,78.38 154.88,79.48 v1(153.5,80.86)
  BOTTOM w0.127: v1(153.5,80.86) 148.82,80.86 141.05,88.63 138.37,88.63 135.82,91.18 R677.1 ; v1(181.16,40.42) 181.17,40.41 182.76,40.41 183.58,41.23 U45.123
DP_UTIL: length 13.2
  IN1 w0.089: v1(111.18,125.88) 111.18,127.53 108.9,129.81 108.9,130.3 v1(107.63,131.57)
  BOTTOM w0.127: v1(111.18,125.88) 110.93,125.62 110.93,124.35 111.16,124.12 111.46,124.12 111.69,123.9 111.69,123.37 U35.B52 ; R546.2 v1(107.63,131.57) 107.96,131.24 107.96,130.52 R553.2
DPWROK_R: length 4.6
  BOTTOM w0.076: U35.BB20 129.85,100.85 132.52,98.18 132.52,97.94
  BOTTOM w0.127: R661.1 132.52,97.94
EC_FPBACK#: length 324
  IN1 w0.089: v1(173.16,37.37) 173.13,37.35 172.33,37.35 170.78,35.8 170.32,35.8 168.71,34.18 164.96,34.18 163.44,32.66 161.38,32.66 160.6,31.88 160.22,31.88 157.22,28.89 113.72,28.89 113.42,29.19 81.08,29.19 67.01,15.11 57.48,15.11 56.83,15.77 55.5,15.77 47.04,24.23 45.96,24.23 43.06,27.13 43.06,32.22 41.52,33.75 41.52,35.92 35.06,42.38 35.06,51.21 33.72,52.55 33.72,60.61 35.74,62.63 36.76,62.63 40.32,66.19 40.32,67.34 43.33,70.36 43.33,73.93 43.15,74.11 43.15,78.8 44.38,80.03 44.38,94.64 54.79,105.06 57.34,105.06 60.89,108.6 69.91,108.6 v1(77.4,116.1)
  IN2 w0.114: v1(111.82,157.75) 111.82,156.1 110.8,155.09 109.69,155.09 106.26,151.66 106.26,150.03 105.58,149.35 105.58,148.97 103.61,146.99 103.61,145.49 102.41,144.29 96.37,138.25 96.37,137.77 93.71,135.1 88.23,129.62 88.23,126.7 84.53,123.01 84.53,121.4 81.67,118.54 81.67,117.52 80.25,116.1 v1(77.4,116.1)
  BOTTOM w0.127: U45.86 172.61,37.4 172.78,37.23 173.02,37.23 v1(173.16,37.37) ; Q4.2 112.17,157.4 v1(111.82,157.75)
EC_GND: length 86.9
  TOP w0.508: v1(166.55,31.67) 166.05,31.16 v1(166.05,31.08) v1(166.05,27.3) 166.05,27.08 166.58,26.55 169.04,26.55 170.45,27.96 177.8,27.96 179.56,26.21 v1(179.56,26.18) ; v1(183.88,38.63) 182.94,38.63 182.81,38.5 R784.1
  IN1 w0.508: v1(170.37,36.88) 170.37,37.34 172.32,39.29 175.09,39.29 176.21,40.41 176.21,42.44 175.47,43.17 v1(175.47,44.6)
  IN2 w0.508: v1(182.05,33.04) 186.37,33.04 187.51,31.9 189.41,31.9 190.56,30.75 190.56,29.61 190.18,29.23 v1(189.15,29.23) 187.64,29.23 185.45,27.05 180.18,27.05 179.56,26.42 v1(179.56,26.18)
  IN3 w0.508: v1(166.55,31.67) 166.55,32 166.83,32.28 168.59,32.28 169.47,33.17 169.47,34.44 170.63,35.59 170.63,36.61 v1(170.37,36.88)
  BOTTOM w0.203: 170.36,38.88 170.36,39.14 170.62,39.4 U45.91 ; v1(179.56,26.18) 179.18,26.56 U45.49 ; U45.27 188.13,31 188.52,30.61 ; v1(183.88,38.63) 184.57,38.63 184.84,38.89 184.84,40.37 185.87,41.4 U45.1
  BOTTOM w0.508: v1(189.15,29.23) R782.1 189.15,29.98 188.52,30.61 ; v1(166.05,27.3) 165.91,27.44 L11.1 ; v1(170.37,36.88) 170.13,37.11 R783.1 169.73,38.25 170.36,38.88 ; v1(182.05,33.04) 181.54,33.55 181.54,37.36 182.81,38.63 v1(183.88,38.63)
EC_ODD_EJ#: length 130.5
  TOP w0.127: CN9.11 230.72,106.96 R209.1 v1(228.93,106.96) 228.28,106.96 v1(227.89,106.57) ; v1(164.78,75.25) 166.49,76.97 170.54,76.97 172.6,79.03 173.15,79.03 173.39,79.27 174.7,79.27 175.06,78.91 175.06,77.74 v1(175.57,77.24)
  IN1 w0.089: v1(227.89,106.57) 227.89,105.68 227.13,104.92 215.93,104.92 213.61,102.6 207.71,102.6 207.02,101.9 205.59,101.9 204.82,102.67 195.48,102.67 194.57,101.75 187.3,101.75 186.8,101.25 180.69,101.25 179.23,99.8 179.23,95.46 178.94,95.16 178.94,91.07 177.44,89.57 177.44,86.71 176.43,85.7 176.43,78.1 v1(175.57,77.24)
  IN3 w0.114: v1(164.78,75.25) 164.65,75.13 164.65,65.88 166.02,64.51 166.93,64.51 167.26,64.18 167.26,62.35 169.82,59.79 169.82,53.07 168.97,52.22 168.97,51.07 169.42,50.62 v1(169.42,44.85)
  BOTTOM w0.127: v1(169.42,44.85) 169.42,44.59 169.47,44.55 R746.1
EC_ODD_EJ#_R: length 5.2
  BOTTOM w0.127: U45.94 170.77,40.6 170.57,40.8 170.57,41.65 v1(171.2,42.29) 171.25,42.34 C799.1 171.25,43.21 R746.2
EC_PECR_R: length 5.2
  BOTTOM w0.127: U45.117 181.18,43.82 181.71,44.34 181.9,44.34 182.63,45.08 v1(182.63,45.84) 182.63,46.98 R738.1
EC_PWROK: length 138.1
  TOP w0.127: R560.2 180.53,37.24 180.24,36.95 180.24,36.11 180.4,35.96 U8.2 182.05,35.96 182.17,35.83 R130.2 182.8,36.46 v1(182.81,36.47)
  IN1 w0.089: v1(182.81,36.47) 183.08,36.2 183.61,36.2 184.21,36.79 184.21,37.48 183.42,38.27 183.42,41.45 178.97,45.89 178.97,46.88 178.8,47.06 177.87,47.06 176.84,48.09 176.84,49.93 172.7,54.07 v1(172.45,54.07)
  IN2 w0.114: v1(172.45,54.07) 171.63,54.88 171.63,59.46 169.24,61.85 169.24,72.04 169.25,72.04 169.25,75.15 167.42,76.98 165.03,76.98 163.76,78.25 163.76,80.79 165.28,82.32 165.28,86.32 164.52,87.08 164.52,88.79 164.86,89.14 164.86,90.32 164.44,90.74 164.44,92.65 163.3,93.79 163.3,101.01 163.94,101.65 163.94,102.59 162.24,104.29 162.24,114.57 v1(160.2,116.61)
  BOTTOM w0.127: U45.33 185.58,28.11 183.57,30.12 181.79,30.12 181.6,30.31 181.6,31.43 182.56,32.38 182.56,33.55 182.3,33.8 182.3,35.96 v1(182.81,36.47) ; R131.2 143.58,128.82 151.24,128.82 154.36,125.71 154.36,122.37 157.07,119.67 157.76,119.67 160.2,117.23 v1(160.2,116.61)
EC_PWROK_R: length 12.5
  BOTTOM w0.076: U35.BA20 129.8,101.74 129.43,101.37 129.43,100.9 132.01,98.32 132.01,97.94
  BOTTOM w0.127: 132.01,97.94 132.01,94.26 R643.2 132.52,93.75 131.76,92.98 v1(131.76,92) 131.76,91.84 131.63,91.71 R647.1
EC_RCIN#: length 12.5
  BOTTOM w0.076: 135.31,97.94 135.31,98.06 133.24,100.14 133.24,100.61 133.06,100.79 133.06,101.23 133.08,101.26 133.11,101.34 133.11,101.46 133.05,101.68 133.05,101.82 133.1,101.98 133.1,102.43 133.49,102.82 U35.AW13
  BOTTOM w0.127: 135.31,97.94 135.31,94.63 R639.2 135.94,93.37 v1(136.08,93.23) 136.65,92.67 136.65,92.29 R652.2
