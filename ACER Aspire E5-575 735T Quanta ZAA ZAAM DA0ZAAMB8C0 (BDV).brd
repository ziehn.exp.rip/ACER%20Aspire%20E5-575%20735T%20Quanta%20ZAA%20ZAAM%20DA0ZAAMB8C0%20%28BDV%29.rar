# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PVDD: length 10.1
  BOTTOM w0.508: L13.1 197.54,49.22 198.38,50.06 199.62,50.06 199.83,50.26 199.83,51.96 Q28.1 200.34,52.98 200.55,53.2 v1(201.28,53.2) R338.1
V0P85A_VID0: length 11.7
  TOP w0.127: v3(134.95,106.48) 134.95,106.47 135.37,106.06 135.37,104.36 135.79,103.93 135.79,101.78 v1(138.99,98.57)
  BOTTOM w0.127: v3(134.95,106.48) U35.AN11 ; v1(138.99,98.57) 138.84,98.42 TP31.1
VCCGT_PHASE1: length 12.2
  TOP w0.762: v2(121.24,152.47) 121.64,152.87 v1(121.64,153.5) PR57.1
  IN3 w0.508: v2(121.44,161.67) 121.57,161.67 122.15,161.08 122.15,153.39 v2(121.24,152.47)
VCCGT_PHASE2: length 8.7
  TOP w0.762: PR58.1 130.31,154.15 v1(130.45,154.01) v2(131.1,153.36)
  IN3 w0.508: v2(131.04,161.84) 131.04,161.74 131.83,160.95 131.83,157.6 131.22,156.99 v3(131.22,155.75)
VCCGT_SENSE: length 95.9
  TOP w0.127: PR191.1 133.91,166.59 125.84,166.59 124.31,168.12 122.18,168.12 v1(121.72,167.66) ; v1(97.73,119.23) 97.31,119.65 R155.2 ; v1(113.59,155.65) 112.96,155.01 112.96,153.56 111.94,152.55 105.44,152.55 104.07,151.18 104.07,150.93 103.05,149.91 103.05,149.62 102.48,149.05 102.48,148.55 101.66,147.73 101.66,146.45 93.27,138.07 93.27,133.15 90.58,130.45 89.46,130.45 88.19,129.18 88.19,122.3 87.84,121.94 v1(87.56,121.94)
  IN1 w0.089: v1(97.73,119.23) 97.73,119.21 97.63,119.11 90.04,119.11 87.56,121.59 v1(87.56,121.94) ; v1(113.59,155.65) 113.51,155.73 113.51,156.78 113.9,157.17 113.9,160.87 114.5,161.46 114.5,162.01 117.64,165.15 119,165.15 120.07,166.21 120.07,167.15 120.67,167.75 121.62,167.75 121.71,167.66 v1(121.72,167.66)
  BOTTOM w0.127: v1(97.73,119.23) 97.76,119.21 99.16,119.21 99.21,119.16 100.51,119.16 U35.J70
VCCGT_VBST1:
  vias: v1(120.99,162.3)
VCCGT_VBST2:
  vias: v1(129.98,162.2)
VCCGT_VCC1:
  vias: v1(117.66,161.46) v1(118.32,161.44)
VCCGT_VCC2:
  vias: v1(127.31,160.52) v1(127.87,160.83)
VCCK_V12: length 14.3
  TOP w0.203: 21.88,65.5 21.93,65.5 22.28,65.85 U13.25 ; C4748.2 27.61,67.76 27.22,68.15 U13.4
  TOP w0.508: v1(26.98,67.66) 27.56,67.66 C4748.2 ; 21.88,65.5 21.52,65.15 v1(21.52,65.09) C4751.2 C4754.2 20.4,64.69 v1(20.76,65.04)
  IN1 w0.508: v1(26.98,67.66) 25.38,66.06 22.28,66.06 21.27,65.04 v1(20.76,65.04)
VCCOPC_VID0: length 3
  TOP w0.127: v1(50.02,82.29) 49.74,82.01 v1(49.38,82.01)
  TOP w0.305: v1(49.38,82.01) 48.95,82.44 R708.1
  BOTTOM w0.305: 49.33,82.01 49.26,82.09 49.19,82.09 R708.1 ; 49.33,82.01 49.41,82.09 49.45,82.09 PR287.2 ; 49.33,82.01 v1(49.38,82.01)
VCCOPC_VID0_C: length 4.1
  BOTTOM w0.127: PR287.1 50.71,82.81 50.37,83.15 49.73,83.15 49.4,83.48 v1(48.9,83.48)
  BOTTOM w0.254: PR287.1 51.36,82.57 51.56,82.37 PU14.4
VCCOPC_VID1: length 3.3
  TOP w0.305: R705.1 48.83,81.54 v1(49.36,81.02)
  BOTTOM w0.127: R705.1 48.37,81.09 v1(48.37,80.82)
  BOTTOM w0.305: R705.1 48.83,81.27 49.08,81.02 v1(49.36,81.02) 49.43,81.02 PR286.2
VCCOPC_VID1_C: length 1.9
  BOTTOM w0.254: PR286.1 51.03,81.5 v1(51.42,81.88) 51.71,81.88 51.72,81.87 PU14.3
VCCRTC_2: length 3.5
  TOP w0.635: BT1.1 72.33,50.7 v1(72.57,50.95) R308.1
VCCSA_SW: length 8
  TOP w0.762: v2(148.9,153.18) 149.65,152.43 PR59.1
  IN3 w0.508: v2(153.19,162.1) 153.65,161.64 153.65,156.56 v2(153.07,155.98)
  vias: v1(153.09,155.16)
VCCSA_VBST: length 2.8
  BOTTOM w0.127: v1(151.77,165.32) 151.34,164.89 151.34,163.65 151.89,163.1 PR232.2
VCCSA_VCC: length 1
  BOTTOM w0.127: v1(147.45,160.5) 147.52,160.56 PC151.2
VCCST_PWRGD: length 88.9
  IN1 w0.089: v1(145.22,137.31) 144.79,137.73 131.17,137.73 130.06,138.84 125.88,138.84 125.22,139.51 125.22,141.13 122.35,144 118.42,144 114.11,139.68 106.14,139.68 105.35,140.47 103.06,140.47 101.73,141.8 v1(101.73,142.87) ; v1(101.78,125.11) 95.69,125.11 93.02,127.78 v1(90.86,127.78)
  IN2 w0.114: v1(101.73,142.87) 101.58,142.87 96.79,138.07 96.79,136.28 95.19,134.68 93.88,134.68 90.86,131.67 v1(90.86,127.78)
  BOTTOM w0.076: U35.B65 103.95,123.18 103.71,123.42 103.71,123.55 103.68,123.62 103.68,124.62 103.43,124.86 102.04,124.86 v1(101.78,125.11)
  BOTTOM w0.127: v1(145.22,137.31) 145.09,137.18 C136.2 R89.1
VCCST_PWRGD_EN: length 4.5
  BOTTOM w0.305: U47.1 140.92,133.23 R102.1
  BOTTOM w0.508: R777.2 140.24,131.97 v1(140.06,132.15) 140.06,132.52 140.15,132.61 R103.1 R102.1
VCCST_PWRGD_EN_L: length 12.1
  BOTTOM w0.127: v1(141.97,135.92) 141.98,135.9 C824.2 C823.2 144.07,135.9 144.55,135.43 145.83,135.43 146.23,135.02 146.23,134.26 145.98,134 U6.2 144.2,134 143.68,134.53 U47.4 142.9,134.53 142.42,134.06 142.42,132.99 141.67,132.24 R777.1
VCCST_PWRGD_R: length 3.6
  BOTTOM w0.127: U6.4 147.9,134.65 148.11,134.87 v1(148.11,135.3) 147.51,135.9 R85.1 R89.2
VDD10: length 11.1
  TOP w0.203: C760.1 39.24,67.53 39.24,68.19 38.9,68.52 U15.33 ; U15.46 41.93,74.06 42.12,74.26 ; U15.3 39.3,76.32 39.43,76.45 39.43,77.24 39.55,77.36 C757.1 ; U15.8 37.3,77.37 36.89,77.79 C355.1
  TOP w0.508: v1(38.66,67.96) 38.66,67.72 C760.1 ; v1(37.52,78.25) 37.13,77.86 C355.1 ; v1(38.89,78.66) 39.39,78.66 C757.1
  vias: v1(28.91,72.92) v1(29.55,73.02) v1(42.58,75) v1(45.27,76.22) v1(45.27,68.75) v1(45.9,68.75)
VDD_DAC_33: length 1.1
  TOP w0.203: U13.20 20.74,68.55 v1(20.55,68.73)
VDDREG:
  vias: v1(40.44,68.22)
VIN: length 203.1
  TOP w0.254: v1(56.06,104.41) 46.89,104.41 43.62,107.69 v1(43.62,107.71) PD4.2
  TOP w0.381: v1(44.13,51.79) 44.15,51.76 44.25,51.76 44.96,52.47 PR261.2 ; 51.87,74.49 52.14,74.23 PR159.1
  TOP w0.508: v1(208.34,59.33) 209.48,59.33 215.68,65.53 215.68,78.28 v2(213.67,80.28) ; v1(47.66,36.88) 47.33,36.88 46.76,36.31 PR148.1 PR151.1 ; PR141.1 67.93,106.06 v1(67.24,105.38) 67.49,105.13 PR142.1 ; v1(222.69,106.7) 222.69,107.72 223.07,108.1 R686.2 ; PR6130.1 48.82,42.56 v1(48.7,42.69)
  IN2 w0.508: v2(54.64,77.34) 51.9,77.34 48.19,81.05 48.19,97.56 55.05,104.41 v1(56.06,104.41) 66.27,104.41 v1(67.24,105.38)
  BOTTOM w0.152: 211.33,184.12 211.05,184.4 208.57,184.4 PR209.1
  BOTTOM w0.381: PR116.1 223.14,177.34 PC292.1 223.16,177.2 222.48,176.52 222.48,175.43 222.92,175 ; v2(56.37,66.64) 55.17,66.64 51.67,63.15 51.67,60.1 47.89,56.32 47.42,56.32 47.41,56.33 46.74,56.33 45.22,54.81 45.22,54.19 45.23,54.18 45.23,53.71 45.22,53.69 45.22,52.9 44.1,51.79 v1(44.13,51.79) ; 60.92,74.17 61.08,74.17 61.5,73.76 61.5,72.05 61.3,71.86 PC271.1 61.3,70.93 61.71,70.52 PR97.1
  BOTTOM w0.508: v1(48.7,42.69) 49.13,42.69 51.29,44.85 54.08,44.85 54.36,45.13 ; PR161.1 198.56,108.35 200.84,106.06 205.54,106.06 207.19,104.41 214.94,104.41 215.73,105.2 219,105.2 219.54,104.67 ; 219.54,104.67 219.54,99.99 218.62,99.08 ; 219.54,104.67 220.91,104.67 222.69,106.45 v1(222.69,106.7) ; R345.1 197.16,51.84 197.41,52.09 PR260.1 197.74,53.6 197.8,53.66 197.8,53.66 198,53.87 198.25,53.87 198.58,54.2 199.12,54.2 199.13,54.21 202.91,54.21 203.23,53.89 203.34,53.89 203.36,53.87 204.98,53.87 205.36,54.25 207.83,54.25 208.34,54.76 v1(208.34,59.33) ; PR212.2 132.91,176.16 133.15,175.91 133.15,175.28 132.77,174.9 132.01,174.9 131.12,174.01 131.12,171.22 132.14,170.2
  vias: v1(115.6,161.9) v1(116.26,161.9) v1(116.26,161.27) v1(141.43,159.33) v1(177.2,79.45) v1(180.75,74.67) v1(209.25,73.3) v2(51.47,66.82) v2(51.47,65.3) v2(51.47,32.25) v2(51.49,31.34) v2(51.49,30.45) v2(51.92,66.06) v2(52.33,66.87) v2(52.3,65.25) v2(52.38,31.77) v2(52.38,30.88) v2(52.38,29.86) v2(52.61,79.12) v2(52.74,74.11) v2(52.91,79.8) v2(53.3,74.62) v2(53.27,31.16) v2(53.3,30.25) v2(53.68,79.85) v2(54.18,30.32) v2(54.62,76.09) v2(54.62,74.42) v2(55.3,44.6) v2(55.68,43.96) v2(56.19,44.6) v2(56.37,67.66) v2(56.6,32.18) v2(56.7,43.96) v2(56.98,66.11) v2(57.05,67.23) v2(57.21,44.6) v2(57.36,31.62) v2(58.86,76.85) v2(58.86,76.09) v2(59.62,76.85) v2(59.62,76.09) v2(131.81,167.53) v2(132.14,164.23) v2(132.67,167.56) v2(132.92,164.23) v2(133.46,167.56) v2(133.66,164.23) v2(134.4,164.23) v2(135.13,164.23) v2(138.79,159.33) v2(139.12,159.99) v2(139.53,159.35) v2(140.01,159.94) v2(140.47,159.35) v2(140.9,159.96) v2(142.53,161.01) v2(143.19,161.36) v2(144.1,163.67) v2(144.89,163.67) v2(146.16,165.93) v2(146.61,166.52) v2(147,165.88) v2(148.32,169.06) v2(148.34,168.32) v2(149,170.28) v2(148.98,169.49) v2(148.98,168.7) v2(148.98,167.84) v2(151.47,159.89) v2(151.75,160.57) v2(152.2,159.89) v2(152.48,160.57) v2(152.94,159.91) v2(158.83,166.21) v2(159.16,165.4) v2(159.59,166.21) v2(159.92,165.4) v2(161.55,178.79) v2(161.55,178.05) v2(162.31,178.79) v2(162.31,178.05) v2(164.27,180.82) v2(178.72,80.16) v2(179.15,79.52) v2(179.58,80.18) v2(180.12,79.5) v2(180.55,80.16) v2(181.11,79.52) v2(181.54,80.18) v2(182.15,79.64) v2(208.08,81.22) v2(208.51,81.99) v2(209.02,81.27) v2(209.53,82.06) v2(210.14,182.29) v2(210.11,180.89) v2(210.17,81.25) v2(210.65,82.01) v2(210.83,181.6) v2(211.11,81.25) v2(211.54,182.32) v2(211.64,180.84) v2(212.1,181.53) v2(215.58,98.57) v2(215.58,97.68) v2(215.58,96.79) v2(218.24,98.57) v2(218.24,97.68) v2(218.24,96.79) v2(224.92,174.62) v2(224.92,173.86) v2(224.92,173.12) v2(225.68,174.62) v2(225.86,170.23) v2(226.29,169.46) v2(226.68,170.25) v2(227.18,169.44) v2(227.49,170.23) v2(230.64,127.1) v2(230.64,126.11) v2(230.64,125.22) v2(231.27,126.51) v2(231.32,125.62) v2(231.32,124.89) v2(231.45,156.74) v2(231.45,155.98) v2(231.45,155.21) v2(231.45,154.45)
VSSGT_SENSE: length 98.1
  TOP w0.127: v1(87.05,121.3) 87.74,121.3 88.58,122.14 88.58,129.02 89.62,130.07 90.73,130.07 93.66,132.99 93.66,137.91 102.04,146.29 102.04,147.57 102.86,148.39 102.86,148.89 103.43,149.46 103.43,149.75 104.45,150.77 104.45,151.02 105.59,152.17 112.1,152.17 113.34,153.4 113.34,154.76 v1(113.59,155.01) ; R161.1 97.69,118.64 v1(97.73,118.6) ; v1(122.36,167.66) 122.43,167.74 124.16,167.74 125.68,166.21 134.06,166.21 134.22,166.36 PR181.1
  IN1 w0.089: v1(113.59,155.01) 113.16,155.44 113.16,156.92 113.56,157.31 113.56,161.01 114.15,161.61 114.15,162.15 117.49,165.49 118.86,165.49 119.73,166.35 119.73,167.29 120.53,168.09 121.93,168.09 v1(122.36,167.66) ; v1(97.73,118.6) 97.57,118.76 89.9,118.76 87.36,121.3 v1(87.05,121.3)
  BOTTOM w0.127: U35.J69 101.16,118.5 98.99,118.5 98.89,118.6 v1(97.73,118.6)
1P35V_BOOT:
  vias: v1(44.86,59.86)
1P35V_CS: length 2.8
  TOP w0.203: PU21.13 47.3,56.56 47.58,56.28 v1(47.83,56.28) 48.27,56.71 48.27,56.88 PR250.2
1P35V_FB: length 4.4
  TOP w0.203: PR258.1 41.02,54.44 41.76,55.19 43.87,55.19 43.96,55.1 PU21.6
  TOP w0.305: PR266.1 40.03,54.44 PR258.1
1P35V_LGATE: length 12.8
  IN3 w1.016: v2(47.31,57.89) 47.58,58.16 53.85,58.16 57.16,61.46 v2(57.46,61.46)
  BOTTOM w0.127: v1(57.51,62.61) 57.51,61.51 v2(57.46,61.46)
1P35V_PGOOD: length 1.8
  TOP w0.203: PR267.1 45.56,53.71 PU21.10
1P35V_PHASE: length 16.5
  TOP w0.762: PR90.1 63.18,59.56 v2(63.79,60.17)
  IN3 w1.016: v2(60,63.37) 59.85,63.22 54.34,63.22 51.14,60.01 47.66,60.01 v2(46.92,59.28)
  vias: v1(60.94,63.27)
1P35V_S3: length 17
  TOP w0.127: v1(44.89,62.71) 44.89,62.49 45.08,62.3 PR6302.1
  TOP w0.203: v1(43.54,53.99) 43.92,53.99 44.29,54.36 44.3,54.36 44.36,54.42 PU21.7
  TOP w0.305: v1(43.54,53.99) 43.38,53.84 42.65,53.84 42.13,53.32 PC196.1 41.26,53.32 PR257.1 40.96,53.75 41.08,53.87 41.71,53.87 41.93,54.09 PR6303.2
  BOTTOM w0.203: v1(44.89,62.71) v1(43.86,61.68) 42.63,60.45 42.63,54.71 43.34,53.99 v1(43.54,53.99)
1P35V_S5: length 6
  TOP w0.203: v1(43.37,54.66) 43.16,54.45 PR6303.1 ; v1(44.66,53.94) 44.76,54.05 PU21.8
  TOP w0.305: v1(44.66,53.94) 44.03,53.32 PR263.1
  TOP w0.381: PC203.1 PR263.1
  IN2 w0.305: v1(43.37,54.66) 43.95,54.66 v1(44.66,53.94)
  BOTTOM w0.127: v1(44.66,53.94) 44.56,54.05 v1(44.56,54.71)
1P35V_TON: length 1.7
  TOP w0.203: PU21.9 45.16,53.73 44.96,53.54 PR261.1
1P35V_UGATE: length 15.6
  IN3 w1.016: v2(58.02,64.82) 53.32,64.82 49.97,61.46 46.89,61.46 45.78,60.34 v2(45.78,59.89)
  BOTTOM w0.127: v2(58.02,64.82) 57.51,64.31 v1(57.51,63.98)
1P35V_VDD: length 6.1
  TOP w0.127: v1(49.69,58.77) 49.95,58.5 49.95,57.42 49.69,57.16 PC217.1
  TOP w0.203: PU21.12 47.12,56.16 47.48,55.8 48.09,55.8 48.37,56.08 PR274.2
  TOP w0.305: PC217.1 49.37,57.16 48.66,56.45 PR274.2
1P35V_VDDQ: length 30.6
  TOP w0.127: PR254.2 66.91,59.34 v1(66.91,60.07)
  TOP w0.203: PU21.5 42.21,55.76 v1(42.12,55.67) 42.02,55.57 41.48,55.57 41.14,55.22 PR258.2
  TOP w0.381: v1(66.07,59.3) 66.1,59.33 PR254.2
  IN3 w0.381: v1(66.07,59.3) 66.1,59.3 66.15,59.25 65.44,58.54 65.41,58.54 64.39,57.53 54.67,57.53 52.95,55.8 51.39,55.8 50.42,54.83 49.13,54.83 48.16,55.8 46.34,55.8 45.95,55.42 43.82,55.42 43.59,55.65 42.14,55.65 v1(42.12,55.67)
1P35V_VID: length 4.6
  TOP w0.127: PR264.1 48.66,54.87 48.94,54.59 49.76,54.59 49.8,54.55 50.22,54.55 v1(50.27,54.5)
  TOP w0.203: PR265.1 47.67,55.34 47.4,55.34 46.98,55.76 PU21.11
  TOP w0.305: PR264.1 48.43,55.32 PR265.1
2ND_MBCLK: length 133
  TOP w0.127: v1(185.48,107.33) 185.25,107.56 184.2,107.56 183.74,107.11 176.99,107.11 174.02,104.13 163.77,104.13 159.94,107.97 v1(159.7,107.97)
  IN1 w0.089: v1(145.98,116.02) 146.18,116.22 147.15,116.22 147.81,116.87 148.62,116.87 150.02,118.27 151.94,118.27 154.62,115.59 154.62,114.45 155.76,113.3 155.76,111.49 159.03,108.22 159.44,108.22 v1(159.7,107.97) 159.86,108.13 160.4,108.13 163.9,104.63 163.9,91.94 163.51,91.55 163.51,84.96 162.77,84.22 162.77,78.18 165.27,75.67 165.27,74.18 167.96,71.48 167.96,68.33 172.42,63.87 173.03,63.87 173.37,63.53 173.37,62.8 173.81,62.36 173.81,61.2 174.26,60.74 174.54,60.74 v1(174.94,60.34)
  IN3 w0.114: v1(174.94,60.34) 175.06,60.47 175.32,60.47 175.37,60.42 175.37,56.1 177.36,54.11 180.16,54.11 181.1,53.17 181.1,51.39 181.78,50.7 181.78,46.87 181.27,46.35 181.27,45.03 v1(181.08,44.85)
  BOTTOM w0.127: 181.08,44.83 181.08,44.56 180.38,43.86 U45.115 ; 181.08,44.83 v1(181.08,44.85) ; 181.08,44.83 180.9,45 R733.1 ; v1(145.98,116.02) 145.28,116.02 R171.1 ; Q4302.3 185.33,109.51 185.48,109.37 v1(185.48,107.33)
2ND_MBDATA: length 136
  TOP w0.127: v1(186.11,107.33) 186.23,107.33 186.38,107.49 186.38,107.69 186.23,107.84 184.08,107.84 183.62,107.39 176.88,107.39 173.91,104.41 163.89,104.41 161.27,107.03 161.27,107.21 161.6,107.54 161.6,107.72 161.42,107.9 161.24,107.9 160.91,107.57 160.73,107.57 160.55,107.75 160.55,107.93 160.88,108.26 160.88,108.44 160.7,108.62 160.52,108.62 160.19,108.29 160.01,108.29 v1(159.7,108.6)
  IN1 w0.089: v1(174.94,60.98) 174.36,60.98 174.05,61.3 174.05,62.46 173.61,62.9 173.61,63.63 173.13,64.12 172.52,64.12 168.2,68.43 168.2,71.58 165.51,74.28 165.51,75.77 163.01,78.28 163.01,84.12 163.75,84.86 163.75,91.45 164.14,91.84 164.14,104.73 160.5,108.38 159.92,108.38 v1(159.7,108.6) 159.57,108.48 159.11,108.48 156,111.59 156,113.4 154.86,114.55 154.86,115.69 152.04,118.51 149.92,118.51 148.52,117.11 147.71,117.11 147.05,116.46 146.18,116.46 v1(145.98,116.66)
  IN3 w0.114: v1(181.72,44.85) 181.53,45.03 181.53,46.24 182.05,46.76 182.05,50.81 181.36,51.5 181.36,53.28 180.27,54.38 177.47,54.38 175.63,56.21 175.63,60.53 175.43,60.74 175.18,60.74 v1(174.94,60.98)
  BOTTOM w0.127: U45.116 180.78,43.86 181.72,44.8 181.72,44.83 ; R175.1 145.3,116.66 v1(145.98,116.66) ; v1(186.11,107.33) 185.76,107.69 185.76,108 185.97,108.21 Q4302.6 ; R734.1 181.92,45.03 181.72,44.83 ; 181.72,44.83 v1(181.72,44.85)
554EN_0.95V: length 3.3
  BOTTOM w0.127: v1(205.16,171.6) 205.02,171.74 PR321.1
  BOTTOM w0.305: PU18.5 205.07,173.45 PC300.2 205.04,172.89 205.02,172.87 PR321.1
554FB_0.95V: length 5.3
  BOTTOM w0.127: PR309.1 205.03,176.52 204.58,176.07 203.66,176.07 v1(203.43,175.84)
  BOTTOM w0.254: PR309.1 205.04,176.5 PR310.2 PC301.1
  BOTTOM w0.305: PR309.1 205.47,176.52 205.59,176.65 PU18.6
554FB_0.95V_S: length 3.2
  BOTTOM w0.127: PR311.1 202.91,174.58 202.39,174.06 v1(202.29,174.06)
  BOTTOM w0.254: PR310.1 PC301.2
  BOTTOM w0.381: PR311.1 204.2,174.58 PC301.2
554LX_0.95V:
  vias: v1(208.82,171.75)
554NC_0.95V: length 4.8
  BOTTOM w0.127: PC247.2 205.06,177.54 204.55,178.05 204.02,178.05 203.71,178.35 v1(203.13,178.35)
  BOTTOM w0.305: PC247.2 206.61,177.54 206.9,177.25 PU18.7
554PG_0.95V: length 3.5
  TOP w0.127: v1(205.24,171.62) 205.02,171.84 PR317.2
  TOP w0.508: PR317.2 206.19,172.41 v1(206.27,172.49)
  BOTTOM w0.305: PU18.4 206.9,172.87 206.51,172.49 v1(206.27,172.49)
554SVIN_0.95V:
  vias: v1(205.97,178.58)
681_AGND: length 69
  TOP w0.508: v1(75.88,108.1) 76.89,108.1 78.03,109.24 89.97,109.24 90.48,109.75 R636.1 R632.1 ; v1(56.47,82.72) 56.85,82.35 56.85,81.73 v1(56.49,81.37) 56.27,81.15 PR294.2
  IN2 w0.508: v1(56.47,82.72) 55.34,82.72 49.97,88.1 49.97,96.54 56.06,102.64 67.06,102.64 72.52,108.1 v1(75.88,108.1)
  BOTTOM w0.254: v1(56.47,82.72) 56.32,82.87 PU14.11
  BOTTOM w0.508: v1(56.47,82.72) 56.68,82.51 PC230.1
1658R-BOOT1:
  vias: v1(201.96,61.74)
1658R-BOOT2:
  vias: v1(197.72,61.84)
1658R-COMP: length 5.4
  BOTTOM w0.203: PU19.12 197.57,59.74 197.26,59.43 196.53,59.43 196.45,59.51 PC221.1
  BOTTOM w0.381: TP4362.1 196.01,58.64 195.62,59.03 PC221.1 PC199.1
1658R-EN: length 7.2
  BOTTOM w0.203: PR276.2 v1(205.19,61.53) 204.49,60.83 203.74,60.83 203.05,60.14 PU19.3
  BOTTOM w0.305: PR276.2 PR345.2 PR253.2
1658R-FB: length 7.1
  BOTTOM w0.203: PC110.1 195.14,56.43 195.89,56.43 198.25,58.8 PU19.11
  BOTTOM w0.305: PR277.2 194.88,57.65 TP4363.1
  BOTTOM w0.381: PR277.2 PC110.1
1658R-FBRTN: length 6.1
  BOTTOM w0.127: PR279.2 194.8,55.81 v1(194.8,55.11)
  BOTTOM w0.203: PU19.10 198.51,58.54 196.07,56.1 195.09,56.1 PR279.2
1658R-LGATE1: length 17.4
  IN3 w1.016: v2(197.24,79.14) v2(197.24,72.99) 197.24,69.15 200.59,65.81 v2(200.59,63.09)
  vias: v1(197.92,73.27)
1658R-LGATE2: length 16.6
  IN3 w1.016: v2(192.23,74.75) 191.57,74.09 v2(191.57,68.3) 193.3,66.57 195.87,66.57 199.19,63.24 v2(199.19,63.04)
  vias: v1(192.28,68.37)
1658R-OCS/CB: length 5
  BOTTOM w0.203: PR275.2 198.08,56.56 v1(198.6,57.08) 199.45,57.94 PU19.9
  BOTTOM w0.305: PR268.1 PR275.2
  BOTTOM w0.33: PR275.2 198.17,56.37 198.95,55.59 PR270.2
1658R-PG: length 9.6
  IN1 w0.305: v1(196.68,59.94) 193.53,59.94 v1(191.6,61.87)
  BOTTOM w0.203: v1(196.68,59.94) 197.16,59.94 197.36,60.14 PU19.13
  BOTTOM w0.305: PR259.1 192.14,60.7 192.11,60.73 PR252.1 192.11,61.58 191.83,61.87 v1(191.6,61.87)
1658R-PHASE1: length 15.1
  TOP w0.762: v2(199.42,79.8) 199.47,79.75 199.47,79.04 v1(198.66,78.23) 198.61,78.18 PR89.1
  IN3 w1.016: v2(201.61,62.43) 202.49,63.32 202.49,68.09 200.49,70.1 v2(200.49,73.3)
1658R-PHASE2: length 21.3
  TOP w0.762: v2(185.81,71.14) 186.26,71.6 v1(187.11,71.6) PR91.1
  IN3 w1.016: v2(198.05,62.53) 196.27,62.53 194.39,64.41 191.22,64.41 188.68,66.95 v2(188.68,74.42)
1658R-PSI: length 3.2
  BOTTOM w0.127: PR255.2 203.76,60.08 v1(203.97,60.29)
  BOTTOM w0.203: PR255.2 203.13,59.58 202.97,59.74 PU19.4
1658R-PVCC:
  vias: v1(201.3,64.49)
1658R-REFADJ: length 3.9
  BOTTOM w0.203: PU19.6 200.65,57.96 200.78,57.83 202.19,57.83 202.47,57.55 v1(203.06,57.55) PR106.1
1658R-REFIN: length 5.2
  BOTTOM w0.203: PR115.2 201.28,57.22 v1(201.12,57.22) 200.74,57.22 200.25,57.71 PU19.7
  BOTTOM w0.381: PR114.1 PC178.2 PR115.2
1658R-UGATE1: length 20.6
  IN3 w1.016: v2(205.85,80.06) 205.8,80 v2(205.8,73.35) 205.8,63.93 v2(202.67,60.8)
  vias: v1(203.18,61.34)
1658R-UGATE2: length 21.4
  IN3 w1.016: v2(197.06,60.78) 196.6,61.23 194.49,61.23 192.97,62.76 189.01,62.76 v2(184.49,67.28) 184.51,67.3 v2(184.51,73.4)
  vias: v1(196.47,61.23)
1658R-VID: length 2.6
  BOTTOM w0.203: PR256.2 202.72,58.67 v1(202.61,58.78) 202.05,59.34 PU19.5
1658R-VREF: length 4.2
  BOTTOM w0.203: PU19.8 v1(199.85,57.41) 199.85,56.52 PR113.1
  BOTTOM w0.305: PC206.2 PR113.1 PR270.1
24780_ACDET: length 4.1
  TOP w0.191: PU5.6 155.92,184.55
  TOP w0.203: 155.92,184.55 155.92,185.1 v1(155.45,185.57) 155.4,185.52 154.83,185.52 PR3.2
  TOP w0.381: PR3.2 154.72,185.86 PR168.2
24780_ACDRV: length 3.5
  TOP w0.191: PU5.4 156.72,184.5
  TOP w0.203: 156.72,184.5 157.84,185.62 v1(157.84,185.8) 157.33,186.3 PR165.2
24780_ACN: length 76
  TOP w0.191: PU5.1 157.92,184.15
  TOP w0.203: 157.92,184.15 159.21,185.44 159.21,185.9 159.42,186.1 159.83,186.1 PC5.2
  TOP w0.305: PC2.1 161.58,186.35 161.19,186.35 v1(161.02,186.18) 160.4,186.18 PC5.2
  IN3 w0.203: v1(206.86,184.32) 206.86,184.37 205.54,185.69 197.67,185.69 187.66,175.69 179.5,175.69 178.49,174.67 162.62,174.67 157.84,179.45 156.06,179.45 155.15,180.36 155.15,183.05 158.53,186.43 160.76,186.43 v1(161.02,186.18)
  BOTTOM w0.203: PR209.2 207.31,184.32 v1(206.86,184.32)
24780_ACP: length 78
  TOP w0.191: PU5.2 157.52,184.22
  TOP w0.203: 157.52,184.22 158.88,185.58 158.88,186.03 158.95,186.1 158.95,186.11 159.26,186.43 159.45,186.43 PC5.1
  TOP w0.305: PC5.1 160.24,186.89 v1(161.04,186.89) 161.33,186.89 PC115.2
  IN3 w0.203: v1(161.04,186.89) 160.91,186.76 158.38,186.76 154.82,183.2 154.82,180.23 155.94,179.12 157.69,179.12 162.52,174.29 178.56,174.29 179.58,175.31 187.74,175.31 197.8,185.36 205.16,185.36 v1(206.23,184.3)
  BOTTOM w0.203: v1(206.23,184.3) 206.23,184.43 206.73,184.93 207.27,184.93 PR210.2
24780_BATDRV: length 15.7
  TOP w0.191: PU5.18 156.72,178.66
  TOP w0.254: PR185.2 155.95,166.53 156.77,167.36 156.77,169.06 156.39,169.44 156.39,171.29 154.62,173.07 v1(154.62,173.88) 154.62,174.16 155.28,174.82 155.63,174.82 155.91,175.1 155.91,177.85 156.72,178.66
24780_BATSRC: length 3.4
  TOP w0.191: PU5.17 156.32,179.02
  TOP w0.203: 156.32,179.02 v1(155.23,177.92) PR186.2
24780_BM#: length 4.5
  TOP w0.191: PU5.16 155.92,179.18
  TOP w0.203: PR16.1 154.06,177.29 153.8,177.54 v1(153.8,177.75) 153.8,178.37 154.11,178.68 155.43,178.68 155.92,179.18
24780_BST:
  vias: v1(160.28,181.58)
24780_CMPIN: length 3.5
  TOP w0.191: PU5.13 154.2,180.91 v1(153.7,180.41)
  TOP w0.203: v1(153.7,180.41) 153.62,180.33 153.15,180.33 152.77,180.7 152.77,180.7 152.68,180.79 152.38,180.79 PR11.2
24780_CMPOUT: length 8.8
  TOP w0.191: PU5.14 154.28,180.51
  TOP w0.203: PQ40.2 150.53,176.78 v1(150.7,176.96) ; 154.28,180.51 154.21,180.44 154.21,180.08 153.93,179.8 152.99,179.8 v1(152.48,180.31) PR179.1
  IN2 w0.203: v1(150.7,176.96) 151.69,177.95 151.69,179.52 v1(152.48,180.31)
24780_CMSRC: length 4.3
  TOP w0.127: PR166.2 158.42,186.55 158.78,186.91 v1(159.16,186.91)
  TOP w0.191: PU5.3 157.12,184.37
  TOP w0.203: 157.12,184.37 158.32,185.57 PR166.2
24780_DH: length 9.4
  IN1 w0.889: v2(168.59,184.37) 166.5,184.37 164.37,182.24 v2(160.03,182.24)
  vias: v1(169.17,184.75)
24780_DL: length 11.3
  TOP w0.127: v2(169.35,178.33) 168.89,177.87 v1(168.89,177.77)
  IN1 w0.889: v2(169.35,178.33) 168.46,178.33 166.83,179.95 163.4,179.95 162.72,180.64 160.05,180.64 v2(159.87,180.46)
24780_ILIM: length 5.2
  TOP w0.191: PU5.21 157.92,179.27
  TOP w0.203: 157.92,179.27 157.92,179.2 PC123.2
  TOP w0.305: PR14.1 159.53,176.21 160.29,176.97 160.36,176.97
  TOP w0.381: PC123.2 159.25,178.22 v1(159.62,177.85) 160.38,177.08 PR15.2 160.36,176.97
24780_LX: length 14
  IN3 w0.889: v2(159.9,183.23) 168.51,183.23 170.26,181.48 v2(173.21,181.48)
  vias: v1(169.17,183.38) v2(170.26,183) v2(170.9,182.6) v2(173.97,180.46) v2(174.28,181.48) v2(175.01,180.44) v2(175.19,181.45)
24780_SRN: length 13.7
  TOP w0.203: PC132.2 155.9,174.3 156.14,174.06 PC131.1 157,174.25 157,174.64 v1(156.88,174.77) 157.05,174.95 157.05,175.34 PR184.1
  IN1 w0.203: v1(164.8,176.83) 164.7,176.93 163.25,176.93 160.56,174.24 157.41,174.24 v1(156.88,174.77)
  BOTTOM w0.203: PR175.1 165.33,176.98 165.03,176.98 164.85,176.8 164.83,176.8 v1(164.8,176.83)
24780_SRP: length 13.3
  TOP w0.203: PR183.1 157.41,175.21 157.41,174.9 v1(157.54,174.77) 157.41,174.64 157.41,174.25 PC131.2 158.35,174.06 158.57,174.28 PC130.2
  IN1 w0.203: v1(157.54,174.77) 157.77,174.54 160.33,174.54 163.1,177.31 164.62,177.31 v1(164.8,177.49)
  BOTTOM w0.203: PR176.1 165.33,177.39 164.85,177.39 164.8,177.44 v1(164.8,177.49)
24780_VCC: length 79.2
  TOP w0.191: PU5.28 159.02,182.91 159.19,183.08
  TOP w0.203: v1(159.06,183.92) 159.19,183.79 159.19,183.08
  TOP w0.305: v1(159.06,183.92) 159.75,184.6 v1(159.75,184.6) PC116.2
  TOP w0.508: v1(207.57,185.95) 203.13,185.95 202.24,185.06 200.97,185.06 198.56,182.65 198.56,180.61 v1(197.19,179.24)
  IN1 w0.508: v1(154.34,178.2) 154.34,183 155.25,183.92 v1(159.06,183.92)
  IN2 w0.508: v1(154.34,178.2) 155.12,177.41 155.12,175.03 157.37,172.78 165.62,172.78 166.38,173.55 180.57,173.55 182.17,175.15 183.95,175.15 186.82,178.02 191.9,178.02 192.44,178.56 195.76,178.56 196.45,179.24 v1(197.19,179.24)
  BOTTOM w0.508: v1(207.57,185.95) 208.01,185.95 208.59,186.53 PR5.1
25810_AUO#: length 2.6
  TOP w0.203: U28.17 31.31,106.28 31.03,106 30.75,106 v1(30.29,105.53) 30.29,105.06 R11197.2
25810_CC1: length 27.7
  TOP w0.203: v1(14.15,117.75) 14.36,117.54 U4513.5 15.3,117.54 15.55,117.8 v1(15.65,117.8) ; v1(29.9,110.26) 30.3,109.85 U28.11
  IN2 w0.203: v1(14.15,117.75) 13.49,118.41 10.93,118.41 10.17,119.17 9.28,119.17 9.07,118.96 8.55,118.96 v1(8.31,119.2)
  IN3 w0.203: v1(29.9,110.26) 25.71,114.45 23.22,114.45 19.87,117.8 v1(15.65,117.8)
  BOTTOM w0.203: CN2021.A5 8.26,119.15 v1(8.31,119.2)
25810_CC2: length 31.6
  TOP w0.203: v1(15.65,117.14) U4513.6 13.8,117.14 13.47,117.47 v1(13.47,117.75) ; U28.13 v1(29.9,108.85)
  IN2 w0.114: CN2021.B5 5.33,120.78 6.55,120.78 6.91,120.42
  IN2 w0.203: v1(13.47,117.75) 13.14,118.08 10.8,118.08 10.04,118.84 9.4,118.84 9.2,118.64 8.18,118.64 7.68,119.15 7.68,119.65 6.91,120.42
  IN3 w0.203: v1(15.65,117.14) 19.71,117.14 23.04,113.81 25.71,113.81 29.14,110.38 29.14,109.37 29.65,108.85 v1(29.9,108.85)
25810_DBG#: length 3.1
  TOP w0.203: R11194.2 29.65,105.58 29.86,105.79 v1(29.86,106.76) 30.46,107.35 U28.16
25810_FAULT#: length 5.1
  TOP w0.203: R11281.2 34.58,103.51 34.58,104.32 R11206.2 v1(34.09,106.09) 34.09,106.95 33.69,107.35 U28.1
25810_LD_DET#: length 2.1
  TOP w0.203: U28.20 v1(32.81,105.83) 32.81,105.7 33.2,105.3 R11208.2
25810_POL#: length 2.1
  TOP w0.203: U28.18 31.81,105.76 v1(31.56,105.51) 31.43,105.38 R11203.2
25810_REF: length 2
  TOP w0.127: v1(30.46,111.78) R11204.1
  TOP w0.203: U28.10 31.31,111.38 31.16,111.53 R11204.1
25810_REF_RTN: length 2.1
  TOP w0.127: v1(32.64,111.91) 32.52,111.78 R11204.2
  TOP w0.203: U28.9 31.81,111.39 31.94,111.53 R11204.2
25810_UFP#: length 11.6
  TOP w0.127: v1(26.09,103.91) Q15.2 27.23,103.17 27.61,102.8 R11280.2
  TOP w0.203: R11193.2 v1(32.31,105.43) 32.31,105.43 U28.19
  IN1 w0.089: v1(26.09,103.91) 27.62,105.43 v1(32.31,105.43)
25810_UFP#_G1: length 6.1
  TOP w0.127: Q17.2 24.96,106.45 25.2,106.2 Q15.3 v1(27.63,104.92) 28.17,104.92 28.29,104.8 R11201.1
25810_UFP#_G2: length 5.7
  TOP w0.127: Q6062.4 20.17,110.3 20,110.12 R11195.1 v1(19.49,109.27) 19.49,108.99 21.01,107.46 Q17.3
51225_CS1: length 3.4
  TOP w0.127: v1(55.53,35.5) 55.53,36.34 PR6124.1
  TOP w0.203: PR6124.1 55.55,36.48 54.95,37.08 54.95,37.33 54.35,37.93 PU6010.1
51225_CS2: length 2.4
  TOP w0.127: PR6122.2 53.9,40.96 v1(53.88,40.94)
  TOP w0.203: PR6122.2 54.58,40.6 53.91,39.92 PU6010.5
51225_DH1: length 8.1
  IN1 w1.016: v2(51.11,36.44) 52.46,36.44 54.01,34.89 56.6,34.89 57.36,34.13 v2(57.36,34.18)
  BOTTOM w0.127: v2(51.11,36.44) 51.06,36.39 v1(51.06,35.66)
51225_DH2: length 12.9
  TOP w0.203: v2(51.11,41.14) 51.19,41.07 51.24,41.07 51.61,40.7 PU6010.10
  IN1 w1.016: v2(62.58,41.69) 61.98,41.09 51.16,41.09 v2(51.11,41.14)
  vias: v1(62.29,40.99)
51225_DL1: length 16.2
  IN1 w1.016: v2(50.17,37.15) 49.84,36.82 49.84,30.3 53.09,27.05 57.61,27.05 v2(57.66,27.1)
  vias: v1(49.61,36.65)
51225_DL2: length 19.3
  TOP w0.203: PU6010.11 50.44,39.53 50.24,39.73 50.24,40.32 v2(50.25,40.33)
  IN1 w1.016: v2(58.76,49.83) 58.48,50.11 53.45,50.11 49.56,46.22 49.56,41.02 v2(50.25,40.33)
  BOTTOM w0.127: v2(50.25,40.33) 50.09,40.48 v1(50.09,41.09)
51225_EN1: length 1.7
  TOP w0.203: PU6010.20 v1(53.21,36.27) 53.21,35.55 PR6278.1
51225_FB1: length 3
  TOP w0.203: PR6281.1 55.71,37.42 55.71,38.34 PR6120.1 55.23,38.4 v1(54.92,38.09) 54.69,38.09 54.46,38.33 PU6010.2
51225_FB2: length 4.2
  TOP w0.203: PU6010.4 54.41,39.13 54.77,39.49 v1(54.77,39.92)
  TOP w0.381: v1(54.77,39.92) 55.15,39.92 55.52,39.55 PR6121.1
  BOTTOM w0.381: PR6279.2 54.87,40.81 v1(54.67,40.61) 54.67,40.02 v1(54.77,39.92)
51225_SW1: length 14.1
  IN1 w1.016: v2(63.48,29.59) 62.77,30.3 55.71,30.3 52.28,33.73 52.28,34.84 v2(52.3,34.87)
  vias: v1(65.79,27.6)
51225_SW2: length 14.4
  TOP w0.762: PR6289.1 65.13,49.07 v2(65.82,49.75)
  IN1 w1.016: v2(62.46,46.04) 54.51,46.04 52.51,44.04 52.51,42.51 52.53,42.49 v2(52.53,42.41)
  vias: v1(63.99,42.39)
51225_VBST1:
  vias: v1(51.87,36.06)
51225_VBST2:
  vias: v1(51.85,41.24)
51225_VIN: length 4.4
  TOP w0.127: v1(49.76,40.94) 49.52,40.69 PR6130.2
  TOP w0.203: PU6010.12 50.2,39.13 50.01,39.33 PC6100.2
  TOP w0.508: PC6100.2 49.19,39.78 48.82,40.15 PR6130.2
+AZA_VDD: length 25.7
  TOP w0.508: v1(201.2,48.64) 200.67,48.64 199.42,47.39 198.18,47.39 v1(197.92,47.14) 196.5,45.71 v1(196.5,45.24)
  IN1 w0.508: v1(201.21,36.99) 201.46,36.99 201.99,37.51 201.99,38.63 203.64,40.28 203.64,45.1 201.2,47.54 v1(201.2,48.64)
  BOTTOM w0.203: 201.61,45.99 202.37,45.99 202.58,45.78 U23.1 ; U23.36 202.58,38.71 202.11,38.25
  BOTTOM w0.508: v1(201.21,36.99) C527.1 201.86,37.99 202.11,38.25 ; R372.1 v1(196.5,45.24)
+G_SEN_PW: length 48.5
  IN3 w0.508: v1(225.99,58.95) 224.85,57.8 v1(224.85,55.38) 224.85,52.85 223.88,51.89 216.54,51.89 214.81,53.61 214.81,54.16 215.45,54.8 v1(215.45,56.28) 214.94,56.28 214.56,56.66 214.56,61.61 217.06,64.12 v1(217.9,64.12) 218.56,63.46 v1(220.6,63.46)
  BOTTOM w0.305: U19.14 215.71,56.54 v1(215.45,56.28) ; C428.1 v1(222.84,56.03) 222.32,56.54 U19.8 ; U19.1 219.02,59.71
  BOTTOM w0.508: R333.2 v1(220.6,63.46) ; v1(224.85,55.38) 224.53,55.69 C428.1 ; v1(217.9,64.12) R318.2 C412.1 217.9,60.94 v1(218.13,60.71) 219.02,59.82 219.02,59.71 ; R334.2 v1(225.99,58.95)
+TPVDD:
  vias: v1(117.7,16.78) v1(117.7,16.15) v1(118.14,18.97) v1(118.34,16.15) v1(131.37,16.94) v1(131.37,16.3) v1(131.37,15.67) v1(132.52,13) v1(136.45,17.42) v1(139.76,13.35)
+TYPEC_VBUS: length 3.8
  BOTTOM w0.305: CN2021.A4 6.15,118.65 CN2021.B9 ; CN2021.B4 6.15,121.15 CN2021.A9 8.54,121.15 8.54,121.15
  vias: v1(9.15,121) v1(9.51,119.04) v1(9.45,116.1) v1(9.45,115.46) v1(9.84,118.36) v1(10.09,116.1) v1(10.09,115.46) v1(10.29,119.63) v1(10.8,119.25) v1(10.75,115.64) v1(16.95,111.17) v1(17.51,111.53) v1(17.51,110.87) v1(18.14,111.53) v1(18.14,110.89) v1(18.78,111.53) v1(18.78,110.89)
+TYPEC_VBUS_C:
  vias: v1(27.87,107.06)
+VGPU_CORE: length 28.2
  TOP w0.305: v2(185.1,94.51) 184.46,93.87 184.46,92.98 184.08,92.6 181.41,92.6 180.65,91.84 180.65,88.41 v1(179.38,87.14)
  TOP w0.381: v1(182.24,129.54) 182.05,129.73 C4409.1
  TOP w0.508: C4404.1 184.21,134.44 v1(184.22,134.45) ; C4411.1 181.41,135.41 v1(181.32,135.5) ; C4405.1 178.15,129.91 v1(178.15,129.49) ; v1(187.24,136.39) 186.82,135.97 C4418.1 ; C4416.1 187.29,134.35 v1(187.37,134.43) ; v1(185.21,136.39) 184.85,136.03 C4419.1 ; v1(178.23,132.63) 177.86,132.26 C4407.1 ; v1(181.15,130.49) 180.55,129.89 C4406.1 ; v1(185.3,128.38) 184.83,127.91 C4400.2 ; v1(186.23,130.47) 186.64,130.06 C4403.2 ; v1(187.24,135.48) 187.74,135.97 C4415.1 ; v1(180.26,134.36) 179.98,134.64 C4421.1 ; v1(180.13,136.49) 180.04,136.49 179.22,137.31 C4413.1
  BOTTOM w0.305: v1(179.38,87.14) 178.99,87.53 PR84.1
  vias: v1(175.64,128.52) v1(176.41,119.14) v1(176.41,118.34) v1(177.09,116.86) v1(177.09,116.22) v1(177.09,115.34) v1(177.09,114.7) v1(177.09,113.81) v1(177.09,113.18) v1(177.09,112.29) v1(177.09,111.65) v1(177.09,110.76) v1(177.09,110.13) v1(177.22,137.6) v1(177.25,126.58) v1(177.23,120.74) v1(177.23,119.94) v1(177.23,119.14) v1(177.23,118.34) v1(177.58,122.19) v1(177.73,117.6) v1(178.08,121.54) v1(178.08,120.74) v1(178.08,119.94) v1(178.08,119.14) v1(178.1,118.34) v1(178.2,136.37) v1(178.25,133.59) v1(178.92,124.04) v1(178.92,121.54) v1(178.92,120.74) v1(178.92,119.14) v1(178.92,118.34) v1(179.73,124.04) v1(179.73,123.21) v1(179.73,122.36) v1(179.73,121.54) v1(179.73,120.74) v1(179.73,119.94) v1(179.73,119.14) v1(179.73,118.34) v1(180.14,132.48) v1(180.55,124.04) v1(180.55,122.39) v1(180.55,121.53) v1(180.55,120.74) v1(180.55,119.94) v1(180.55,119.14) v1(180.55,118.34) v1(180.57,123.23) v1(180.73,124.97) v1(180.8,126.33) v1(180.8,125.62) v1(181.15,132.42) v1(181.15,128.43) v1(181.22,133.26) v1(181.39,124.95) v1(181.41,124.04) v1(181.4,123.24) v1(181.43,122.36) v1(181.4,121.54) v1(181.4,120.74) v1(181.4,119.94) v1(181.4,119.14) v1(181.4,118.34) v1(181.47,126.34) v1(181.49,125.68) v1(182.07,124.96) v1(182.18,126.34) v1(182.2,125.69) v1(182.23,124.04) v1(182.23,123.21) v1(182.23,122.36) v1(182.23,121.54) v1(182.23,120.74) v1(182.23,119.94) v1(182.23,119.14) v1(182.23,118.31) v1(183.06,124.04) v1(183.18,134.51) v1(183.19,131.46) v1(183.19,130.45) v1(183.31,129.41) v1(184.3,132.35) v1(185.21,137.41) v1(185.21,134.49) v1(185.21,130.3) v1(186.21,132.58) v1(186.15,126.51) v1(186.16,96.57) v1(187.25,132.35) v1(207.68,93.24) v2(186.19,95.88) v2(186.72,98.98) v2(188.09,98.93) v2(189.39,92.96) v2(189.41,91.46) v2(189.41,90.06) v2(189.79,100.22) v2(189.79,98.9) v2(190.94,92.81) v2(190.91,91.49) v2(190.86,90.01) v2(190.99,99.74) v2(190.99,98.52) v2(190.99,97.07) v2(190.99,95.7) v2(190.96,94.18) v2(192.46,89.81) v2(192.64,99.16) v2(192.64,96.49) v2(192.64,95.12) v2(192.61,93.59) v2(192.59,92.22) v2(192.59,90.82) v2(192.66,100.45) v2(192.66,97.86) v2(194.24,98.11) v2(194.24,95.45) v2(194.24,94.08) v2(194.21,92.55) v2(194.19,91.18) v2(194.16,89.86) v2(194.27,96.82) v2(195.38,93.11) v2(195.38,91.97) v2(195.51,90.95) v2(195.84,94.25) v2(195.87,97.15) v2(195.87,95.78) v2(197.16,96.92) v2(197.16,96.03) v2(197.16,95.02) v2(197.16,93.75) v2(200.34,90.09) v2(200.44,95.6) v2(200.41,94.08) v2(200.39,92.7) v2(200.36,91.38) v2(202.04,93.03) v2(202.01,91.66) v2(201.99,90.06) v2(202.06,95.93) v2(202.06,94.56) v2(203.26,90.06) v2(203.74,92.45) v2(203.71,91.13) v2(203.79,99.38) v2(203.82,98.09) v2(203.79,96.72) v2(203.79,95.35) v2(203.76,93.82) v2(204.91,98.06) v2(204.91,96.11) v2(204.93,94.33) v2(204.93,92.96) v2(205.03,91.33) v2(205.92,102.76) v2(206.2,96.13) v2(206.51,91.56) v2(207.35,95.96)
+VREF_CA_CPU: length 134.1
  TOP w0.508: R10878.1 129.09,39.29 128.57,38.77 C1252.1 128.57,37.35 127.82,36.6 119.16,36.6 117.29,38.46 95.54,38.46 94.86,39.14 v1(92,39.14)
  IN1 w0.508: v3(102.93,103.26) 102.95,103.26 102.57,102.88 99.78,102.88 98.27,101.37 96.81,101.37 v1(95.69,100.25)
  BOTTOM w0.254: v3(102.93,103.26) 102.95,103.26 102.95,102.93 102.6,102.58 U35.AY67
  BOTTOM w0.508: v1(95.69,100.25) 95.69,99.87 95.33,99.51 91.67,99.51 89.31,97.15 89.31,80.39 v1(87.94,79.01) 85.02,76.09 81.21,76.09 79.69,74.57 79.69,71.52 79.13,70.96 79.13,67.01 80.7,65.43 80.7,60.66 80,59.96 80,41.13 81.11,40.02 91.24,40.02 92,39.26 v1(92,39.14)
+VREFDQ_SA_M3: length 7.3
  IN1 w0.381: v3(101.3,102.19) 99.86,102.19 98.37,100.71 97.01,100.71 96.54,100.23 v1(96.54,100.11)
  BOTTOM w0.254: U35.AY68 101.41,102.13 101.33,102.22 v3(101.3,102.19)
  BOTTOM w0.508: v1(96.54,100.11) 96.54,99.53 TP4344.1
+VREFDQ_SB_M3: length 75.5
  TOP w0.508: R10932.1 116.13,57.46 115.92,57.68 115.07,57.68 114.74,58.01 114.74,58.24 114.15,58.82 v1(113.31,58.82) 113.34,58.85 C1329.1
  IN1 w0.381: v1(97.28,100.11) 98.64,100.11 99.2,100.67 99.92,100.67 100.87,101.62 v3(102,101.62)
  IN2 w0.508: v1(113.31,58.82) 113.21,58.82 112.07,59.96 112.07,62 110.55,63.52 97.08,63.52 94.05,66.56 v1(94.05,67.39)
  BOTTOM w0.305: v3(102,101.62) 102.12,101.74 U35.BA67
  BOTTOM w0.508: v1(94.05,67.39) 94.05,71.64 90.15,75.53 v1(90.15,77.52) 90.15,96.72 92.03,98.6 96.73,98.6 97.26,99.13 97.26,100.11 v1(97.28,100.11)
+WL_VDD: length 28.7
  TOP w0.508: 180.66,176.81 R242.2 ; 180.66,176.81 181.43,176.04 v1(184.71,176.04) 186.37,176.04 188.02,177.69 190.3,177.69 191.06,178.45 198.56,178.45 200.21,176.8 v1(200.97,176.8) ; 180.66,176.81 180.35,176.5 179.13,176.5 178.87,176.75 v1(178.87,177.16) 178.88,177.17 R241.2
  BOTTOM w0.279: Q23.2 v1(178.87,177.16)
  BOTTOM w0.508: v1(202.09,181.83) 201.79,182.14 R714.2
  vias: v1(200.08,191.15) v1(200.08,190.39) v1(200.08,189.76) v1(200.08,189.12) v1(200.08,188.49) v1(201.61,176.8) v1(201.81,178.53) v1(201.81,177.9)
A_DE0: length 2
  TOP w0.127: U9.29 31.28,115.6 30.79,115.11 R11213.2
A_DE1: length 3
  TOP w0.127: U9.28 30.88,115.91 29.9,114.93 R254.2 29.79,114.47 v1(29.19,114.47)
A_EQ0: length 3.6
  TOP w0.127: v1(34.32,114.83) 34.12,114.63 34.03,114.63 33.98,114.58 R258.2 33.46,115.64 33.25,115.84 32.61,115.84 32.48,115.97 U9.32
A_EQ1: length 3
  TOP w0.127: U9.31 32.08,115.57 32.21,115.44 32.21,114.93 32.57,114.57 R11211.2 33,115.01 v1(33,115.36)
ACCEL_INT2: length 3.2
  BOTTOM w0.127: D35.1 223.62,52.05 223.45,52.22 223.45,53.18 v1(223.63,53.36) 223.75,53.48 R326.1
ACCEL_INT2_R: length 3.8
  BOTTOM w0.127: D35.2 v1(221.7,53.71) 221.7,53.72 221.02,54.39 U19.9
ACCEL_INTA: length 135.4
  TOP w0.127: v1(162.54,67.89) 162.67,68.03 164.49,68.03 165.25,67.27 172.64,67.27 175.1,64.8 181.56,64.8 186.87,59.49 v1(186.87,57.8) v1(186.87,57.07)
  IN1 w0.089: v1(186.87,57.07) 192.06,57.07 192.58,56.55 210.77,56.55 214.8,52.52 v1(214.8,52.35)
  IN2 w0.114: v1(162.54,67.89) 162.54,68.8 158.81,72.54 158.81,79.14 158.05,79.9 158.05,86.95 158.95,87.85 158.95,92.24 159.6,92.89 159.6,101.2 159.17,101.63 159.17,108.9 159.63,109.35 159.63,110.1 158.17,111.55 158.17,112.41 v1(158.68,112.92)
  BOTTOM w0.127: v1(214.8,52.35) 214.92,52.47 C425.2 215.98,52.47 216.45,52.01 D8.1 ; v1(158.68,112.92) 157.7,113.9 157.7,116.49 156.83,117.37 154.11,117.37 152.77,116.03 152.77,115.53 152.24,114.99 149.96,114.99 148.85,113.88 146.05,113.88 145.4,113.23 142.48,113.23 141.49,112.25 U35.AB1
ACCEL_INTA_R: length 3.6
  BOTTOM w0.127: U19.11 220.02,53.46 v1(219.89,53.33) D8.2
ACIN: length 189.3
  TOP w0.127: PR167.1 156.39,187.7 156.65,187.95 v1(156.65,187.98)
  TOP w0.305: v1(161.6,179.78) 161.94,180.11 PR1.2
  IN1 w0.089: v1(161.6,179.78) 159.87,179.78 158.55,178.45 158.3,178.45 155.38,175.53 155.38,168.47 v1(156.24,167.61)
  IN2 w0.114: v1(164.45,78.58) 164.45,81.15 165.84,82.55 165.84,93.06 164.39,94.51 164.39,100.76 164.17,100.98 164.17,103.12 162.62,104.67 162.62,119.78 163.1,120.26 163.1,132.07 163.76,132.73 166.43,132.73 167.19,133.5 167.19,137.84 165.28,139.75 165.28,144.72 164.53,145.47 161.65,148.36 159.89,148.36 158.04,150.2 158.04,165.11 156.24,166.91 v1(156.24,167.61)
  IN3 w0.114: v1(164.45,78.58) 165.33,77.69 165.33,75.13 164.9,74.7 164.9,66.31 166.17,65.04 167.19,65.04 167.57,64.66 167.57,62.37 170.05,59.89 170.05,52.65 170.62,52.09 170.62,50.57 170.11,50.06 170.11,48.53 171,47.64 171,46.5 172.01,45.49 172.01,43.59 173.39,42.21 173.39,39.68 172.72,39.01 172.14,39.01 171.51,38.37 171.51,33.14 v1(172.81,31.85)
  BOTTOM w0.127: U45.72 172.76,31.8 v1(172.81,31.85) ; v1(156.65,187.98) 157.16,187.47 158.3,187.47 158.86,188.03 160.91,188.03 164.84,184.1 PR4.1
  BOTTOM w0.305: v1(161.6,179.78) 163.76,181.93 PR4.1
ACZ_SDIN: length 1.8
  BOTTOM w0.127: U23.8 205.38,46.46 R359.1
ADOGND: length 28.1
  TOP w0.381: v1(211.89,41.93) 212.01,42.05 R400.1
  TOP w0.508: v1(207.88,38.7) v1(207.09,39.49) 207.08,39.51 C537.1 ; R401.2 209.72,34.58 v1(209.51,34.36)
  BOTTOM w0.203: v1(199.95,39.62) 200.36,39.62 201.13,40.38 U23.38 ; v1(207.88,38.7) 207.8,38.63 207.11,38.63 206.98,38.75 U23.25
  BOTTOM w0.305: CN2020.24 v1(212.12,11.15) ; CN2020.15 v1(212.14,15.65) ; CN2020.22 v1(212.15,12.15) ; CN2020.26 211.99,10.15 v1(212.15,10.31)
  BOTTOM w0.381: C553.2 v1(202.88,21.36) ; R393.1 209.49,44.97 v1(209.73,44.72) ; C534.2 207.7,36.09 v1(207.83,35.96) ; C547.2 205.29,21.6 v1(205.29,21.36) ; C519.2 v1(211.27,41.43) ; R417.2 v1(201.48,27.2) ; C532.2 v1(210.29,37.99) ; C526.2 v1(206.3,34.44) ; v1(201.22,32.79) 201.11,32.67 R399.1 ; C550.2 v1(201.48,21.36) ; v1(203.51,21.36) 204.14,21.98 C554.2 ; C535.1 v1(206.69,35.96) ; C536.2 209.87,37.23 v1(210.29,37.23) ; v1(205.54,30.68) 205.94,30.28 C523.1 ; R423.2 v1(202.88,27.2) ; R390.1 v1(205.67,33.55) ; R750.1 v1(210.62,38.75) ; R397.1 v1(206.3,35.33)
  BOTTOM w0.508: R375.1 v1(199.07,36.72) ; v1(206.81,11.58) 206.42,11.58 C538.1 ; C524.2 v1(197.41,37.74) ; C529.1 v1(199.32,38.5) ; C520.2 v1(198.43,37.74) ; R394.1 v1(197.8,36.85)
AMP_MUTE#: length 24.6
  IN1 w0.089: v1(179.29,38.56) 179.29,39.64 179.51,39.86 179.51,40.38 179.06,40.82 178.17,40.82 v1(177.32,41.68)
  IN3 w0.114: v1(179.29,38.56) 179.29,39.11 180.68,40.5 180.68,42.34 183.57,45.23 184.87,45.23 188.93,49.3 v1(190.05,49.3)
  BOTTOM w0.127: U45.108 177.58,41.93 v1(177.32,41.68) ; v1(190.05,49.3) 190.09,49.25 v1(190.09,48.59) D16.1
APS1: length 3.7
  TOP w0.305: R289.2 v1(164.43,99.11) 165.1,98.44 CN2.1
APS3: length 1.6
  TOP w0.305: CN2.3 166.1,97.86 166.55,98.32
  vias: v1(166.2,99.31)
APS7: length 5
  TOP w0.127: v1(171.07,98.67) 170.76,98.99 R271.1
  TOP w0.305: CN2.7 168.1,97.79 168.05,97.84 168.05,98.29 168.42,98.66 R272.1
  TOP w0.508: R272.1 169.19,98.95 169.22,98.99 R271.1
AUX_CH_N: length 2.9
  TOP w0.127: U13.3 26.29,67.75 27.03,67 27.03,66.44 27.19,66.29 27.42,66.29 27.61,66.48 C343.2
AUX_CH_P: length 2.9
  TOP w0.127: U13.2 26.33,67.35 26.78,66.9 26.78,66.34 27.08,66.03 27.38,66.03 27.61,65.81 C341.2
B_DE0: length 3.1
  TOP w0.127: U9.15 31.28,123.36 31.17,123.46 R11214.2 30.93,124.22 30.79,124.07 30.79,123.69 v1(30.51,123.41)
B_DE1: length 3.4
  TOP w0.127: v1(29.42,124.23) 30.27,124.23 R203.2 30.28,123.87 30.03,123.62 30.03,123.13 30.23,122.93 30.73,122.93 30.88,122.78 U9.16
B_EQ0: length 2.2
  TOP w0.127: R206.2 32.95,123.82 32.08,122.95 U9.13
  vias: v1(33.69,124.2)
B_EQ1: length 2
  TOP w0.127: U9.14 31.68,123.24 v1(31.84,123.39) 32.06,123.62 R11212.2
BAT-V: length 7.1
  TOP w0.381: PC125.2 160.48,174.49 159.64,173.65
  TOP w0.762: v2(159.64,173.68) 159.64,173.65 159.31,173.32 158.64,173.32 PC126.1
  BOTTOM w0.178: 168.15,175.08 168.38,175.31 168.38,176.85 168.15,177.08 166.77,177.08 PR175.2
  vias: v1(161.75,173.2)
BATLED0#: length 143.1
  TOP w0.127: v1(62.67,10.41) 62.67,12.59 v1(61.13,14.13) 60.64,14.62 60.64,17.93 61.02,18.31 R428.1 R430.1
  IN2 w0.114: v1(185.6,30.12) 185.6,29.61 184.34,28.35 179.31,28.35 177.78,26.82 170.62,26.82 168.59,24.78 113.1,24.78 112.27,23.95 80.39,23.95 77.67,21.23 74.73,21.23 65.71,12.21 64.47,12.21 v1(62.67,10.41)
  BOTTOM w0.127: v1(185.6,30.12) 185.68,30.2 U45.29
BATLED1#: length 149.9
  TOP w0.127: R431.1 R429.1 64.32,18.31 64.06,18.05 v1(64.06,14.59) v1(64.06,10.31)
  IN1 w0.089: v1(64.06,10.31) 64.57,10.81 68.96,10.81 70.37,12.21 72.7,12.21 73.08,11.83 75.37,11.83 77.27,13.74 77.27,18.03 83.14,23.9 102.59,23.9 103.29,23.19 107.42,23.19 108.64,21.97 112.67,21.97 113.56,21.08 118.23,21.08 121.09,18.22 126.65,18.22 129.91,21.48 159.19,21.48 163.87,26.16 169.95,26.16 171.9,28.11 174.01,28.11 178.35,32.45 183.4,32.45 184.49,31.36 v1(185.6,31.36)
  BOTTOM w0.127: U45.25 186.04,31.8 v1(185.6,31.36)
BEEP_1: length 3.6
  BOTTOM w0.127: C476.2 C477.1 R354.2 R352.1 v1(211.77,48.51)
BI: length 161.6
  TOP w0.381: v1(156.93,171.6) 156.93,171.54 157.1,171.37 PR10.2
  IN2 w0.114: v1(156.93,171.6) 156.93,171.88 157.41,172.36 165.79,172.36 166.55,173.12 181.03,173.12 181.29,173.37 184.59,173.37 184.97,173.76 191.5,173.76 193.79,171.46 198.94,171.46 200.08,170.33 202.46,170.33 203.21,169.58 203.21,156.15 205.54,153.82 212.78,153.82 213.09,153.51 222.48,153.51 225.23,150.77 225.23,135.08 224.69,134.54 224.69,115 220.04,110.35 219.48,110.35 214.4,105.27 214.4,88.96 v1(214.1,88.67)
  BOTTOM w0.127: v1(214.1,88.67) 213.92,88.85 R11282.1 213.92,89.97 213.85,90.03 213.85,90.12 213.85,90.12 SW4.3 SW4.4
  BOTTOM w0.381: v1(156.93,171.6) 156.55,171.97 PJ1.6
BI_GATE: length 70.2
  TOP w0.127: v1(218.12,69.59) 218.6,69.11 R719.2 C765.1
  IN1 w0.089: v1(218.12,69.59) 218.12,72.66 217.23,73.55 217.23,82.19 217.51,82.47 217.51,95.06 221.21,98.77 221.21,102.18 222.43,103.4 228.02,103.4 229.44,104.82 229.44,112.77 229.08,113.13 229.08,117.3 v1(229.15,117.37)
  BOTTOM w0.127: v1(229.15,117.37) SW1.3 SW1.4 ; Q56.5 218.75,69.87 218.47,69.59 v1(218.12,69.59) 218.12,68.96 218.47,68.6 Q40.2
BL#: length 4.6
  BOTTOM w0.127: Q3.3 107.36,150.01 R52.1 ; R52.1 108.01,150.4 Q3.2 ; R52.1 107.46,149.85 v1(106.71,149.85)
BL_ON: length 28.8
  IN1 w0.089: v1(109.86,157.12) 110.51,157.77 110.51,158.27 111.11,158.86 111.11,162.09 111.78,162.76 111.78,163.13 115.22,166.57 115.22,169.08 v1(114.74,169.56)
  BOTTOM w0.127: Q3.6 108.66,153.14 108.91,152.89 D1.2 110.11,153.73 110.03,153.82 R58.1 110.03,155.18 110.19,155.34 Q4.3 110.19,156.79 v1(109.86,157.12) ; v1(114.74,169.56) 115.63,169.56 117.53,171.47 120.54,171.47 CN5.26
BOARD_ID0: length 8.4
  BOTTOM w0.076: 143.69,107.67 142.52,106.49 140.74,106.49 140.65,106.52 140.59,106.55 140.39,106.55 140.3,106.51 140.03,106.51 139.95,106.55 139.73,106.55 139.6,106.49 139.4,106.28 U35.AN3
  BOTTOM w0.127: 143.69,107.67 144.19,108.16 R595.2 144.64,107.78 145.92,107.78 146.22,108.09 R600.1
BOARD_ID1: length 13
  BOTTOM w0.076: 143.69,107.28 142.7,106.29 140.5,106.29 U35.AN1
  BOTTOM w0.127: v1(152.28,107.56) 150.93,107.56 150.45,107.08 R598.2 150.16,107.33 149.29,107.33 R599.1 148.43,107.69 146.19,107.69 146.02,107.53 143.93,107.53 143.69,107.28
BOARD_ID2: length 7.4
  BOTTOM w0.076: U35.AN2 140.07,106.05 140.3,106.05 140.38,106.01 140.6,106.01 140.72,106.07 143.19,106.07 143.69,106.58
  BOTTOM w0.127: 143.69,106.58 R605.2 144.64,106.64 145.92,106.64 146.22,106.94 R608.1
BOARD_ID3: length 12.8
  BOTTOM w0.076: U35.AM4 139.18,106.62 139.51,106.62 139.69,106.71 139.98,106.71 140.06,106.68 140.27,106.68 140.36,106.71 140.62,106.71 140.71,106.68 140.77,106.65 141.06,106.65 141.15,106.74 142.34,106.74 143.69,108.1
  BOTTOM w0.127: 143.69,108.1 143.74,108.15 143.74,108.53 143.83,108.62 143.83,108.62 143.86,108.65 145.73,108.65 145.75,108.67 148.59,108.67 R590.1 R592.2
BOARD_ID4: length 126.2
  TOP w0.127: v1(156.57,106.95) 156.57,107.36 156.5,107.44 v1(156.5,113.65) 156.5,118.92 154.23,121.18 154.23,126.68 158.81,131.25 158.81,134.64 160.48,136.32 160.48,146.39 162.7,148.61 163.17,148.61 165.72,151.15 165.72,154.93 163.38,157.27 163.38,160.75 v1(161.96,162.17)
  IN2 w0.114: v1(134.59,179.71) 134.17,179.29 134.17,178.13 134.77,177.53 134.77,176.3 135.44,175.62 135.44,174.54 137.12,172.87 145.55,172.87 145.8,173.12 150.04,173.12 150.37,172.79 152.67,172.79 154.94,170.52 157.68,170.52 158.39,171.24 160.11,171.24 161.47,169.88 161.47,162.66 v1(161.96,162.17)
  BOTTOM w0.076: U35.AM1 142.21,106.94 143.54,108.27 143.54,108.65 143.69,108.8
  BOTTOM w0.127: v1(156.57,106.95) 156.06,107.46 153.35,107.46 151.95,108.86 150.81,108.86 150.3,109.37 R593.1 150.29,109.23 149.98,108.92 145.6,108.92 145.55,108.88 143.77,108.88 143.69,108.8 ; v1(134.59,179.71) 134.07,179.19 133.63,179.19 C803.2 R441.1
BOARD_ID4_TOUCH_S: length 2.1
  BOTTOM w0.127: CN5.2 v1(130.27,178.71) R441.2
BOARD_ID5: length 9.8
  BOTTOM w0.076: 143.69,109.1 143.38,108.78 143.38,108.39 142.2,107.21 140.71,107.21 140.63,107.17 140.39,107.17 U35.AM2
  BOTTOM w0.127: 143.69,109.1 143.7,109.1 145.35,109.1 145.62,109.37 R606.2 146.69,109.84 147.92,109.84 148.26,109.5 R607.1
BOARD_ID6: length 14.9
  TOP w0.127: R764.2 149.04,109.68 149.36,110 v1(149.79,110) 149.91,110 R765.1 150.42,110.95 v1(150.04,111.32)
  BOTTOM w0.076: 143.69,109.33 143.63,109.33 143.21,108.91 143.21,108.47 142.15,107.4 140.72,107.4 140.6,107.34 140.18,107.34 140.05,107.21 139.78,107.21 U35.AM3
  BOTTOM w0.127: 143.69,109.33 145.26,109.33 146.03,110.1 149.69,110.1 v1(149.79,110)
BOARD_ID7: length 12.4
  BOTTOM w0.076: 143.69,106.14 143.38,105.83 141.16,105.83 141.1,105.89 140.71,105.89 140.63,105.85 140.35,105.85 140.26,105.88 140.06,105.88 140.01,105.86 139.95,105.83 139.73,105.83 139.62,105.88 139.13,105.88 U35.AP4
  BOTTOM w0.127: 143.69,106.14 143.93,106.38 148.59,106.38 R767.1 149.29,105.68 150.16,105.68 R766.2
BT_EN: length 217.2
  TOP w0.127: v1(166.68,75.97) v1(167.18,76.46) 167.37,76.65 170.59,76.65 172.7,78.76 174.09,78.76 v1(174.17,78.67)
  IN1 w0.089: v1(174.17,78.67) 174.8,79.3 174.8,85.68 176.29,87.18 176.29,94.14 178.09,95.94 178.09,100.27 180.21,102.39 186.32,102.39 186.83,102.9 194.09,102.9 195.01,103.81 212.99,103.81 216.52,107.33 219.61,107.33 227.17,114.89 227.17,120.81 226.42,121.56 226.42,123.16 226.54,123.29 226.54,150.64 219.55,157.64 208.14,157.64 206.31,159.47 206.31,169.3 205.11,170.5 204.46,170.5 202.86,172.1 202.86,176.18 200.29,178.75 v1(200.08,178.75)
  IN3 w0.114: v1(166.68,75.97) 165.92,75.2 165.92,74.95 165.48,74.51 165.48,68.47 166.67,67.27 166.67,66.45 169.26,63.86 169.26,61.33 170.51,60.08 170.51,53.42 171.76,52.17 171.76,48.62 172.14,48.24 172.14,47.39 171.84,47.09 171.84,46.37 172.47,45.74 172.47,43.78 173.86,42.39 173.86,39.5 172.6,38.24 172.6,36.22 v1(172.87,35.95)
  BOTTOM w0.127: U45.82 172.72,35.8 v1(172.87,35.95) ; CN10.54 v1(200.08,178.75)
C_PEG_TX0: length 6.4
  BOTTOM w0.076: 132.43,126.26 132.42,126.24 132.42,126.18 131.34,125.1 131.34,123.84 U35.A17
  BOTTOM w0.127: 132.43,126.26 133.06,126.89 133.91,126.89 134.22,127.2 134.22,127.68 134.1,127.8 133.94,127.8 C652.2
C_PEG_TX1: length 10.2
  BOTTOM w0.076: 134.45,126.26 134.42,126.23 133.1,126.23 131.73,124.87 131.73,123.18 131.55,123.01 131.55,122.83 131.64,122.74 U35.C16
  BOTTOM w0.127: 134.45,126.26 135.34,127.15 135.34,127.54 135.85,128.04 135.85,129.56 135.73,129.68 135.57,129.68 C655.2
C_PEG_TX2: length 12.8
  BOTTOM w0.076: 131.92,126.08 131.9,126.06 131.84,126.06 130.94,125.16 130.94,123.6 130.96,123.53 130.96,123.24 130.94,123.19 130.93,123.16 130.93,122.98 130.98,122.86 130.99,122.82 130.99,122.63 U35.C17
  BOTTOM w0.127: 131.92,126.08 132.47,126.63 132.47,128.8 133,129.33 133,129.84 v1(133.51,130.35) 133,130.86 133,130.93 134,131.93 134,132.65 134.13,132.78 134.37,132.78 C662.2
C_PEG_TX3: length 11
  BOTTOM w0.076: U35.A19 129.86,123.45 129.78,123.37 129.65,123.37 129.53,123.49 129.53,123.97 129.85,124.29 129.85,126.19 129.9,126.24 129.9,126.26
  BOTTOM w0.127: 129.9,126.26 129.9,130.49 130.74,131.34 131.1,131.34 131.6,131.84 131.6,132.19 C660.2
C_PEG_TX#0: length 6.4
  BOTTOM w0.076: 132.61,126.08 132.6,126.06 132.53,126.06 131.5,125.03 131.5,123.52 131.21,123.23 U35.B17
  BOTTOM w0.127: 132.61,126.08 133.17,126.64 134.02,126.64 134.47,127.09 134.47,127.32 C653.1
C_PEG_TX#1: length 10.2
  BOTTOM w0.076: U35.D16 131.77,122.34 132.07,122.64 132.07,123.02 131.9,123.2 131.9,124.8 133.16,126.07 134.62,126.07 134.81,126.26
  BOTTOM w0.127: C656.2 136.1,129.2 136.1,127.93 135.6,127.43 135.6,127.05 134.81,126.26
