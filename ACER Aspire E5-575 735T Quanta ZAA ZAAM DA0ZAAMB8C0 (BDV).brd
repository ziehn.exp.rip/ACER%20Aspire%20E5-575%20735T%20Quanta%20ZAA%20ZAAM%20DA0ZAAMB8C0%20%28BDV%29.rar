# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Nets (continued)
IRQ_SERIRQ: R629.2 U35.AY11 U44.27 U45.5
ISEN1_B: PC18.1 PR19.1 PR188.2 PU1.9
ISEN2_B: PC17.1 PR18.2 PR189.1 PR6301.1 PU1.10
ISL95857_COMP_A: PC24.2 PR199.1 PU1.16
ISL95857_COMP_B: PC21.2 PR195.1 PU1.4
ISL95857_COMP_C: PC37.2 PR216.1 PU1.24
ISL95857_FB_A: PR34.1 PR36.1 PR201.1 PU1.17
ISL95857_FB_B: PR23.1 PR24.1 PR194.1 PU1.5
ISL95857_FB_C: PR44.1 PR45.1 PR217.1 PU1.25
ISL95857_FCCM_A: PR42.1 PU1.21
ISL95857_FCCM_B: PR26.2 PU1.11
ISL95857_FCCM_C: PR46.1 PU1.29
ISL95857_IMON_A: PC23.1 PR202.1 PU1.14
ISL95857_IMON_B: PC22.1 PR198.1 PU1.2
ISL95857_IMON_C: PC36.1 PR207.1 PU1.23
ISL95857_ISUMN_A: PC34.2 PR211.1 PU1.20
ISL95857_ISUMN_B: PC19.1 PR192.2 PU1.8
ISL95857_ISUMN_C: PC40.2 PR220.1 PU1.28
ISL95857_NTC_A: PR235.1 PR236.1 PU1.15
ISL95857_NTC_B: PR226.1 PR227.1 PU1.3
ISL95857_PROG1: PR203.1 PU1.32
ISL95857_PROG2: PR206.1 PU1.31
ISL95857_PSYS: PR25.1 PU1.1
ISL95857_PWM1_B: PR27.2 PU1.12
ISL95857_PWM2_B: PR29.2 PU1.13
ISL95857_PWM_A: PR43.1 PU1.22
ISL95857_PWM_C: PR47.1 PU1.30
ISL95857_RTN_A: PC27.2 PC29.2 PR38.1 PR39.1 PU1.18
ISL95857_RTN_B: PC10.2 PC12.2 PR180.1 PR181.2 PU1.6
ISL95857_RTN_C: PC44.2 PC45.2 PR49.1 PR52.1 PU1.26
ISL95857_SCLK: PR35.2 PU1.37
ISL95857_SDA: PR40.1 PU1.35
ISL95857_VCC: PC32.1 PR204.2 PU1.34
ISL95857_VIN: PC35.1 PR212.1 PU1.33
ISL95857_VR_EN: PR28.2 PU1.40
ISL95857_VR_HOT: PR32.2 PU1.38
ISL95857_VR_READY: PR30.2 PU1.39
ISOLATEB: R11262.1 R11263.2 U15.31
ISUMN_A: PC30.2 PC31.1 PC33.1 PR41.2 PR208.1 PR211.2 PR214.1 PR243.2
ISUMN_B: PC14.1 PC17.2 PC18.2 PC20.1 PC134.2 PR17.1 PR21.1 PR22.1 PR182.1 PR192.1 PR241.1
ISUMN_C: PC38.2 PC39.1 PC43.1 PR48.2 PR219.1 PR220.2 PR221.1 PR242.2
ISUMP_A: PC30.1 PC31.2 PR205.2 PR208.2 PR215.1 PU1.19
ISUMP_B: PC20.2 PC134.1 PR20.1 PR22.2 PR190.1 PR193.2 PU1.7
ISUMP_C: PC38.1 PC39.2 PR218.2 PR219.2 PR222.1 PU1.27
JTAG_TCK: R4332.2 TP4300.1 U3002.AM10
JTAG_TDI: R4331.2 TP4303.1 U3002.AM11
JTAG_TDO: TP4305.1 U3002.AP12
JTAG_TMS: R4330.2 TP4301.1 U3002.AP11
JTAG_TRST#: R4334.2 TP4307.1 U3002.AN11
KB_BL_LED: Q19.2 U45.113
L_SPK+: R404.2 U23.42
L_SPK+_1: C545.1 CN18.4 R404.1
L_SPK-: R406.2 U23.43
L_SPK-_1: C546.1 CN18.3 R406.1
LAN_MCT0: R251.2 U42.24
LAN_MCT1: R11265.2 U42.21
LAN_MCT2: R262.2 U42.18
LAN_MCT3: R269.2 U42.15
LAN_MX0+: CN11.1 U42.14
LAN_MX0-: CN11.2 U42.13
LAN_MX1+: CN11.3 U42.17
LAN_MX1-: CN11.6 U42.16
LAN_MX2+: CN11.4 U42.20
LAN_MX2-: CN11.5 U42.19
LAN_MX3+: CN11.7 U42.23
LAN_MX3-: CN11.8 U42.22
LAN_XTAL2: C4605.2 U15.45 Y1.3
LAN_XTALI: C4606.2 U15.44 Y1.1
LANE0_N: C331.2 U13.6
LANE0_P: C335.2 U13.5
LANE1_N: C315.2 U13.8
LANE1_P: C329.2 U13.7
LANPWR#: R259.1 R260.2 U45.70
LANVCC: C350.2 C354.1 C361.2 C365.1 C366.1 C367.2 C370.1 C377.2 Q39.2 R247.1 R248.2 R702.1 R11259.2 R11266.2 U15.11 U15.48
LCDVCC: C29.2 C30.1 C33.2 C34.1 C35.2 R28.1 U1.1
LCDVCC_R: C580.2 C581.1 CN5.34 CN5.35 CN5.36 R28.2
LID#: D1.1 D23.2 R53.2 R460.2 R11129.1
LID#15: MR1.2 R435.1 R11129.2
LINE1-L: C552.1 U23.22
LINE1-R: C549.1 U23.21
LINE1-VREFO-L: R421.2 U23.31
LINE1-VREFO-R: R418.2 U23.30
LM393_PIN2: PR146.2 PR262.2 PU4.2
LPC_LAD0: R659.2 R688.1 U44.24 U45.10
LPC_LAD0_C: CN10.64 R688.2
LPC_LAD1: R640.2 R690.1 U44.21 U45.9
LPC_LAD1_C: CN10.66 R690.2
LPC_LAD2: R653.2 R693.1 U44.18 U45.8
LPC_LAD2_C: CN10.68 R693.2
LPC_LAD3: R668.2 R696.1 U44.15 U45.7
LPC_LAD3_C: CN10.70 R696.2
LPC_LFRAME#: R699.2 U35.BA12 U44.20 U45.6
LPC_LFRAME#_C: CN10.73 R699.1
LPCPD: R744.2 U44.28
LPM_ZVM_N: PR280.1 R762.2
M_A_A0: JDIM1.144 U35.AY50
M_A_A1: JDIM1.133 U35.BB50
M_A_A2: JDIM1.132 U35.AY51
M_A_A3: JDIM1.131 U35.BA50
M_A_A4: JDIM1.128 U35.BB52
M_A_A5: JDIM1.126 U35.BA51
M_A_A6: JDIM1.127 U35.BA52
M_A_A7: JDIM1.122 U35.AW52
M_A_A8: JDIM1.125 U35.AY52
M_A_A9: JDIM1.121 U35.BB54
M_A_A10: JDIM1.146 U35.AT50
M_A_A11: JDIM1.120 U35.BA54
M_A_A12: JDIM1.119 U35.AW54
M_A_A13: JDIM1.158 U35.AU46
M_A_ACT#: JDIM1.114 U35.BA55
M_A_ALERT#: JDIM1.116 U35.AW50
M_A_BA#0: JDIM1.150 U35.AU52
M_A_BA#1: JDIM1.145 U35.AT48
M_A_BG#0: JDIM1.115 U35.AY55
M_A_BG#1: JDIM1.113 U35.AY54
M_A_CAS#: JDIM1.156 U35.AU48
M_A_CB0: JDIM1.92 R10896.2
M_A_CB1: JDIM1.91 R10871.2
M_A_CB2: JDIM1.101 R10875.2
M_A_CB3: JDIM1.105 R10881.2
M_A_CB4: JDIM1.88 R10879.2
M_A_CB5: JDIM1.87 R10884.2
M_A_CB6: JDIM1.100 R10888.2
M_A_CB7: JDIM1.104 R10892.2
M_A_CKE0: JDIM1.109 U35.BA56
M_A_CKE1: JDIM1.110 U35.BB56
M_A_CLK0: JDIM1.137 U35.AT53
M_A_CLK0#: JDIM1.139 U35.AU53
M_A_CLK1: JDIM1.138 U35.AT55
M_A_CLK1#: JDIM1.140 U35.AU55
M_A_CS#0: JDIM1.149 U35.AU45
M_A_CS#1: JDIM1.157 U35.AU43
M_A_DQ0: JDIM1.8 U35.AL71
M_A_DQ1: JDIM1.3 U35.AL68
M_A_DQ2: JDIM1.20 U35.AN68
M_A_DQ3: JDIM1.17 U35.AN69
M_A_DQ4: JDIM1.7 U35.AL70
M_A_DQ5: JDIM1.4 U35.AL69
M_A_DQ6: JDIM1.21 U35.AN70
M_A_DQ7: JDIM1.16 U35.AN71
M_A_DQ8: JDIM1.29 U35.AR70
M_A_DQ9: JDIM1.24 U35.AR68
M_A_DQ10: JDIM1.42 U35.AU71
M_A_DQ11: JDIM1.38 U35.AU68
M_A_DQ12: JDIM1.25 U35.AR71
M_A_DQ13: JDIM1.28 U35.AR69
M_A_DQ14: JDIM1.37 U35.AU70
M_A_DQ15: JDIM1.41 U35.AU69
M_A_DQ16: JDIM1.49 U35.BB65
M_A_DQ17: JDIM1.46 U35.AW65
M_A_DQ18: JDIM1.58 U35.AW63
M_A_DQ19: JDIM1.59 U35.AY63
M_A_DQ20: JDIM1.45 U35.BA65
M_A_DQ21: JDIM1.50 U35.AY65
M_A_DQ22: JDIM1.63 U35.BA63
M_A_DQ23: JDIM1.62 U35.BB63
M_A_DQ24: JDIM1.67 U35.BA61
M_A_DQ25: JDIM1.66 U35.AW61
M_A_DQ26: JDIM1.84 U35.BB59
M_A_DQ27: JDIM1.80 U35.AW59
M_A_DQ28: JDIM1.70 U35.BB61
M_A_DQ29: JDIM1.71 U35.AY61
M_A_DQ30: JDIM1.83 U35.BA59
M_A_DQ31: JDIM1.79 U35.AY59
M_A_DQ32: JDIM1.170 U35.AY39
M_A_DQ33: JDIM1.173 U35.AW39
M_A_DQ34: JDIM1.183 U35.AY37
M_A_DQ35: JDIM1.187 U35.AW37
M_A_DQ36: JDIM1.169 U35.BB39
M_A_DQ37: JDIM1.174 U35.BA39
M_A_DQ38: JDIM1.182 U35.BA37
M_A_DQ39: JDIM1.186 U35.BB37
M_A_DQ40: JDIM1.194 U35.AY35
M_A_DQ41: JDIM1.195 U35.AW35
M_A_DQ42: JDIM1.207 U35.AY33
M_A_DQ43: JDIM1.203 U35.AW33
M_A_DQ44: JDIM1.190 U35.BB35
M_A_DQ45: JDIM1.208 U35.BA35
M_A_DQ46: JDIM1.204 U35.BA33
M_A_DQ47: JDIM1.191 U35.BB33
M_A_DQ48: JDIM1.211 U35.AY31
M_A_DQ49: JDIM1.215 U35.AW31
M_A_DQ50: JDIM1.225 U35.AY29
M_A_DQ51: JDIM1.228 U35.AW29
M_A_DQ52: JDIM1.212 U35.BB31
M_A_DQ53: JDIM1.216 U35.BA31
M_A_DQ54: JDIM1.224 U35.BA29
M_A_DQ55: JDIM1.229 U35.BB29
M_A_DQ56: JDIM1.245 U35.AY27
M_A_DQ57: JDIM1.246 U35.AW27
M_A_DQ58: JDIM1.232 U35.AY25
M_A_DQ59: JDIM1.236 U35.AW25
M_A_DQ60: JDIM1.249 U35.BB27
M_A_DQ61: JDIM1.250 U35.BA27
M_A_DQ62: JDIM1.237 U35.BA25
M_A_DQ63: JDIM1.233 U35.BB25
M_A_DQS0: JDIM1.13 U35.AM69
M_A_DQS1: JDIM1.34 U35.AT70
M_A_DQS2: JDIM1.55 U35.AY64
M_A_DQS3: JDIM1.76 U35.BA60
M_A_DQS4: JDIM1.179 U35.AY38
M_A_DQS5: JDIM1.200 U35.BA34
M_A_DQS6: JDIM1.221 U35.AY30
M_A_DQS7: JDIM1.242 U35.BA26
M_A_DQS8: JDIM1.97 R10891.2
M_A_DQS#0: JDIM1.11 U35.AM70
M_A_DQS#1: JDIM1.32 U35.AT69
M_A_DQS#2: JDIM1.53 U35.BA64
M_A_DQS#3: JDIM1.74 U35.AY60
M_A_DQS#4: JDIM1.177 U35.BA38
M_A_DQS#5: JDIM1.198 U35.AY34
M_A_DQS#6: JDIM1.219 U35.BA30
M_A_DQS#7: JDIM1.240 U35.AY26
M_A_DQS#8: JDIM1.95 R10894.2
M_A_EVENT#: JDIM1.134 R10885.2 R10890.1
M_A_ODT0_DIMM: JDIM1.155 U35.AT45
M_A_ODT1_DIMM: JDIM1.161 U35.AT43
M_A_PARITY: JDIM1.143 U35.AT52
M_A_RAS#: JDIM1.152 U35.AU50
M_A_WE#: JDIM1.151 U35.AT46
M_B_A0: JDIM2.144 U35.BA46
M_B_A1: JDIM2.133 U35.AY46
M_B_A2: JDIM2.132 U35.AY47
M_B_A3: JDIM2.131 U35.BB46
M_B_A4: JDIM2.128 U35.BA47
M_B_A5: JDIM2.126 U35.AY48
M_B_A6: JDIM2.127 U35.BA48
M_B_A7: JDIM2.122 U35.AP48
M_B_A8: JDIM2.125 U35.BB48
M_B_A9: JDIM2.121 U35.AP50
M_B_A10: JDIM2.146 U35.AW46
M_B_A11: JDIM2.120 U35.AN48
M_B_A12: JDIM2.119 U35.AN50
M_B_A13: JDIM2.158 U35.BA43
M_B_ACT#: JDIM2.114 U35.AN53
M_B_ALERT#: JDIM2.116 U35.AN43
M_B_BA#0: JDIM2.150 U35.BB44
M_B_BA#1: JDIM2.145 U35.BA44
M_B_BG#0: JDIM2.115 U35.AP52
M_B_BG#1: JDIM2.113 U35.AN52
M_B_CAS#: JDIM2.156 U35.AY43
M_B_CB0: JDIM2.92 R10931.2
M_B_CB1: JDIM2.91 R10936.2
M_B_CB2: JDIM2.101 R10933.2
M_B_CB3: JDIM2.105 R10939.2
M_B_CB4: JDIM2.88 R10941.2
M_B_CB5: JDIM2.87 R10922.2
M_B_CB6: JDIM2.100 R10942.2
M_B_CB7: JDIM2.104 R10925.2
M_B_CKE0: JDIM2.109 U35.AN56
M_B_CKE1: JDIM2.110 U35.AP55
M_B_CLK0: JDIM2.137 U35.AP45
M_B_CLK0#: JDIM2.139 U35.AN45
M_B_CLK1: JDIM2.138 U35.AP46
M_B_CLK1#: JDIM2.140 U35.AN46
M_B_CS#0: JDIM2.149 U35.BB42
M_B_CS#1: JDIM2.157 U35.AY42
M_B_DQ0: JDIM2.4 U35.AF65
M_B_DQ1: JDIM2.8 U35.AF64
M_B_DQ2: JDIM2.16 U35.AK65
M_B_DQ3: JDIM2.21 U35.AK64
M_B_DQ4: JDIM2.7 U35.AF66
M_B_DQ5: JDIM2.3 U35.AF67
M_B_DQ6: JDIM2.17 U35.AK67
M_B_DQ7: JDIM2.20 U35.AK66
M_B_DQ8: JDIM2.25 U35.AF70
M_B_DQ9: JDIM2.29 U35.AF68
M_B_DQ10: JDIM2.37 U35.AH71
M_B_DQ11: JDIM2.38 U35.AH68
M_B_DQ12: JDIM2.24 U35.AF71
M_B_DQ13: JDIM2.28 U35.AF69
M_B_DQ14: JDIM2.41 U35.AH70
M_B_DQ15: JDIM2.42 U35.AH69
M_B_DQ16: JDIM2.45 U35.AT66
M_B_DQ17: JDIM2.49 U35.AU66
M_B_DQ18: JDIM2.58 U35.AP65
M_B_DQ19: JDIM2.62 U35.AN65
M_B_DQ20: JDIM2.46 U35.AN66
M_B_DQ21: JDIM2.50 U35.AP66
M_B_DQ22: JDIM2.63 U35.AT65
M_B_DQ23: JDIM2.59 U35.AU65
M_B_DQ24: JDIM2.67 U35.AT61
M_B_DQ25: JDIM2.71 U35.AU61
M_B_DQ26: JDIM2.83 U35.AP60
M_B_DQ27: JDIM2.80 U35.AN60
M_B_DQ28: JDIM2.70 U35.AN61
M_B_DQ29: JDIM2.66 U35.AP61
M_B_DQ30: JDIM2.79 U35.AT60
M_B_DQ31: JDIM2.84 U35.AU60
M_B_DQ32: JDIM2.174 U35.AU40
M_B_DQ33: JDIM2.170 U35.AT40
M_B_DQ34: JDIM2.182 U35.AT37
M_B_DQ35: JDIM2.186 U35.AU37
M_B_DQ36: JDIM2.173 U35.AR40
M_B_DQ37: JDIM2.169 U35.AP40
M_B_DQ38: JDIM2.183 U35.AP37
M_B_DQ39: JDIM2.187 U35.AR37
M_B_DQ40: JDIM2.194 U35.AT33
M_B_DQ41: JDIM2.190 U35.AU33
M_B_DQ42: JDIM2.207 U35.AU30
M_B_DQ43: JDIM2.203 U35.AT30
M_B_DQ44: JDIM2.191 U35.AR33
M_B_DQ45: JDIM2.195 U35.AP33
M_B_DQ46: JDIM2.204 U35.AR30
M_B_DQ47: JDIM2.208 U35.AP30
M_B_DQ48: JDIM2.211 U35.AU27
M_B_DQ49: JDIM2.215 U35.AT27
M_B_DQ50: JDIM2.225 U35.AT25
M_B_DQ51: JDIM2.224 U35.AU25
M_B_DQ52: JDIM2.212 U35.AP27
M_B_DQ53: JDIM2.216 U35.AN27
M_B_DQ54: JDIM2.228 U35.AN25
M_B_DQ55: JDIM2.229 U35.AP25
M_B_DQ56: JDIM2.233 U35.AT22
M_B_DQ57: JDIM2.232 U35.AU22
M_B_DQ58: JDIM2.245 U35.AU21
M_B_DQ59: JDIM2.249 U35.AT21
M_B_DQ60: JDIM2.236 U35.AN22
M_B_DQ61: JDIM2.237 U35.AP22
M_B_DQ62: JDIM2.250 U35.AP21
M_B_DQ63: JDIM2.246 U35.AN21
M_B_DQS0: JDIM2.13 U35.AH65
M_B_DQS1: JDIM2.34 U35.AG70
M_B_DQS2: JDIM2.55 U35.AR65
M_B_DQS3: JDIM2.76 U35.AR60
M_B_DQS4: JDIM2.179 U35.AR38
M_B_DQS5: JDIM2.200 U35.AR32
M_B_DQS6: JDIM2.221 U35.AR27
M_B_DQS7: JDIM2.242 U35.AR21
M_B_DQS8: JDIM2.97 R10926.2
M_B_DQS#0: JDIM2.11 U35.AH66
M_B_DQS#1: JDIM2.32 U35.AG69
M_B_DQS#2: JDIM2.53 U35.AR66
M_B_DQS#3: JDIM2.74 U35.AR61
M_B_DQS#4: JDIM2.177 U35.AT38
M_B_DQS#5: JDIM2.198 U35.AT32
M_B_DQS#6: JDIM2.219 U35.AR25
M_B_DQS#7: JDIM2.240 U35.AR22
M_B_DQS#8: JDIM2.95 R10929.2
M_B_EVENT#: JDIM2.134 R10921.1 R10928.2
M_B_ODT0_DIMM: JDIM2.155 U35.BA42
M_B_ODT1_DIMM: JDIM2.161 U35.AW42
M_B_PARITY: JDIM2.143 U35.AP43
M_B_RAS#: JDIM2.152 U35.AW44
M_B_WE#: JDIM2.151 U35.AY44
MAIND: PC103.2 PQ3.3 PQ26.4 PQ6058.3 PQ6065.2 PR148.2
MAINON: R389.1 R791.2 U45.30 U49.1 U1006.10
MAINON_ON_G: PQ3.2 PQ4.2 PQ5.2 PQ10.2 PQ11.3 PQ6066.2 PR150.1 PR151.2
MAINON_R: PQ11.2 PR37.1 PR147.1 PR257.2 PR6291.2 PR6294.2 R791.1 U49.4
MBCLK: PC9.1 PD2.1 PR7.2 PR178.1 R731.1 U45.110
MBDATA: PC8.1 PD1.1 PR6.2 PR177.1 R732.1 U45.111
MDI_0+: U15.1 U42.11
MDI_0-: U15.2 U42.12
MDI_1+: U15.4 U42.8
MDI_1-: U15.5 U42.9
MDI_2+: U15.6 U42.5
MDI_2-: U15.7 U42.6
MDI_3+: U15.9 U42.2
MDI_3-: U15.10 U42.3
ME_WR#: R737.1 U45.109
MIC2-VREFO: R407.1 R424.1 U23.29
MOD_EN_5V: C752.1 Q34.3 Q37.6 R686.1
MPHY_EXT_PWR: R195.2 U35.AM10
MULTISTRAP_REF_GND: R4344.2 R4345.2 U3002.J1
MX0: C4804.1 CN20.1 CN2019.1 RP1.4 U45.58
MX1: C4805.1 CN20.2 CN2019.2 RP1.5 U45.59
MX2: C4806.1 CN20.3 CN2019.3 RP1.3 U45.60
MX3: C4807.1 CN20.4 CN2019.4 RP1.1 U45.61
MX4: C4788.1 CN20.5 CN2019.5 RP1.9 U45.62
MX5: C4789.1 CN20.6 CN2019.6 RP1.7 U45.63
MX6: C4790.1 CN20.7 CN2019.7 RP1.8 U45.64
MX7: C4791.1 CN20.8 CN2019.8 RP1.6 U45.65
MY0: C4795.1 CN20.26 CN2019.26 U45.36
MY1: C4794.1 CN20.25 CN2019.25 U45.37
MY2: C4793.1 CN20.24 CN2019.24 U45.38
MY3: C4792.1 CN20.23 CN2019.23 U45.39
MY4: C4799.1 CN20.22 CN2019.22 U45.40
MY5: C4798.1 CN20.21 CN2019.21 U45.41
MY6: C4797.1 CN20.20 CN2019.20 U45.42
MY7: C4796.1 CN20.19 CN2019.19 U45.43
MY8: C4803.1 CN20.18 CN2019.18 U45.44
MY9: C4802.1 CN20.17 CN2019.17 U45.45
MY10: C4801.1 CN20.16 CN2019.16 U45.46
MY11: C4800.1 CN20.15 CN2019.15 U45.51
MY12: C4811.1 CN20.14 CN2019.14 U45.52
MY13: C4810.1 CN20.13 CN2019.13 U45.53
MY14: C4809.1 CN20.12 CN2019.12 U45.54
MY15: C4808.1 CN20.11 CN2019.11 U45.55
MY16: CN20.10 CN2019.10 U45.56
MY17: CN20.9 CN2019.9 U45.57
NBSWON#: C785.2 C805.1 R265.2 R730.1 R753.1 R776.2 R11107.2 SW2.1 SW2.2 U45.107
NGFF1_RST#_SSD: CN23.50 R960.1
NGFF3_PEDET: CN23.69 Q59.2 R961.2 R968.2
NGFF_SATA_DET: Q59.3 R11284.2 U35.G4
NGFF_SSD_CLK: CN23.55 R11113.1
NGFF_SSD_CLK#: CN23.53 R11112.1
NGFF_SSD_CLK#_C: R11112.2 U35.B42
NGFF_SSD_CLK_C: R11113.2 U35.A42
NV_PLLVDD: C4204.1 C4205.2 L4200.2 U3002.AD8
ODD_EN: Q37.5 R692.1 R703.1 R704.1
ODD_EN_Q: Q36.2 Q37.2 Q37.3 R695.2
ODD_POWER: R704.2 U45.71
ODD_PRSNT#: C802.1 R217.2 U35.AB2
ODD_PRSNT#_C: C330.1 CN9.8 R216.1 R217.1
PCBEEP: C476.1 U23.12
PCBEEP_EC: D10.2 U45.34
PCH_ACPRESENT: R651.2 R676.2 U35.AY15
PCH_AZ_CODEC_BITCLK: C493.2 C739.2 R644.1 U23.6
PCH_AZ_CODEC_RST#: Q29.1 R660.1 U23.11
PCH_AZ_CODEC_SDIN0: R359.2 U35.BA21
PCH_AZ_CODEC_SDOUT: R645.1 U23.5
PCH_AZ_CODEC_SYNC: R667.1 U23.10
PCH_BATLOW#: R628.2 TP74.1 U35.AU13
PCH_BLON: R67.1 U35.R12
PCH_BLON_C: Q3.5 R65.2 R66.2 R67.2
PCH_BLON_R: R66.1 U45.88
PCH_BRIGHT: CN5.27 R546.1 U35.R11
PCH_DP_HPD: R564.2 R10846.1 U35.L7
PCH_MBCLK0_R: Q32.6 R578.2 U35.R7
PCH_MBDAT0_R: Q32.3 R580.2 U35.R8
PCH_ODD_EN: R703.2 U35.N12
PCH_PWRBTN#: R677.2 U35.BA15
PCH_PWROK: R103.2 R647.2 R648.1 U45.78
PCH_RSMRST#: R642.1 R655.2 R661.2 U35.AY17
PCH_SLP_A#: R273.2 U35.AN16
PCH_SLP_LAN#: TP30.1 U35.AW15
PCH_SLP_S5#: R279.2 U35.AY16
PCH_SLP_SUS#: TP4369.1 U35.AN15
PCH_SLP_WLAN#: TP23.1 U35.BB17
PCH_SPI_CLK: C747.1 R684.2 U35.AV2
PCH_SPI_CLK_EC: C4726.1 R687.1 U45.105
PCH_SPI_CS0#: R602.2 U35.AU3 U41.1
PCH_SPI_IO2: R589.1 U35.AW2
PCH_SPI_IO3: R239.1 U35.AU4
PCH_SPI_SI: R691.2 U35.AV3
PCH_SPI_SI_EC: R654.1 R735.1 U45.102
PCH_SPI_SO: R650.1 U35.AW3
PCH_SPI_SO_EC: R588.1 R736.1 U45.103
PCH_SUSPWRACK: R11114.2 R11140.1 U45.15
PCH_TRST#: R534.2 U35.B59 U35.C61
PCH_TYPEC_UPFB#: R11251.1 R11280.1 U35.L6
PCH_VRALERT#: R211.2 TP19.1 U35.AM11
PCI_PLTRST#: U14.1 U14.2 U35.AN10
PCIE_CLKREQ_NGFF_SSD#: R11110.2 R11111.1
PCIE_CLKREQ_NGFF_SSD#_R: CN23.52 R11110.1
PCIE_CLKREQ_WLAN#: Q23.3 R224.1 R241.1 R253.1
PCIE_LAN_WAKE#: R244.1 R250.1 R713.2 U35.BB15
PCIE_LAN_WAKE#_R: Q39.1 R702.2 R709.1 U15.39
PCIE_RCOMPN: R562.2 U35.F5
PCIE_RCOMPP: R562.1 U35.E5
PCIE_REQ_LAN#_R: Q25.1 R276.1 R277.2 U15.29
PCIE_RX5+_LAN: C4601.2 U35.E23
PCIE_RX5+_LAN_C: C4601.1 U15.25
PCIE_RX5-_LAN: C4602.2 U35.E22
PCIE_RX5-_LAN_C: C4602.1 U15.26
PCIE_RX6+_WLAN: CN10.41 U35.E25
PCIE_RX6-_WLAN: CN10.43 U35.F25
PCIE_TX5+: C669.1 U35.A23
PCIE_TX5+_LAN: C669.2 U15.21
PCIE_TX5-: C668.1 U35.B23
PCIE_TX5-_LAN: C668.2 U15.22
PCIE_TX6+: C649.1 U35.C23
PCIE_TX6+_WLAN: C649.2 CN10.35
PCIE_TX6-: C648.1 U35.D23
PCIE_TX6-_WLAN: C648.2 CN10.37
PCLK_TPM: R626.1 U44.19
PD#: C494.1 D15.2 D16.2 R369.1 R372.2 U23.47
PEG_RX0: C4015.1 U35.G13
PEG_RX1: C4017.1 U35.F11
PEG_RX2: C4020.1 U35.G16
PEG_RX3: C4022.1 U35.F15
PEG_RX#0: C4016.1 U35.H13
PEG_RX#1: C4018.1 U35.G11
PEG_RX#2: C4021.1 U35.H16
PEG_RX#3: C4023.1 U35.G15
PEG_RXN0_C: C4016.2 U3002.AJ14
PEG_RXN1_C: C4018.2 U3002.AG14
PEG_RXN2_C: C4021.2 U3002.AJ15
PEG_RXN3_C: C4023.2 U3002.AK16
PEG_RXP0_C: C4015.2 U3002.AK14
PEG_RXP1_C: C4017.2 U3002.AH14
PEG_RXP2_C: C4020.2 U3002.AK15
PEG_RXP3_C: C4022.2 U3002.AL16
PEG_TX0: C652.1 U3002.AN12
PEG_TX1: C655.1 U3002.AN14
PEG_TX2: C662.1 U3002.AP14
PEG_TX3: C660.1 U3002.AN15
PEG_TX#0: C653.2 U3002.AM12
PEG_TX#1: C656.1 U3002.AM14
PEG_TX#2: C661.1 U3002.AP15
PEG_TX#3: C654.1 U3002.AM15
PEGX_RST#: Q4301.2 R4004.1 R4005.2 R4007.1 U3002.AJ12 U4002.4
PEX_CLKREQ#: Q4002.1 R4008.1 U3002.AK12
PEX_PLLVDD: C4036.1 C4037.2 C4040.1 R4010.2 U3002.AG26
PEX_TERMP: R4009.2 U3002.AP29
PEX_TSTCLK: R4006.2 U3002.AJ26
PEX_TSTCLK#: R4006.1 U3002.AK26
PIRQA#: R631.1 U35.BB11
PLLVDD: C4208.1 C4209.1 C4210.2 C4211.2 L4201.2 U3002.AD7 U3002.AE8
PLTRST#: C4030.2 R214.1 R671.1 R742.1 R749.1 R960.2 R11261.1 U14.4 U4001.2
PLTRST#_EC: C822.1 R749.2 U45.22
PM_THRMTRIP#: R10890.2 R10921.2
PMON: PC7.2 PR25.2 PR172.1 PR342.2
POA_AUTH_ERR: R11294.2 U45.48
POA_EN#: R11292.2 U45.83
POA_FP_PWREN#: R2854.1 U45.76
POA_POWERREQ: R11295.2 U45.20
POA_PWR: C3001.2 Q75.1 R11287.1 R11289.1 R11296.1 R11297.1
POA_PWR_INT#: R11293.2 U45.19
PROC_PWRGD: R544.2 R554.1 U35.A68
PROCHOT_EC: Q30.2 R380.2 U45.17
PS_FB_CLAMP: R4114.1 U3002.E1
PTP_PWR_EN#: R754.1 U45.125
PWM1_B: PR27.1 PR228.1
PWM2_B: PR29.1 PR233.1
PWM-VID: PR256.1 U3002.M5
PWM_A: PR43.2 PR237.1
PWM_C: PR47.2 PR239.1
PWRLED#: R426.1 R432.1 R436.1 U45.24
R_SPK+: R419.2 U23.45
R_SPK+_1: C551.1 CN18.1 R419.1
R_SPK-: R414.2 U23.44
R_SPK-_1: C548.1 CN18.2 R414.1
RAM_ID1: R610.2 R611.1 U35.AP2
RAM_ID2: R612.2 R613.1 U35.AP1
RAM_ID3: R614.2 R615.1 U35.AP3
REGN6V: PC122.1 PR1.1 PU5.24
REGOUT: C363.2 R246.1 U15.36
RF_EN: CN10.56 R774.2
RING2: R424.2 R425.1 U23.17
RING2_R: C554.1 CN2020.19 CN2020.20 CN2020.21 R425.2
ROM_SCLK: R4307.1 R4315.2 U3002.H4
ROM_SI: R4305.1 R4313.2 U3002.H5
ROM_SO: R4306.1 R4314.2 U3002.H7
RSET: R11264.2 U15.47
RSMRST#: R655.1 U45.112
RST_MON#: R4007.2 R11108.1 U4001.4
RTC_RST#: C380.1 J1.1 Q6060.3 R268.2 R299.2 U35.AM16
RTC_X1: C351.2 R255.1 U35.AM18 Y2.1
RTC_X2: C362.2 R255.2 U35.AM20 Y2.2
RTD_PIN11: R11285.1 U13.11
RTD_PIN12: R11286.1 U13.12
S5_ON: PQ9.2 PQ13.2 PR69.1 PR6285.1 PR6293.1 PR6299.1 R741.1 U45.100
SATA_DEVSLP1: R574.1 U35.J2
SATA_DEVSLP2: R575.1 R956.2 U35.J3
SATA_RXN0: C507.2 U35.F20
SATA_RXN0_C: C507.1 CN14.5
SATA_RXN1: C744.2 U35.G21
SATA_RXN1_C: C744.1 CN9.5
SATA_RXN3/PEG_RXN9_L0: R959.2 U35.E28
SATA_RXN3/PEG_RXN9_L0_N: CN23.29 R959.1
SATA_RXN3/PEG_RXN10_L1: R11062.2 U35.E30
SATA_RXN3/PEG_RXN10_L1_N: CN23.43 R11062.1
SATA_RXP0: C504.2 U35.E20
SATA_RXP0_C: C504.1 CN14.6
SATA_RXP1: C743.2 U35.F21
SATA_RXP1_C: C743.1 CN9.6
SATA_RXP3/PEG_RXP9_L0: R958.2 U35.E27
SATA_RXP3/PEG_RXP9_L0_N: CN23.31 R958.1
SATA_RXP3/PEG_RXP10_L1: R11061.2 U35.F30
SATA_RXP3/PEG_RXP10_L1_N: CN23.41 R11061.1
SATA_TXN0: C513.2 U35.B21
SATA_TXN0_C: C513.1 CN14.3
SATA_TXN1: C749.2 U35.D21
SATA_TXN1_C: C749.1 CN9.3
SATA_TXN3/PEG_TXN9_L0: C1176.1 U35.D24
SATA_TXN3/PEG_TXN9_L0_N: C1176.2 CN23.35
SATA_TXN3/PEG_TXN10_L1: C4664.1 U35.A25
SATA_TXN3/PEG_TXN10_L1_N: C4664.2 CN23.47
SATA_TXP0: C522.2 U35.A21
SATA_TXP0_C: C522.1 CN14.2
SATA_TXP1: C751.2 U35.C21
SATA_TXP1_C: C751.1 CN9.2
SATA_TXP3/PEG_TXP9_L0: C1177.1 U35.C24
SATA_TXP3/PEG_TXP9_L0_N: C1177.2 CN23.37
SATA_TXP3/PEG_TXP10_L1: C4665.1 U35.B25
SATA_TXP3/PEG_TXP10_L1_N: C4665.2 CN23.49
SATAGP0: R568.2 R570.2 U35.H2
SATAGP1: R569.1 U35.H3
SB_ACDC: R676.1 U45.84
SD_CLK_R: CN4.5 R11141.1
SEN_A0: R4547.2 VRAM3000.J10
SEN_A1: R4550.2 VRAM3004.J10
SEN_A2: R4553.2 VRAM3001.J10
SEN_A3: R4556.2 VRAM3005.J10
SEN_B0: R11090.2 VRAM3003.J10
SEN_B1: R11092.2 VRAM3007.J10
SEN_B2: R11083.2 VRAM3002.J10
SEN_B3: R11069.2 VRAM3006.J10
SENSEA: R378.2 R383.2 U23.13
SIO_A20GATE: TP77.1 U45.126
SIO_EXT_SCI#: R571.1 R781.1 U45.23
SIO_RCIN#: R652.1 U45.4
SLEEVE: R407.2 R408.1 U23.18
SLEEVE_R: C547.1 CN2020.16 CN2020.17 CN2020.18 R408.2
SM_RCOMP_0: R685.2 U35.AR18
SM_RCOMP_1: R678.2 U35.AT18
SM_RCOMP_2: R681.2 U35.AU18
SMB1ALERT#: R205.1 R218.2 U12.1 U35.AM7
SMB_ME1_CLK: R171.2 U35.W3
SMB_ME1_DAT: R175.2 U35.V3
SMBALERT#: R160.1 U35.R10
SML0ALERT#: R586.2 U35.W1
SP1: R11254.1 U15.14
SP1=SD_D1: C4611.1 CN4.8 R11254.2
SP2: R11253.1 U15.15
SP2=SD_D0=MS_D1: C4612.1 CN4.7 R11253.2
SP3: R11255.1 U15.16
SP3=SD_CLK=MS_D0: C4616.1 R11141.2 R11255.2
SP4: R11136.1 U15.17
SP4=SD_CMD=MS_D2: C4614.1 CN4.2 R11136.2
SP5: R11137.1 U15.18
SP5=SD_D3=MS_D3: C4613.1 CN4.1 R11137.2
SP6: R11138.1 U15.19
SP6=SD_D2=MS_CLK: C4615.1 CN4.9 R11138.2
SP7: R11139.1 U15.28
SP7=SD_WP=MS_BS: CN4.11 R11139.2
SP8: R11256.1 U15.42
SP8=SD_CD#: CN4.10 R11256.2
SPI_CLK_8M: R684.1 R687.2 U41.6
SPI_CS0#_UR_ME: R591.2 R602.1 U45.101
SPI_HOLD_IO3_ME: R239.2 R698.1 U41.7
SPI_SI_8M: R654.2 R691.1 U41.5
SPI_SO_8M: R588.2 R650.2 U41.2
SPI_WP_IO2_ME: R589.2 R649.2 U41.3
SPKR: D9.2 R624.1 R625.2 U35.AW5
SRTC_RST#: C382.1 Q6059.3 R300.2 U35.AN18
SSD_ID: CN9.7 R568.1
STRAP0: R4300.1 R4308.2 U3002.J2
STRAP1: R4301.1 R4309.2 U3002.J7
STRAP2: R4302.1 R4310.2 U3002.J6
STRAP3: R4303.1 R4311.2 U3002.J5
STRAP4: R4304.1 R4312.2 U3002.J3
SUSACK#_R: TP4368.1 U35.AP11
SUSB#: PQ6057.2 R282.2 U35.AP15 U45.119 U47.2 U49.2 U50.2
SUSC#: R274.2 U35.BA16 U45.18 U48.2
SUSCLK: R716.2 U35.BA17 U43.2
SUSD: PC101.2 PQ8.3 PQ23.2 PR142.2
SUSLED#: R427.1 R433.1 U45.28
SUSON: R739.1 R790.2 U45.120 U48.1
SUSON_R: PQ6.2 PR263.2 PR304.2 R790.1 U48.4
SYS_HWPG: D4014.1 PR6283.2 U45.77
SYS_PEX_RST_MON#: R4321.1 R11108.2 U3002.L3 U4002.2
SYS_PWROK: R113.1 R556.1 R560.1 R643.1 U8.4
SYS_PWROK_R: R131.1 R555.1 R556.2 U35.B6
SYS_RESET#: R267.2 R561.2 U35.B5
SYS_SHDN#: PQ14.3 PR6278.2 PR6280.2 PU6010.6 Q5.3 R11283.2
SYSTEM_AGND: PR6120.2 PR6121.2 PR6122.1 PR6124.2 PR6125.2
TEMP_MBAT#: PR8.2 PR9.1 PR12.1 U45.73
TERM9: C746.1 R251.1 R262.1 R269.1 R11265.1
TESTMODE: R4011.1 U3002.AK11
TH_FAN_POWER: C723.2 C728.2 CN8.1 U12.3
THRMTRIP#: Q5.1 R488.1 R530.1
TP_INT: CN5.1 Q1.1 R7.1 R8.2 R443.2
TP_INT_PCH: Q1.3 R8.1 U35.AB3
TP_PWR: C577.2 C578.2 CN5.30 CN5.31 R16.2 R19.2
TP_RST#: CN5.29 R444.1
TPCLK: R411.1 R415.2 U45.89
TPCLK_R: C787.2 CN17.7 R411.2
TPD_EN: CN17.1 R190.2
TPD_INT#: CN17.2 Q20.1 R164.1 R349.2
TPD_INT#_D: Q20.3 R164.2 R177.1 U35.W4
TPDATA: R412.1 R416.2 U45.90
TPDATA_R: C788.2 CN17.6 R412.2
TPM_BADD: R729.2 U44.6
TPM_CLKRUN#: R743.1 U44.13
TPM_LRESET#: R742.2 U44.17
TPM_PP: TP4358.1 U44.4
TS_EN: R442.1 R443.1 R751.1
TS_EN_C: C800.1 R751.2 U45.32
TS_EN_R: CN5.6 R442.2
TST: R617.1 R11209.1 U9.22
TYPEC_CHG: R11205.2 U28.7
TYPEC_CHG_HI: R11198.2 R11279.1 U28.8
TYPEC_SBU1: CN2021.A8 TP143.1 U4513.4
TYPEC_SBU2: CN2021.B8 TP144.1 U4513.7
UART2_CTS#: R290.1 TP4357.1 U35.AD4
UART2_RTS#: R283.1 TP4356.1 U35.AD3
UART2_RXD: R275.1 TP4354.1 U35.AD1
UART2_TXD: R280.1 TP4355.1 U35.AD2
USB2_ID: R587.1 U35.AG3
USB2_TYPC_7N_C: CN2021.A7 CN2021.B7 L69.3 R818.2 U4513.9
USB2_TYPC_7P_C: CN2021.A6 CN2021.B6 L69.2 R819.2 U4513.1
USB3_RXN0: C518.2 R392.2 U35.H8
USB3_RXN0_R: CN16.5 R392.1 U24.6
USB3_RXN1: C475.2 R355.2 U35.J6
USB3_RXN1_R: CN13.5 R355.1 U21.6
USB3_RXN2: C394.1 U35.J10
USB3_RXN3: C4777.1 U35.E10
USB3_RXP0: C517.2 R387.2 U35.G8
USB3_RXP0_R: CN16.6 R387.1 U24.5
USB3_RXP1: C469.2 R353.2 U35.H6
USB3_RXP1_R: CN13.6 R353.1 U21.5
USB3_RXP2: C4781.1 U35.H10
USB3_RXP3: C4776.1 U35.F10
USB3_TXN0: C499.1 U35.C13
USB3_TXN0_C: C499.2 R384.2
USB3_TXN0_R: C511.1 CN16.8 R384.1 U24.10
USB3_TXN1: C461.1 U35.B13
USB3_TXN1_C: C461.2 R341.2
USB3_TXN1_R: C460.1 CN13.8 R341.1 U21.10
USB3_TXN2: C4780.1 U35.B15
USB3_TXN3: C4779.1 U35.C15
USB3_TXP0: C498.1 U35.D13
USB3_TXP0_C: C498.2 R381.2
USB3_TXP0_R: C505.1 CN16.9 R381.1 U24.1
USB3_TXP1: C459.1 U35.A13
USB3_TXP1_C: C459.2 R340.2
USB3_TXP1_R: C458.1 CN13.9 R340.1 U21.1
USB3_TXP2: C369.1 U35.A15
USB3_TXP3: C4778.1 U35.D15
USB3_TYPC_RX2N_C: CN2021.B10 R11196.2 RP2.2 U4509.8
USB3_TYPC_RX2N_C_RE: C394.2 U9.1
USB3_TYPC_RX2N_RE: R11196.1 RP2.1 U9.27
USB3_TYPC_RX2P_C: CN2021.B11 R11199.2 RP2.3 U4509.2
USB3_TYPC_RX2P_C_RE: C4781.2 U9.2
USB3_TYPC_RX2P_RE: R11199.1 RP2.4 U9.26
USB3_TYPC_RX3N_C: CN2021.A10 R817.2 RP3.1 U4509.6
USB3_TYPC_RX3N_C_RE: C4777.2 U9.7
USB3_TYPC_RX3N_RE: R817.1 RP3.2 U9.21
USB3_TYPC_RX3P_C: CN2021.A11 R816.2 RP3.4 U4509.5
USB3_TYPC_RX3P_C_RE: C4776.2 U9.8
USB3_TYPC_RX3P_RE: R816.1 RP3.3 U9.20
USB3_TYPC_TX2N_C: CN2021.A3 R820.2 RP4.2 U4509.9
USB3_TYPC_TX2N_C_RE: C4780.2 U9.4
USB3_TYPC_TX2N_R: C4771.1 R820.1 RP4.1
USB3_TYPC_TX2N_RE: C4771.2 U9.24
USB3_TYPC_TX2P_C: CN2021.A2 R821.2 RP4.3 U4509.1
USB3_TYPC_TX2P_C_RE: C369.2 U9.5
USB3_TYPC_TX2P_R: C4770.1 R821.1 RP4.4
USB3_TYPC_TX2P_RE: C4770.2 U9.23
USB3_TYPC_TX3N_C: CN2021.B3 R11207.2 RP5.3 U4509.7
USB3_TYPC_TX3N_C_RE: C4779.2 U9.10
USB3_TYPC_TX3N_R: C4762.1 R11207.1 RP5.4
USB3_TYPC_TX3N_RE: C4762.2 U9.18
USB3_TYPC_TX3P_C: CN2021.B2 R11202.2 RP5.2 U4509.4
USB3_TYPC_TX3P_C_RE: C4778.2 U9.11
USB3_TYPC_TX3P_R: C4763.1 R11202.1 RP5.1
USB3_TYPC_TX3P_RE: C4763.2 U9.17
USB_BC_ON: U22.4 U45.97
USB_CHARGE_ON: R364.1 U22.5 U45.96
USB_CLT1: U22.6 U45.31
USB_OC0#: R541.1 U22.13 U35.A9
USB_OC1#: R540.1 U20.3 U35.C9
USB_OC2#: R543.1 U35.D9 U4511.3
USB_OC3#: R542.1 R11281.1 U35.B9
USBCOMP: R178.1 U35.AB6
USBON#: U20.4 U45.99 U4511.4
USBP0+: U22.3 U35.AB10
USBP0+_C: R386.2 U22.10
USBP0+_R: CN16.3 R386.1 U24.7
USBP0-: U22.2 U35.AB9
USBP0-_C: R385.2 U22.11
USBP0-_R: CN16.2 R385.1 U24.4
USBP1+: R348.2 U35.AD7
USBP1+_R: CN13.3 R348.1 U21.7
USBP1-: R342.2 U35.AD6
USBP1-_R: CN13.2 R342.1 U21.4
USBP2+: CN2020.7 U35.AJ3
USBP2-: CN2020.8 U35.AH3
USBP3+: CN2020.11 U35.AD10
USBP3-: CN2020.12 U35.AD9
USBP4+: CN10.3 U35.AJ2
USBP4-: CN10.5 U35.AJ1
USBP5+: R4.1 U35.AF7
USBP5-: R3.1 U35.AF6
USBP6+: R2.1 U35.AH2
USBP6+_R: CN5.14 R2.2
USBP6-: R1.1 U35.AH1
USBP6-_R: CN5.13 R1.2
USBP7+: L69.1 R819.1 U35.AF9
USBP7-: L69.4 R818.1 U35.AF8
USBP8+: R11290.2 R11298.2 U35.AG2
USBP8+_PI3: R11290.1 U1006.1
USBP8+_R: CN95.2 EC52.2 R11300.1 R11302.1
USBP8+_R_COM: R11298.1 R11300.2
USBP8+_R_PI3: R11302.2 U1006.7
USBP8-: R11291.2 R11299.2 U35.AG1
USBP8-_PI3: R11291.1 U1006.2
USBP8-_R: CN95.3 EC53.2 R11301.1 R11303.1
USBP8-_R_COM: R11299.1 R11301.2
USBP8-_R_PI3: R11303.2 U1006.6
USBPWR0: C487.1 C496.2 C497.2 C502.2 CN16.1 U22.12 U24.2
USBPWR1: C450.2 C451.2 C452.2 C462.2 CN13.1 U20.1 U21.2
USBPWRD2: C4711.1 C4712.2 C4713.2 C4715.2 CN2020.1 CN2020.2 CN2020.3 CN2020.4 U4511.1
V_BLIGHT: CN5.39 CN5.40 R14.2 R15.2
V_POA_Q: C3000.2 C3002.2 Q75.3 R2855.1 R11296.2
V_POA_R: CN95.1 R2855.2
VA: PC124.2 PC128.2 PD3.1 PD8.1 PD8.2 PJ3.3 PJ3.4 PR168.1
VA1: PC13.2 PC133.1 PD8.3 PQ22.5 PR5.2
VA2: PC136.1 PQ22.1 PQ22.2 PQ22.3 PR166.1 PR210.1 PR213.1
VCORE_PHASE: PC144.2 PL4.1 PR60.1 PU8.5 PU8.13
VCORE_SENSE: PR33.2 R96.2 U35.E32
VCORE_VBST: PR231.2 PU8.3
VCORE_VCC: PC149.2 PR55.1 PU8.23 PU8.24
VCORESS_SENSE: PR38.2 R98.1 U35.E33
VDD33/18: C4597.2 C4598.2 U15.27
VGA_MBCLK: R582.2 U35.R9
VGA_MBDATA: R585.2 U35.W2
VGA_VCCSENSE: PR163.1 U3002.L4
VGA_VSSSENSE: PR162.1 U3002.L5
VGPU_EN: PR253.1 R196.1 R220.1 U35.AN8
VL: PC6219.2 PR144.1 PR146.1 PU6010.13
VMA_CLK0: R4526.1 U3002.R30 VRAM3000.J12 VRAM3004.J12
VMA_CLK0#: R4526.2 U3002.R31 VRAM3000.J11 VRAM3004.J11
VMA_CLK1: R4527.1 U3002.AB31 VRAM3001.J12 VRAM3005.J12
VMA_CLK1#: R4527.2 U3002.AC31 VRAM3001.J11 VRAM3005.J11
VMA_DQ0: U3002.L28 VRAM3000.A4
VMA_DQ1: U3002.M29 VRAM3000.A2
VMA_DQ2: U3002.L29 VRAM3000.B4
VMA_DQ3: U3002.M28 VRAM3000.B2
VMA_DQ4: U3002.N31 VRAM3000.E4
VMA_DQ5: U3002.P29 VRAM3000.E2
VMA_DQ6: U3002.R29 VRAM3000.F4
VMA_DQ7: U3002.P28 VRAM3000.F2
VMA_DQ8: U3002.J28 VRAM3004.U11
VMA_DQ9: U3002.H29 VRAM3004.U13
VMA_DQ10: U3002.J29 VRAM3004.T11
VMA_DQ11: U3002.H28 VRAM3004.T13
VMA_DQ12: U3002.G29 VRAM3004.N11
VMA_DQ13: U3002.E31 VRAM3004.N13
VMA_DQ14: U3002.E32 VRAM3004.M11
VMA_DQ15: U3002.F30 VRAM3004.M13
VMA_DQ16: U3002.C34 VRAM3000.U11
VMA_DQ17: U3002.D32 VRAM3000.U13
VMA_DQ18: U3002.B33 VRAM3000.T11
VMA_DQ19: U3002.C33 VRAM3000.T13
VMA_DQ20: U3002.F33 VRAM3000.N11
VMA_DQ21: U3002.F32 VRAM3000.N13
VMA_DQ22: U3002.H33 VRAM3000.M11
VMA_DQ23: U3002.H32 VRAM3000.M13
VMA_DQ24: U3002.P34 VRAM3004.A4
VMA_DQ25: U3002.P32 VRAM3004.A2
VMA_DQ26: U3002.P31 VRAM3004.B4
VMA_DQ27: U3002.P33 VRAM3004.B2
VMA_DQ28: U3002.L31 VRAM3004.E4
VMA_DQ29: U3002.L34 VRAM3004.E2
VMA_DQ30: U3002.L32 VRAM3004.F4
VMA_DQ31: U3002.L33 VRAM3004.F2
VMA_DQ32: U3002.AG28 VRAM3001.A4
VMA_DQ33: U3002.AF29 VRAM3001.A2
VMA_DQ34: U3002.AG29 VRAM3001.B4
VMA_DQ35: U3002.AF28 VRAM3001.B2
VMA_DQ36: U3002.AD30 VRAM3001.E4
VMA_DQ37: U3002.AD29 VRAM3001.E2
VMA_DQ38: U3002.AC29 VRAM3001.F4
VMA_DQ39: U3002.AD28 VRAM3001.F2
VMA_DQ40: U3002.AJ29 VRAM3005.U11
VMA_DQ41: U3002.AK29 VRAM3005.U13
VMA_DQ42: U3002.AJ30 VRAM3005.T11
VMA_DQ43: U3002.AK28 VRAM3005.T13
VMA_DQ44: U3002.AM29 VRAM3005.N11
VMA_DQ45: U3002.AM31 VRAM3005.N13
VMA_DQ46: U3002.AN29 VRAM3005.M11
VMA_DQ47: U3002.AM30 VRAM3005.M13
VMA_DQ48: U3002.AN31 VRAM3001.U11
VMA_DQ49: U3002.AN32 VRAM3001.U13
VMA_DQ50: U3002.AP30 VRAM3001.T11
VMA_DQ51: U3002.AP32 VRAM3001.T13
VMA_DQ52: U3002.AM33 VRAM3001.N11
VMA_DQ53: U3002.AL31 VRAM3001.N13
VMA_DQ54: U3002.AK33 VRAM3001.M11
VMA_DQ55: U3002.AK32 VRAM3001.M13
VMA_DQ56: U3002.AD34 VRAM3005.A4
VMA_DQ57: U3002.AD32 VRAM3005.A2
VMA_DQ58: U3002.AC30 VRAM3005.B4
VMA_DQ59: U3002.AD33 VRAM3005.B2
VMA_DQ60: U3002.AF31 VRAM3005.E4
VMA_DQ61: U3002.AG34 VRAM3005.E2
VMA_DQ62: U3002.AG32 VRAM3005.F4
VMA_DQ63: U3002.AG33 VRAM3005.F2
VMA_WCK01: U3002.K31 VRAM3000.D4 VRAM3004.P4
VMA_WCK01#: U3002.L30 VRAM3000.D5 VRAM3004.P5
VMA_WCK23: U3002.H34 VRAM3000.P4 VRAM3004.D4
VMA_WCK23#: U3002.J34 VRAM3000.P5 VRAM3004.D5
VMA_WCK45: U3002.AG30 VRAM3001.D4 VRAM3005.P4
VMA_WCK45#: U3002.AG31 VRAM3001.D5 VRAM3005.P5
VMA_WCK67: U3002.AJ34 VRAM3001.P4 VRAM3005.D4
VMA_WCK67#: U3002.AK34 VRAM3001.P5 VRAM3005.D5
VMB_CLK0: R11094.1 U3002.D12 VRAM3003.J12 VRAM3007.J12
VMB_CLK0#: R11094.2 U3002.E12 VRAM3003.J11 VRAM3007.J11
VMB_CLK1: R11098.1 U3002.E20 VRAM3002.J12 VRAM3006.J12
VMB_CLK1#: R11098.2 U3002.F20 VRAM3002.J11 VRAM3006.J11
VMB_DQ0: U3002.G9 VRAM3003.A4
VMB_DQ1: U3002.E9 VRAM3003.A2
VMB_DQ2: U3002.G8 VRAM3003.B4
VMB_DQ3: U3002.F9 VRAM3003.B2
VMB_DQ4: U3002.F11 VRAM3003.E4
VMB_DQ5: U3002.G11 VRAM3003.E2
VMB_DQ6: U3002.F12 VRAM3003.F4
VMB_DQ7: U3002.G12 VRAM3003.F2
VMB_DQ8: U3002.G6 VRAM3007.U11
VMB_DQ9: U3002.F5 VRAM3007.U13
VMB_DQ10: U3002.E6 VRAM3007.T11
VMB_DQ11: U3002.F6 VRAM3007.T13
VMB_DQ12: U3002.F4 VRAM3007.N11
VMB_DQ13: U3002.G4 VRAM3007.N13
VMB_DQ14: U3002.E2 VRAM3007.M11
VMB_DQ15: U3002.F3 VRAM3007.M13
VMB_DQ16: U3002.C2 VRAM3003.U11
VMB_DQ17: U3002.D4 VRAM3003.U13
VMB_DQ18: U3002.D3 VRAM3003.T11
VMB_DQ19: U3002.C1 VRAM3003.T13
VMB_DQ20: U3002.B3 VRAM3003.N11
VMB_DQ21: U3002.C4 VRAM3003.N13
VMB_DQ22: U3002.B5 VRAM3003.M11
VMB_DQ23: U3002.C5 VRAM3003.M13
VMB_DQ24: U3002.A11 VRAM3007.A4
VMB_DQ25: U3002.C11 VRAM3007.A2
VMB_DQ26: U3002.D11 VRAM3007.B4
VMB_DQ27: U3002.B11 VRAM3007.B2
VMB_DQ28: U3002.D8 VRAM3007.E4
VMB_DQ29: U3002.A8 VRAM3007.E2
VMB_DQ30: U3002.C8 VRAM3007.F4
VMB_DQ31: U3002.B8 VRAM3007.F2
VMB_DQ32: U3002.F24 VRAM3002.A4
VMB_DQ33: U3002.G23 VRAM3002.A2
VMB_DQ34: U3002.E24 VRAM3002.B4
VMB_DQ35: U3002.G24 VRAM3002.B2
VMB_DQ36: U3002.D21 VRAM3002.E4
VMB_DQ37: U3002.E21 VRAM3002.E2
VMB_DQ38: U3002.G21 VRAM3002.F4
VMB_DQ39: U3002.F21 VRAM3002.F2
VMB_DQ40: U3002.G27 VRAM3006.U11
VMB_DQ41: U3002.D27 VRAM3006.U13
VMB_DQ42: U3002.G26 VRAM3006.T11
VMB_DQ43: U3002.E27 VRAM3006.T13
VMB_DQ44: U3002.E29 VRAM3006.N11
VMB_DQ45: U3002.F29 VRAM3006.N13
VMB_DQ46: U3002.E30 VRAM3006.M11
VMB_DQ47: U3002.D30 VRAM3006.M13
VMB_DQ48: U3002.A32 VRAM3002.U11
VMB_DQ49: U3002.C31 VRAM3002.U13
VMB_DQ50: U3002.C32 VRAM3002.T11
VMB_DQ51: U3002.B32 VRAM3002.T13
VMB_DQ52: U3002.D29 VRAM3002.N11
VMB_DQ53: U3002.A29 VRAM3002.N13
VMB_DQ54: U3002.C29 VRAM3002.M11
VMB_DQ55: U3002.B29 VRAM3002.M13
VMB_DQ56: U3002.B21 VRAM3006.A4
VMB_DQ57: U3002.C23 VRAM3006.A2
VMB_DQ58: U3002.A21 VRAM3006.B4
VMB_DQ59: U3002.C21 VRAM3006.B2
VMB_DQ60: U3002.B24 VRAM3006.E4
VMB_DQ61: U3002.C24 VRAM3006.E2
VMB_DQ62: U3002.B26 VRAM3006.F4
VMB_DQ63: U3002.C26 VRAM3006.F2
VMB_WCK01: U3002.F8 VRAM3003.D4 VRAM3007.P4
VMB_WCK01#: U3002.E8 VRAM3003.D5 VRAM3007.P5
VMB_WCK23: U3002.A5 VRAM3003.P4 VRAM3007.D4
VMB_WCK23#: U3002.A6 VRAM3003.P5 VRAM3007.D5
VMB_WCK45: U3002.D24 VRAM3002.D4 VRAM3006.P4
VMB_WCK45#: U3002.D25 VRAM3002.D5 VRAM3006.P5
VMB_WCK67: U3002.B27 VRAM3002.P4 VRAM3006.D4
VMB_WCK67#: U3002.C27 VRAM3002.P5 VRAM3006.D5
VR_SVID_ALERT#_VCORE: PU1.36 R134.2 R552.2
VREF_CA_DIMM0: C1255.1 C1259.1 JDIM1.164 R10878.2 R10883.2 R10887.2 R10895.1
VREF_CA_DIMM1: C1323.1 C1327.1 JDIM2.164 R10932.2 R10934.2 R10935.2 R10938.1
VREF_VMA1_MOS: Q4500.3 R4511.2 R4513.2 R4515.2 R4517.2
VREF_VMA3_MOS: Q4501.3 R4519.2 R4521.2 R4523.2 R4525.2
VREF_VMB1_MOS: Q4509.3 R11066.2 R11067.2 R11070.2 R11085.2
VREF_VMB3_MOS: Q4510.3 R11078.2 R11079.2 R11088.2 R11097.2
VREFC_VMA1: R4510.2 R4511.1 R4528.2 VRAM3000.J14
VREFC_VMA2: R4514.2 R4515.1 R4530.2 VRAM3004.J14
VREFC_VMA3: R4518.2 R4519.1 R4532.2 VRAM3001.J14
VREFC_VMA4: R4522.2 R4523.1 R4534.2 VRAM3005.J14
VREFC_VMB1: R11070.1 R11077.2 R11105.2 VRAM3003.J14
VREFC_VMB2: R11085.1 R11091.2 R11101.2 VRAM3007.J14
VREFC_VMB3: R11097.1 R11099.2 R11100.2 VRAM3002.J14
VREFC_VMB4: R11079.1 R11093.2 R11095.2 VRAM3006.J14
VREFD_VMA1: R4512.2 R4513.1 R4529.2 VRAM3000.A10 VRAM3000.U10
VREFD_VMA2: R4516.2 R4517.1 R4531.2 VRAM3004.A10 VRAM3004.U10
VREFD_VMA3: R4520.2 R4521.1 R4533.2 VRAM3001.A10 VRAM3001.U10
VREFD_VMA4: R4524.2 R4525.1 R4535.2 VRAM3005.A10 VRAM3005.U10
VREFD_VMB1: R11067.1 R11081.2 R11103.2 VRAM3003.A10 VRAM3003.U10
VREFD_VMB2: R11066.1 R11074.2 R11102.2 VRAM3007.A10 VRAM3007.U10
VREFD_VMB3: R11076.2 R11078.1 R11104.2 VRAM3002.A10 VRAM3002.U10
VREFD_VMB4: R11082.2 R11087.2 R11088.1 VRAM3006.A10 VRAM3006.U10
VRON: R463.1 R792.2 U45.69 U50.1
VRON_R: PR28.1 PR136.1 PR196.2 R792.1 U50.4
VSA_SENSE: PR50.2 R122.2 U35.H20
VSASS_SENSE: PR52.2 R109.1 U35.H21
VSTBY_FSPI: R11118.1 R11119.1 U45.106
VSYNC: R11270.1 U13.18 U37.2
WIFI_SUSCLK: CN10.50 R714.1 U43.4
WLAN_CLKREQ#: CN10.53 Q23.4 R245.1 R253.2
WLAN_RST#: C821.2 CN10.52 R671.2 R680.2
WLAN_WAKE_R#: CN10.55 Q23.1 R242.1 R243.2
WLANPWR#: R230.1 R231.2 R710.1 R712.2 U45.35
WRST#: C491.1 D12.2 Q56.6 R368.1 U45.14
XCLK_BIASREF: R512.1 U35.E42
XDP_BPM#0: TP89.1 U35.C55
XDP_BPM#1: TP90.1 U35.D55
XDP_BPM#2: TP64.1 U35.B54
XDP_BPM#3: TP62.1 U35.C56
XDP_PRDY#: TP91.1 U35.D56
XDP_PREQ#: TP92.1 U35.D61
XDP_TCK0: R513.1 R558.2 U35.A59 U35.B61
XDP_TCK1: R537.2 U35.B56
XDP_TDI: R515.2 R796.1 U35.D59
XDP_TDI_CPU: R796.2 U35.D60
XDP_TDO: R559.2 R795.1 U35.A56
XDP_TDO_CPU: R795.2 U35.A61
XDP_TMS: R514.2 R797.1 U35.C59
XDP_TMS_CPU: R797.2 U35.C60
XTAL24_IN: C665.2 R536.1 U35.E37 Y4.3
XTAL24_OUT: C658.2 R536.2 U35.E35 Y4.1
XTAL27_IN: C4207.2 U3002.H3 Y4200.1
XTAL27_OUT: C4206.2 U3002.H2 Y4200.3
XTAL_OUTBUFF: R4210.2 R4211.2 U3002.J4
XTAL_SSIN: R4212.2 U3002.H1
N59985: R571.2 U35.N9
N62917: R158.2 U35.H66
N62945: R162.2 U35.H65
N62977: R635.2 U35.AT16
N62981: R646.2 U35.AU16
N74227: R174.2 U35.AB7
N108264: R623.2 U35.AW9
N108478: C806.1 U35.BA11
N109188: R626.2 R627.2 U35.AY9
N109300: R659.1 U35.AY13
N109332: R640.1 U35.BA13
N109356: R653.1 U35.BB13
N109380: R668.1 U35.AY12
N112417: R616.2 U35.AT1
N112429: TP63.1 U35.B7
N112433: R145.2 U35.E13
N119188: R153.1 U35.E8
N136283: CN2.2 R282.1
N136287: CN2.4 R279.1
N136291: CN2.6 R273.1
N136295: CN2.9 R268.1
N136299: CN2.11 R265.1
N136321: CN2.13 R267.1
N136329: CN2.5 R274.1
N259399: C556.1 D28.2 MR1.1 R434.1
N321886: R390.2 R395.2 U25.5
N366230: Q36.3 R673.2
N16779422: C781.1 L19.2 Q42.1 R752.1
N16779565: Q18.2 Q19.3 R148.2
N16779579: C786.1 Q42.2 R754.2
N16781100: R402.2 R415.1 R416.1
N16946782: Q5.2 R74.2
N16946786: Q31.1 R74.1
N16998366: Q27.2 R343.1 R344.2
N16998426: Q27.3 Q28.2 R345.2
N17002655: C529.2 U23.39
N17002661: C528.2 U23.37
N17002676: C530.1 U23.34
N17002678: C519.1 U23.19
N17002722: TP34.1 U23.48
N17002952: C481.1 U23.7
N17003087: D9.1 D10.1 R352.2
N17003129: C528.1 U23.35
N17003186: R388.2 U23.20
N17004316: D15.1 Q29.3
N17028021: C344.2 Q22.2 R230.2
N17046941: PJ1.3 PR6.1
N17047009: PR183.2 PU5.20
N17047028: PR184.2 PU5.19
N17047083: PJ1.5 PR8.1
N17047087: PC1.1 PL1.1 PQ1.1 PQ1.2 PQ1.3 PR169.1 PR176.2 PR186.1
N17047112: PC133.2 PC136.2 PQ22.4 PR165.1
N17047335: PC4.1 PR2.2
N17047399: PC119.2 PR173.1
N17047425: PJ1.4 PR7.1
N17047601: PC1.2 PQ1.4 PR185.1
N17067472: PC104.2 PR154.2 PR155.1 PU4.8
N17067476: PD4.1 PQ12.1 PR152.1
N17067510: PQ12.3 PR154.1
N17067514: PQ12.2 PQ13.3 PR152.2
N17067548: PC102.2 PQ14.2 PR155.2 PU4.1
N17067560: PQ9.3 PR262.1
N17067629: PQ4.3 PR137.2
N17067635: PQ10.3 PR153.2
N17192633: R337.2 U19.7
N17310717: D24.1 LED2.2 R430.2
N17310725: D27.1 LED1.1 R433.2
N17310735: D25.1 LED2.1 R431.2
N17310861: D26.1 LED1.2 R432.2
N17398787: PR167.2 PU5.5
N17410561: PC222.1 PC223.1 PC225.1 PC226.1 PL13.2 PR344.1 PR6306.1 PR6307.1
N17410571: PR280.2 PR288.1 R697.1
N17410893: PR290.2 PU14.13
N17424918: PR177.2 PU5.11
N17424920: PR178.2 PU5.12
N17424921: PR170.2 PU5.7
N17424925: PR172.2 PU5.9
N17424950: PR12.2 PR13.2 PU5.15
N17435661: PQ5.3 PR138.2
N17542339: C756.2 Q38.2 R710.2
N17642578: TP4367.1 U35.AT11
N17661815: PR171.2 PU5.8
N17738230: D31.1 R316.1
N17738233: D30.1 R317.1
N17792383: R172.1 R634.2 U35.AC63
N17792405: R176.1 R636.2 U35.AE63
N17792407: R633.2 U35.AL63
N17792421: R632.2 U35.AJ62
N17817978: LED1.3 R438.1 R440.1
N17818190: LED2.3 R437.1 R439.1
N18005998: CN14.18 R326.2
N18020348: TP17.1 U35.AM23
N18021386: TP14.1 U35.AM22
N18022283: TP12.1 U35.K32
N18022286: TP20.1 U35.AK32
N18137715: TP29.1 U35.AU11
N18832214: Q40.3 R11282.2 SW4.1 SW4.2
N18834425: C764.1 Q56.2 Q56.3 R717.2
N18834459: R717.1 R756.1 R757.1
N18849499: CN5.11 R4.2 R6.2
N18849555: CN5.10 R3.2 R5.2
N18953365: R759.1 U35.AY3
N18953425: R760.1 U35.AY71
N18954271: R761.1 U35.C64
N18954886: R762.1 U35.AR56
N18954889: TP88.1 U35.AP56
N18994895: C793.2 U35.L1
N19011701: PC231.1 PR291.1
N19018012: C794.2 R775.2 U35.U11 U35.U12
N19520551: CN20.27 D34.1 R776.1
N19736816: TP84.1 U35.AM15
N19940934: PC6213.2 PR6286.2
N19940984: PC6222.1 PR6289.2
N19941046: PR6283.1 PR6284.2 PR6297.1 PU6010.7
N19941188: PC6221.1 PR6288.2
N19941230: PC6215.1 PR6287.1
N20339214: R778.1 U35.AG4
N20915811: TP95.1 U35.AK13
N20965717: PC304.2 PR319.2
N20974305: PC244.1 PR285.1 PU16.4
N20974309: PR273.1 PR278.1
N20974321: PC240.2 PR271.1 PU16.1
N20974323: PR271.2 PR304.1 PR307.2
N20974337: PR278.2 PR302.2 PU16.6
N20974362: PR306.2 PU16.5
N21057139: PC61.2 PR37.2 PR54.1 PU2.2
N21057151: PC71.1 PR121.1 PR1247.1 PU2.6
N21057157: PC65.1 PC74.2 PR1248.2 PU2.3
N21057159: PR119.1 PR121.2 PU2.7
N21057165: PC70.2 PC81.2 PR68.1 PU2.4
N21057401: PC75.2 PR69.2 PR75.1 PU6.2
N21057413: PC80.1 PR156.1 PR1249.1 PU6.6
N21057419: PC76.1 PC78.2 PR1250.2 PU6.3
N21057421: PR133.1 PR156.2 PU6.7
N21057427: PC77.2 PC79.2 PR81.1 PU6.4
N21060883: PQ17.3 PR164.2
N21061023: PQ15.3 PQ16.2 PQ17.2 PR157.1 PR159.2
N21061031: PC109.2 PQ15.2 PR158.1 PR160.2
N21390980: CN23.10 TP108.1
N21390982: CN23.56 TP109.1
N21390990: CN23.58 TP150.1
N21401502: TP4395.1 U35.A50
N21401506: TP4394.1 U35.B50
N21401510: TP4392.1 U35.D51
N21401514: TP4393.1 U35.C51
N21466717: C1329.2 R10930.1
N21467141: C1322.1 C1338.1 JDIM2.255 R11134.1 R11174.1
N21627699: TP4389.1 U35.D41
N21627701: TP4387.1 U35.C41
N21715628: PC88.1 PR6282.2 PU11.4
N21715632: PC175.1 PU11.12
N21715634: PC98.1 PU11.10
N21715675: PC87.1 PR6291.1 PU11.5
N21715683: PC84.1 PR6285.2 PU11.3
N21716568: PC111.1 PR6292.2 PU10.4
N21716582: PC177.1 PU10.12
N21716584: PC176.1 PU10.10
N21716627: PC112.1 PR6294.1 PU10.5
N21716633: PC107.1 PR6293.2 PU10.3
N21720428: R4548.2 VRAM3000.J1
N21720740: R4552.2 VRAM3001.J13
N21720776: R4546.2 VRAM3000.J13
N21721587: R4551.2 VRAM3004.J1
N21721607: R4554.2 VRAM3001.J1
N21722041: R4557.2 VRAM3005.J1
N21722089: R4555.2 VRAM3005.J13
N21722784: R4549.2 VRAM3004.J13
N21854677: PC110.2 PR84.2 PR163.2 PR277.1
N21854679: PR85.2 PR162.2 PR279.1
N21854704: PC187.1 PQ18.2
N21854718: PC227.2 PR260.2 PR275.1
N21854764: PR112.1 PR114.2
N21854773: PC200.1 PR105.1 PR106.2 PR113.2 PR115.1
N21854780: PC253.1 PR96.1
N21854821: PC188.1 PR89.2
N21854867: PC199.2 PR118.1
N21854979: PC183.1 PR91.2
N21854999: PC182.1 PR95.1
N21855085: PQ18.3 PR105.2
N21874303: PQ6.3 PQ7.2 PQ8.2 PR140.1 PR141.2
N21874329: PQ7.3 PR139.2
N22152049: R11068.2 VRAM3003.J1
N22152301: R11075.2 VRAM3002.J13
N22152337: R11089.2 VRAM3003.J13
N22152890: R11096.2 VRAM3007.J1
N22152892: R11073.2 VRAM3002.J1
N22153055: R11071.2 VRAM3006.J1
N22153103: R11084.2 VRAM3006.J13
N22153566: R11106.2 VRAM3007.J13
N22203161: C1252.2 R10873.2
N22210005: JDIM1.162 TP154.1
N22210006: JDIM1.165 TP153.1
N22221753: C1265.1 C1267.1 JDIM1.255 R11133.1 R11170.1
N22317134: CN2019.27 D4002.1 R11107.1
N22411421: C3007.2 C3008.2 R2868.2 R2870.2
N22411423: R2868.1 U1006.9
N22411495: R2872.1 U1006.8
N22485913: TP4360.1 U44.30
N22485947: TP4361.1 U44.29
N22521878: C4200.1 Q4200.2 Q4201.3 R4201.1
N22521888: C4201.1 Q4201.2 R4203.1
N22523419: Q4001.3 R4000.2 R4002.1
N22523424: C4013.2 C4019.1 Q4000.2 R4002.2
N22570409: C798.2 R774.1 U45.66
N22570473: C801.1 D4015.2 R460.1 U45.118
N22570527: C796.1 R190.1 U45.98
N22570909: C797.1 R349.1 U45.128
N22571742: C490.2 R373.1
N22571917: C778.1 U45.12
N22607007: R11283.1 U45.2
N22668004: PQ6066.3 PR6298.2
N22678439: R11140.2 U35.AR13
N22809719: Q4300.6 R4328.1 R4329.2
N22809734: Q4300.3 R4335.1 R4336.2
N22891363: R11187.2 U13.9
N22891365: R11188.2 U13.10
N22891474: TP4376.1 U13.13
N23103876: TP4378.1 U35.AH8
N23103877: TP4377.1 U35.AH7
N23189818: TP4380.1 U35.F16
N23189822: TP4379.1 U35.E16
N23189826: TP4382.1 U35.C19
N23189830: TP4381.1 U35.D19
N23189838: TP4385.1 U35.G18
N23189842: TP4383.1 U35.F18
N23189846: TP4386.1 U35.D20
N23189850: TP4384.1 U35.C20
N23190260: TP4390.1 U35.N11
N23228913: PC214.1 PR6299.2 PU20.3
N23228944: PC180.1 PR6300.2 PU20.4
N23228948: PC210.1 PU20.12
N23229578: PQ6057.3 PQ6058.2 PR6290.1
N23263090: R11210.1 U9.30
N23457928: Q39.3 R709.2 R713.1 R715.1
N23457985: C364.2 U42.1 U42.4 U42.7 U42.10
N23458009: C368.2 Q24.2 R259.2
N23458593: R11259.1 U15.32
N23458605: R11260.2 R11261.2 U15.30
N23458824: C4603.1 TP4333.1 U15.41
N23458866: C4604.1 TP4334.1 U15.37
N23458888: TP4335.1 U15.40
N23458910: TP44.1 U15.43
N23458912: TP4336.1 U15.38
N23534575: R11269.1 U40.4
N23535764: R11272.1 U37.4
N23556733: R11273.1 U18.4
N23597462: PC11.1 PC12.1 PC16.2 PR187.1 PR191.2 PR194.2
N23597481: PC25.2 PC26.2 PC27.1 PR31.1 PR33.1 PR201.2
N23597525: PR224.1 PR235.2 PR236.2
N23597538: PC41.1 PR44.2
N23597590: PR225.1 PR226.2 PR227.2
N23597608: PC139.1 PR216.2
N23597688: PR218.1 PR242.1
N23597706: PC40.1 PR48.1
N23597754: PR193.1 PR241.2
N23597796: PC19.2 PR21.2
N23599146: PC129.1 PR195.2
N23599234: PC15.1 PR23.2
N23599240: PC16.1 PR24.2
N23599296: PC26.1 PR34.2
N23599379: PR205.1 PR243.1
N23599446: PC34.1 PR41.1
N23599474: PC135.1 PR199.2
N23599495: PC28.1 PR36.2
N23599502: PC42.2 PC44.1 PC46.2 PR50.1 PR51.1 PR217.2
N23599619: PC42.1 PR45.2
N23602015: PL4.3 PR215.2
N23602017: PL4.4 PR214.2
N23602068: PC58.1 PR60.2
N23602149: PL2.3 PR19.2 PR20.2
N23602161: PL3.3 PR189.2 PR190.2
N23602183: PL2.4 PR17.2 PR18.1
N23602227: PL3.4 PR182.2 PR188.1
N23602628: PC142.1 PR223.1
N23603098: PC143.1 PR230.1
N23603167: PR237.2 PU8.1
N23603171: PR238.2 PU8.2
N23603204: PC144.1 PR231.1
N23603280: PR229.2 PU13.2
N23603284: PR228.2 PU13.1
N23603328: PR233.2 PU7.1
N23603357: PR234.2 PU7.2
N23605624: PR239.2 PU9.1
N23605675: PL5.3 PR222.2
N23605677: PL5.4 PR221.2
N23605728: PC57.1 PR59.2
N23605743: PC145.1 PR232.1
N23607303: PR240.2 PU9.2
N24586716: PC270.1 PR98.2
N24586737: PC267.1 PR99.2
N24589983: PC218.1 PR269.2 PU21.4
N24590175: PR281.1 PU21.3
N24592825: PC290.1 PR120.2
N24592843: PC289.1 PR123.2
N24594676: PC202.1 PR251.1
N24594784: PC197.1 PR90.2
N25349288: CN95.5 R11292.1
N25349292: CN95.6 R11293.1
N25349296: CN95.7 R11294.1
N25349300: CN95.8 R11295.1
N25382293: C4819.2 Q75.2 R2854.2
N27464643: TP4309.1 U3002.N8
N27464682: TP4308.1 U3002.P7
N27464689: TP4306.1 U3002.P5
N27464696: TP4304.1 U3002.L6
N27464703: TP4302.1 U3002.M3
N215331000: JDIM2.165 TP157.1
N215331770: JDIM2.162 TP158.1
N224115173: TP4396.1 U1006.4
N224115174: TP4397.1 U1006.5
N245985901: PC55.1 PR57.2
N245991371: PC56.1 PR58.2

Pads without a net: CN2 15 16 17 18 19 20; CN5 37 38; CN6 3; CN7 4; CN8 4 5; CN10 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 58 59 60 61 62 65 67 76 77; CN12 13 14; CN14 8 10 20 21 22; CN23 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 54 67 68; CN2020 5; NOREF#2 1; NOREF#3 1; NOREF#6 1; NOREF#8 1; NOREF#10 1; NOREF#11 1; PAD8 1; PU2 5; PU4 7; PU6 5; PU7 4 19 20; PU8 4 19 20; PU9 4 19 20; PU13 4 19 20; PU15 7; PU20 5 6 7 8 9 10; PU22 7; PU6010 19; U6 1; U9 12; U13 27 28 31; U18 3 23 24; U19 2 3; U22 9; U23 14 15 16 23 24; U33 1; U35 A3 A4 A6 A7 A11 A26 A27 A29 A31 A33 A36 A38 A52 A65 A69 AB4 AB11 AB12 AB13 AC1 AC2 AC3 AD11 AD12 AF11 AF12 AF13 AH9 AH10 AH11 AH12 AK6 AK7 AK9 AK10 AK12 AK62 AL25 AL27 AL61 AN13 AN55 AP13 AP53 AT5 AT15 AU1 AU2 AU5 AU56 AW1 AW7 AW17 AW20 AW48 AW56 AW68 AW69 AW70 AW71 AY1 AY2 AY4 AY5 AY7 AY8 AY20 AY21 AY56 B2 B3 B11 B26 B27 B29 B31 B33 B36 B38 B67 B69 B70 BA3 BA4 BA7 BA8 BA9 BA68 BA70 BB2 BB3 BB4 BB5 BB7 BB9 BB68 BB69 C2 C4 C7 C8 C11 C12 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C54 C67 C68 C70 C71 D1 D3 D4 D5 D8 D12 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D54 D65 D67 D68 D71 E1 E2 E3 E61 E63 E66 E68 F6 F46 F50 F52 F60 F61 F63 F65 F66 F70 F71 G1 G2 G3 G46 G50 G65 G68 G69 G70 G71 H1 H11 H69 H70 J4 J5 J68 J71 K45 K46 M1 M2 M3 M4 N1 N2 N3 P1 P2 P3 P4 U1 U2 U3 U4 V1 V2 W7 W8 W10 W11 W12; U43 1; U44 2 5 7 10 11 12 25 26 31; U3002 A9 A26 A27 A30 AA1 AA2 AA3 AA4 AA5 AA6 AA7 AA8 AB3 AB4 AB8 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AD1 AD2 AD3 AD4 AD5 AD6 AE3 AE4 AF1 AF2 AF3 AF4 AF5 AF6 AF7 AF8 AF30 AF32 AG1 AG2 AG3 AG4 AG5 AG6 AG7 AG8 AG9 AG10 AG17 AG20 AG23 AH3 AH4 AH6 AH8 AH9 AH17 AH20 AH23 AH31 AJ1 AJ2 AJ3 AJ4 AJ5 AJ6 AJ8 AJ9 AJ11 AJ17 AJ18 AJ20 AJ21 AJ23 AJ24 AJ28 AJ31 AJ32 AJ33 AK1 AK2 AK3 AK4 AK5 AK6 AK8 AK9 AK17 AK18 AK19 AK20 AK21 AK22 AK23 AK24 AK25 AK31 AL3 AL4 AL6 AL7 AL8 AL9 AL10 AL11 AL19 AL22 AL25 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM17 AM18 AM20 AM21 AM23 AM24 AM26 AM27 AM34 AN2 AN3 AN5 AN6 AN8 AN9 AN17 AN18 AN20 AN21 AN23 AN24 AN26 AN27 AP3 AP5 AP6 AP8 AP9 AP17 AP18 AP20 AP21 AP23 AP24 AP26 AP27 B2 B6 B23 C6 C15 D6 D7 D9 D19 D20 D22 D23 D26 D28 E4 E26 E34 F26 H6 H26 H30 H31 J30 J31 J32 J33 K3 K4 M6 M30 M34 N4 P2 P3 P4 R1 R8 T8 V32 Y1 Y2 Y3; U4513 2 8; VRAM3000 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5; VRAM3001 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5; VRAM3002 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5; VRAM3003 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5; VRAM3004 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5; VRAM3005 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5; VRAM3006 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5; VRAM3007 A5 A11 A13 B11 B13 D13 E11 E13 F11 F13 M2 M4 N2 N4 P2 R2 T2 T4 U2 U4 U5

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 6003 vias
v2: diameter 0.61, hole 0.356, TOP to BOTTOM, 1332 vias
v3: diameter 0.483, hole 0.254, TOP to BOTTOM, 1157 vias
v4: diameter 0.457, hole 0.254, TOP to BOTTOM, 2 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
2.469V: length 4.1
  TOP w0.254: PU4.3 v1(52.69,107.66) PR144.2 52,106.83 52.78,106.05 PR145.1
3.3V_AUX: length 1.4
  TOP w0.127: v1(184.72,124.04) 184.66,124.1 TP4000.1
  BOTTOM w0.127: U3002.P8 v1(184.73,124.04)
3V_LDO: length 13.1
  TOP w0.203: PU6010.3 v1(54.82,38.73)
  IN1 w1.016: v1(54.82,38.73) 57.33,38.73 v1(57.87,38.2)
  IN3 w0.381: v1(54.82,38.73) 57.05,40.96 v1(57.05,42.16)
  BOTTOM w0.127: PR6296.1 59.19,38.26 v1(59.19,39.26)
  BOTTOM w0.381: PR6280.1 56.63,42.16 v1(57.05,42.16)
  BOTTOM w0.508: v1(57.87,38.2) PR6296.1
  BOTTOM w0.762: v1(54.82,38.73) 54.82,38.83 55.53,39.54 PC6098.1
3V_LR: length 14.6
  TOP w0.178: U9.9 34.15,120.6 34.22,120.67 C4774.1
  TOP w0.191: U9.25 29.52,118.2
  TOP w0.203: 28.72,118.08 29.4,118.08 29.52,118.2
  TOP w0.508: v1(26.22,120.16) 26.6,120.16 26.73,120.29 R617.2 ; v1(34.85,121.69) 34.85,120.81 C4774.1 ; R11211.1 R258.1 33.83,113.8 v1(34.21,114.18) ; v1(33.7,125) R206.1 R11212.1 R11214.1 R203.1 v1(29.65,125) ; R11213.1 R254.1 28.44,113.8 28,114.24 v1(28,115.21)
  vias: v1(28.64,114.93)
3V_MAIN_PWGD: length 219.1
  TOP w0.508: v1(207.37,62.73) v1(206.27,62.73) 206.03,62.73 204.15,60.85 204.15,59.46 202.11,57.42 191.06,57.42 189.54,58.94 189.54,60.39 v1(189.06,60.88)
  IN2 w0.508: v1(179.76,105.31) 179.76,101.62 178.75,100.6 178.75,93.64 180.28,92.11 180.28,84.31 176.69,80.72 176.69,75.25 177.25,74.69 177.25,66.89 178.87,65.27 178.87,63.77 179.65,63 184.22,63 184.84,62.38 187.61,62.38 189.06,60.93 v1(189.06,60.88)
  IN3 w0.508: v1(204.5,171.75) 206.93,169.32 206.93,161.58 210.75,157.75 220.4,157.75 223.78,154.38 224.52,154.38 227.26,151.63 227.26,142.16 226.54,141.43 226.54,123.52 228.82,121.23 228.82,120.05 227.78,119.01 227.78,114.21 225.23,111.65 225.23,110.13 223.51,108.41 220.97,108.41 220.2,107.64 217.3,107.64 217.2,107.74 212.68,107.74 209.86,104.92 199.32,104.92 198.56,105.68 196.78,105.68 194.94,107.52 189.86,107.52 188.02,109.37 186.49,109.37 183.9,106.77 183.9,105.63 182.84,104.57 180.5,104.57 179.76,105.3 v1(179.76,105.31)
  BOTTOM w0.508: Q4200.3 179.06,108.28 R4200.1 R4202.2 v1(179.76,105.31) ; PR321.2 204.2,172.37 204.2,172 204.45,171.75 v1(204.5,171.75) ; v1(207.37,62.73) 206.99,63.11 PR345.1
+1.2VSUS: length 220.7
  TOP w0.254: v1(155.89,92.48) 155.51,92.48 R679.1
  TOP w0.305: v1(153.98,83.59) 152.71,83.59 143.82,74.7
  TOP w0.508: v1(145.4,53.36) 144.55,53.36 C1247.1 144.46,52.09 143.82,51.45 142.42,51.45
  IN1 w0.508: v3(126.72,104.5) 126.74,104.49 126.74,102.09 128.27,100.55 v1(128.27,100.26)
  IN1 w1.016: v2(75.82,60.9) 73.39,60.9 71.89,59.41 70.01,59.41 68.92,58.31 58.51,58.31 58.03,58.8 52.74,58.8 50.68,60.85 45.09,60.85 43.95,59.71 43.95,59.48 v2(44.05,59.38)
  IN2 w0.254: v1(153.98,83.59) 155.12,84.73 155.12,91.71 v1(155.89,92.48)
  BOTTOM w0.132: U35.BB23 127.97,101.25 128.01,101.2 128.01,100.51 v1(128.27,100.26) ; U35.BB41 118.03,99.63 v1(118.03,99.63)
  BOTTOM w0.178: U35.BB51 111.91,100.44 v1(111.88,100.41) ; U35.BB32 123,101.48 123,99.61 123.16,99.45 v1(123.16,99.22) ; v1(114.25,100.26) 114.37,100.39 U35.BB47
  BOTTOM w0.203: U35.AU42 v3(116.7,103.9) ; v1(113.72,47.58) 114.16,47.58 114.72,48.14 JDIM1.129
  BOTTOM w0.254: v1(100.41,65.69) 101.22,64.88 JDIM2.75 ; v1(113.82,41.86) 113.8,41.86 113.47,42.19 JDIM1.124 ; JDIM2.96 106.47,54.12 106.36,54 v1(106.36,53.98) ; v1(111.31,41.8) 110.67,41.8 110.47,42 JDIM1.112 ; JDIM2.153 122.72,64.6 122.39,64.94 v1(122,64.94) ; v1(85.29,53.98) 85.47,54.16 JDIM2.12 ; v1(139.5,41.8) 139.47,41.83 JDIM1.220 139.47,44.4 v1(139.6,44.52) ; JDIM2.148 121.47,54.42 121.9,53.99 v1(122.23,53.99) ; JDIM1.135 116.22,52.43 115.91,52.75 v1(115.91,52.8) ; JDIM1.96 106.47,42.1 v1(106.25,41.88) ; v1(129.98,54.1) 129.29,54.1 128.97,54.42 JDIM2.178 ; JDIM2.220 139.47,56.59 139.6,56.71 v1(139.6,56.72) ; JDIM1.159 124.22,52.38 123.75,52.86 v1(123.6,52.86) ; JDIM2.124 113.47,56.46 113.42,56.51 113.42,57.07 113.78,57.43 v1(113.99,57.43) ; JDIM2.123 113.22,65.27 113.54,65.58 v1(114,65.58) ; v1(115.69,65.59) 115.95,65.59 116.31,65.23 116.31,64.75 116.22,64.67 JDIM2.135 ; JDIM1.141 117.72,49.86 118.29,49.3 v1(119.18,49.3) ; JDIM2.118 111.97,56.43 111.92,56.48 111.92,57.11 112.25,57.43 v1(112.47,57.43) ; JDIM1.123 113.22,49.79 113.54,49.47 113.72,49.47 v1(113.72,49.48) ; v1(145.4,53.36) 145.09,53.36 144.72,52.99 JDIM1.241 ; v1(123.62,65.05) 123.78,65.05 124.22,64.61 JDIM2.159 ; v1(111.08,57.43) 110.81,57.43 110.47,57.1 JDIM2.112 ; v1(109.83,52.73) 110.22,52.34 JDIM1.111 ; v1(111.41,52.76) 111.72,52.44 JDIM1.117 ; v1(125.39,45.33) 124.47,44.41 JDIM1.160 ; JDIM1.147 121.22,52.61 121.58,52.97 v1(122.21,52.97) 122.48,52.97 122.72,52.73 JDIM1.153 ; JDIM2.54 95.97,54.37 95.68,54.08 v1(95.46,54.08) ; JDIM2.130 114.97,54.12 114.85,53.99 v1(114.28,53.99) ; JDIM2.33 90.72,64.92 90.75,64.94 v1(90.75,64.97) ; JDIM2.142 117.97,56.65 v1(117.83,56.8) ; v1(100.64,52.98) 101.22,52.39 JDIM1.75 ; JDIM2.111 110.22,64.66 109.96,64.93 109.96,65.34 109.68,65.61 v1(109.37,65.61) ; v1(118.04,65.49) 117.72,65.17 JDIM2.141 ; v1(122.97,44.5) JDIM1.154 ; JDIM1.136 116.47,42.12 v1(116.16,41.8) ; v1(91.26,52.8) 91.04,52.8 90.72,52.49 JDIM1.33 ; JDIM2.163 125.22,64.65 124.05,65.82 v1(123.62,65.82) ; JDIM1.12 v1(85.47,41.8) ; v1(132.92,53.34) 133.6,53.34 134.22,52.72 JDIM1.199 ; JDIM2.154 122.97,54.24 v1(123.6,53.62) 124.03,53.62 125.22,52.42 JDIM1.163 ; v1(125.39,57.66) 125.13,57.66 124.79,57.32 124.79,56.9 124.47,56.58 JDIM2.160 ; JDIM1.130 v1(114.97,41.92) ; JDIM2.241 144.72,65.13 v1(145.34,65.75) ; v1(122,65.68) 121.53,65.68 121.22,65.37 JDIM2.147 ; v1(121.47,41.78) JDIM1.148 ; v1(114,64.91) 114.52,64.91 114.72,64.71 JDIM2.129 ; JDIM2.136 116.47,54.42 116.92,53.97 v1(117.66,53.97) ; JDIM2.117 111.72,64.88 111.5,65.11 v1(111.12,65.11) ; v1(112.45,41.78) 111.97,42.25 JDIM1.118 ; v1(128.96,41.8) 128.97,41.81 JDIM1.178 ; v1(95.94,41.8) 95.97,41.84 JDIM1.54 95.97,44.82 v1(95.43,45.36) ; JDIM1.142 v1(117.97,41.92) ; JDIM2.199 134.22,65.17 133.86,65.54 v1(132.9,65.54)
  BOTTOM w0.305: v3(120.39,103.88) 120.77,104.2 U35.AU35 ; U35.AU28 v3(123.98,104.53) ; U35.AU23 v3(126.72,104.5)
  BOTTOM w0.508: Q35.2 93.43,103.55 92.89,103.02 92.89,101.47 v1(94.11,100.25) ; v1(127.13,65.52) 127.12,65.52 126.93,65.71 C1314.1 ; EC49.1 v1(100.13,40.02) ; EC45.1 135.18,39.89 v1(135.18,39.26) ; C1254.1 v1(106.25,41.04) ; C1244.1 129.85,41.67 v1(129.85,41.8) ; EC46.1 v1(116.16,39.9) ; C1325.1 121.95,68.22 v1(122,68.17) ; C1271.1 v1(85.47,41.04) ; C1260.1 v1(134.41,41.8) ; EC48.1 v1(106.25,40.02) ; C1261.1 v1(100.13,41.04) ; C1336.1 117.79,67.46 118.04,67.71 v1(118.04,68.09) ; C1253.1 v1(121.46,41.13) ; EC38.1 v1(122,67.08) ; C1273.1 v1(116.16,40.91) ; EC50.1 v1(86.16,41.04) ; C1335.1 v1(132.9,66.19) ; C1309.1 v1(145.34,66.39) ; EC36.1 129.72,66.43 v1(129.85,66.3) ; C1256.1 v1(110.42,40.91) ; EC39.1 v1(118.04,66.31) ; EC37.1 v1(123.62,67.19) ; EC47.1 v1(110.42,39.9) ; C325.1 125.53,92.48 125.81,92.2 v1(126.78,92.2) ; v1(130.58,39.26) 130.58,39.87 EC44.1
  vias: v1(77.91,56.99) v1(106.97,43.23) v2(68.18,65.88) v2(68.18,60.17) v2(69.12,66.24) v2(70.97,60.4) v2(75.77,64.92) v2(75.8,63.65) v2(75.85,62.45) v2(76.64,64.92) v2(76.64,63.65) v2(76.64,62.5) v2(77.48,63.62) v2(77.45,62.35)
