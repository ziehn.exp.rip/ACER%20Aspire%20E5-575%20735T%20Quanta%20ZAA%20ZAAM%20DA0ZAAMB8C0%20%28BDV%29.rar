# Allegro board ACER Aspire E5-575 735T Quanta ZAA ZAAM DA0ZAAMB8C0 (BDV).brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
VRAM3004  gkb@gddr5  [BGA170-HYNIX-H5GQ1H24MJR]  194.53 161.42 270 top
VRAM3005  gkb@gddr5  [BGA170-HYNIX-H5GQ1H24MJR]  174.49 161.39 270 bottom
VRAM3006  gka@gddr5  [BGA170-HYNIX-H5GQ1H24MJR]  213 142.56 180 bottom
VRAM3007  gka@gddr5  [BGA170-HYNIX-H5GQ1H24MJR]  212.98 122.44 180 top
Y1  25mhz  [XTL-3_2X2_5-2_2X1_7]  45.9 73.81 90 top
Y2  32.768khz  [XTL-3_2X1_5-2_5-0_8H]  141.15 94.89 270 bottom
Y4  24mhz  [XTL-3_2X2_5-2_2X1_7-4P]  113.21 131.21 0 bottom
Y4200  ev@27mhz_10  [XTL-3_2X2_5-2_2X1_7]  192.97 111.91 180 top

## Library data of the parts
BT1 = BAT-AP-AAA-BAT-054-K01-2P-SMT
C2 C4 C8-C10 C12 C13 C16 C27 C33-C35 C41 C114 C136 C148 C151 C155 C157 C158 C161 C164 C165 C168-C170 C172-C174 C176 C179 C185-C187 C191 C192 C194 C205 C216-C218 C221 C223 C225 C227 C229 C230 C232 C238 C241 C242 C244 C247 C250 C252 C254 C256-C259 C261 C263 C265 C268 C270 C279-C281 C283 C284 C286 C288 C290-C292 C300 C301 C304 C305 C314-C339 C341 C343-C346 C348-C357 C360-C365 C367-C371 C373 C374 C376-C383 C386 C387 C389 C394 C398 C405-C408 C411 C413 C424 C425 C428 C431 C435-C437 C450 C451 C453 C454 C456 C458-C462 C469 C475-C477 C481-C485 C488-C502 C504 C505 C507-C511 C513 C514 C517-C520 C522 C524-C530 C532 C534-C538 C541 C545-C556 C577 C578 C580 C581 C628 C641-C643 C647-C649 C651-C658 C660-C665 C667-C669 C672-C680 C682 C683 C686-C689 C695 C698 C700 C701 C708-C714 C716 C718-C721 C723 C724 C726 C728 C730-C733 C735 C739 C742-C744 C747-C766 C768 C770-C772 C774 C775 C777 C778 C780 C781 C783 C785-C788 C790 C793 C794 C796-C808 C811-C819 C821-C824 C1164 C1166-C1169 C1176 C1177 C1244 C1245 C1249 C1251-C1254 C1256 C1258-C1261 C1266 C1267 C1271 C1273 C1275 C1276 C1309-C1311 C1314 C1315 C1317-C1320 C1323 C1325 C1326 C1329 C1332 C1333 C1335-C1338 C3000 C3002 C3007 C3008 C3224-C3227 C4008-C4041 C4100-C4110 C4112-C4118 C4200-C4203 C4205-C4207 C4209-C4211 C4400-C4423 C4426 C4430-C4434 C4512-C4522 C4524-C4536 C4538-C4541 C4543-C4546 C4548-C4555 C4596-C4609 C4611-C4618 C4664-C4673 C4675-C4688 C4690-C4700 C4702-C4705 C4707-C4709 C4713-C4715 C4719 C4723 C4726 C4733-C4737 C4748-C4754 C4762-C4764 C4767 C4768 C4770 C4771 C4773 C4774 C4776-C4815 C4817-C4819 D2-D6 D24-D27 D4012 D4013 D4015 EC35-EC50 PC1 PC3 PC6-PC12 PC14-PC46 PC55-PC58 PC79 PC81 PC83-PC85 PC87-PC92 PC98 PC100 PC101 PC103 PC106-PC114 PC123 PC125 PC129-PC135 PC137 PC139 PC159-PC161 PC171 PC175-PC178 PC180 PC184 PC185 PC187 PC189 PC191 PC193 PC195 PC196 PC199 PC200 PC203 PC206 PC209 PC210 PC212 PC214 PC215 PC217 PC218 PC221 PC226 PC227 PC229 PC230 PC235 PC240 PC241 PC246 PC247 PC250 PC252 PC269 PC271 PC272 PC274 PC283 PC285-PC287 PC291-PC293 PC300 PC301 PC303 PC304 PC6100 PC6214 PC6218 PC6228 = C0402
C7 C29 C30 C144 C150 C182 C190 C199 C248 C645 C650 C659 C666 C690 C696 C697 C699 C702 C4732 PC47 PC49 PC52 PC54 PC86 PC99 PC118 PC120 PC127 PC148 PC152 PC155 PC157 PC164-PC170 PC172 PC181 PC190 PC192 PC194 PC205 PC211 PC213 PC216 PC219 PC220 PC228 PC238 PC254 PC277 PC6216 PC6220 = C0805
C171 C178 C202 C203 C219 C224 C226 C233 C236 C243 C251 C255 C272-C277 C282 C289 C302 C303 C307 C310 C340 C347 C366 C412 C438 C515 C516 C523 C691-C694 C703-C707 C737 C767 C776 C1163 C1165 C1246-C1248 C1250 C1255 C1257 C1262-C1265 C1268 C1270 C1272 C1308 C1312 C1313 C1316 C1321 C1322 C1324 C1327 C1328 C1330 C1331 C1334 C3001 C4000-C4007 C4111 C4119 C4204 C4208 C4424 C4425 C4427-C4429 C4537 C4542 C4547 C4647-C4650 C4674 C4689 C4706 C4721 C4765 C4766 C4769 C4775 C4816 D23 D28 D34 D4002 PC2 PC4 PC5 PC13 PC48 PC50 PC51 PC53 PC61 PC65 PC70 PC71 PC74-PC78 PC80 PC97 PC102 PC104 PC105 PC115-PC117 PC119 PC121 PC122 PC124 PC126 PC128 PC136 PC140-PC147 PC149-PC151 PC153 PC154 PC156 PC173 PC174 PC179 PC182 PC183 PC188 PC197 PC198 PC202 PC207 PC208 PC222 PC223 PC225 PC231-PC234 PC236 PC237 PC239 PC242-PC245 PC248 PC249 PC251 PC253 PC267 PC268 PC270 PC273 PC275 PC276 PC278-PC282 PC288-PC290 PC302 PC6098 PC6213 PC6215 PC6219 PC6221 PC6222 PC6225 PC6226 PC6230 PC6231 = C0603
C181 C184 C188 C189 C193 C195-C198 C200 C201 C204 C206 C207 C209 C212 C214 C215 C222 C228 C235 C237 C239 C240 C245 C246 C249 C260 C262 C264 C266 C267 C269 C278 C285 C297-C299 C308 C311-C313 C681 C684 C685 = C0201
C452 C487 C4711 C4712 = C1206
C457 C740 C1162 C4772 = C3528
C746 = CC1808
C4435 C4523 C4701 PC59 PC158 PC162 PC163 PC186 PC201 = CC7343
CN2 = 88511-180N-18P-L
CN4 = SDCARD-PSDAT4-11GLBS1NN4H4-11P
CN5 = GS12401-1011-40P-R-NH-SMT
CN6 = 50591-00401-001-4P-L
CN7 = DSUB-95-0005-01-15P
CN8 = HS8803F-3P-L
CN9 = SATA-C185Q2-11311-L-13P-R
CN10 = NGFF-NASE0-S6701-TS48-KE-SMT
CN11 = RJ45-JM361C-HP34AA03-9H-8P
CN12 = HDMI-10444-19001-19P
CN13 CN16 = UB3-YUSB0021-P001A-9P-SMT
CN14 = SATA-C166FQ-12208-L-22P-R
CN17 = 50503-0080N-001-8P-L
CN18 = 50271-0040N-V01-4P-L
CN20 CN2019 = 196153-28021-3-28P-L
CN23 = NGFF-NASM0-S6701-TS50-KM-SMT
CN95 = 196241-08021-3-8P-L
CN2020 = 51619-0260N-001-26P-L
CN2021 = UB31-DX07B024XJ1AR1000-24P-SMT
D1 D8-D11 D14-D18 D20 D30 D31 D35 D4001 D4014 PD1 PD2 PD4 = DSM
D7 = SOT323_213-2_1-1_3-2N7002W
D12 = DSMV
D4000 PQ6 PQ11 PQ13 Q4 Q19 Q27 Q35 Q4002 Q4200 Q4202 = UMT_213-3-1_3
EC51-EC53 = ESD-1X0_6-2P
HOLE1-HOLE4 = HG-C354D134P2
HOLE6 = O-ZAB-2
HOLE7 = HG-TC354IC236BC236D118P2
HOLE8 = H-C236I156D140P2
HOLE9 = H-C236D140P2
HOLE10-HOLE12 = H-TC236IC236BC256D161P2
HOLE13-HOLE15 = H-C256D161P2
HOLE16 = H-TC217IC197BC197D126P2
HOLE17 HOLE18 = HG-ZAB-2
HOLE19 = H-ZAB-5
HOLE20 = H-C87D87N
HOLE21 = H-O146X87D146X87N
HOLE22 = O-ZAA-1
HOLE23 HOLE24 = HG-C315D134P2
HOLE25 = H-C217D217N
J1 = JOPEN25X30_S
JDIM1 = DDR4-D4AS0-26001-1P52-STD-SMT
JDIM2 = DDR4-D4AR0-26001-1P52-RVS-SMT
L4-L7 L13 L18 L4208 L4209 PR2 PR17 PR19 PR20 PR57-PR60 PR88-PR91 PR95 PR96 PR98 PR99 PR111 PR118 PR120 PR123 PR140-PR142 PR147 PR148 PR150-PR152 PR155 PR157 PR159 PR161 PR182-PR184 PR186 PR189 PR190 PR204 PR214 PR215 PR221 PR222 PR251 PR312 PR319 PR6286-PR6289 PR6295 PR6296 R16 R19 R210 R212 R271 R272 R278 R289 R291 R345 R361 R565 R683 R747 R752 R779 R789 R10878 R10932 R11126 R11127 = R0603
L11 L12 L22 L4100 L4200 L4201 L4206 L4207 PR1 PR3 PR4 PR6-PR11 PR13-PR16 PR18 PR21-PR24 PR31 PR34-PR36 PR39-PR41 PR44 PR45 PR48 PR49 PR51 PR53 PR54 PR73 PR75 PR84-PR86 PR92 PR93 PR97 PR100-PR108 PR112-PR116 PR119 PR121 PR133 PR135 PR144-PR146 PR156 PR158 PR165 PR166 PR168 PR174 PR179 PR180 PR187 PR188 PR192-PR203 PR205-PR211 PR216-PR220 PR224-PR227 PR233-PR236 PR241-PR243 PR250 PR253 PR258-PR262 PR265 PR266 PR268-PR271 PR275 PR276 PR278 PR289 PR293 PR295 PR296 PR302 PR304 PR309 PR310 PR314 PR318 PR340-PR342 PR344 PR6120-PR6122 PR6124 PR6279-PR6281 PR6284 PR6290 PR6297 PR6301-PR6303 R3-R10 R12 R13 R38 R52 R53 R58 R65 R74 R85 R89 R96 R98 R103 R109 R110 R113 R115 R122 R127 R130 R131 R134 R138 R145 R148 R152-R156 R158 R160-R162 R165-R167 R169 R172 R174 R176-R178 R190 R195 R196 R199 R203-R209 R211 R213-R220 R222 R223 R227 R228 R230 R231 R234 R239 R241-R245 R249 R250 R253-R260 R265 R267 R268 R270 R273-R277 R279-R283 R290 R299-R301 R303 R304 R308 R312 R314-R317 R319 R322 R326 R333 R334 R343 R344 R349 R351 R352 R354 R356 R359 R360 R364-R366 R368-R370 R372-R378 R380 R382 R383 R389 R390 R393-R395 R397 R399-R401 R407 R409 R410 R415-R418 R420-R424 R426-R433 R435 R436 R439-R441 R443 R444 R447-R450 R457 R460 R463 R465 R478 R485 R488 R512-R515 R529-R534 R536 R537 R540-R544 R546 R548 R552-R555 R558 R559 R561-R564 R568-R570 R572-R578 R580 R582 R585-R593 R595 R598-R601 R605-R621 R623-R636 R639 R642-R646 R648-R651 R654 R660 R667 R671 R678-R682 R684-R687 R691 R692 R694 R695 R697-R699 R702-R710 R712-R717 R719 R720 R722 R729-R741 R744 R746 R751 R753 R754 R756 R757 R761 R762 R764-R767 R774-R778 R781 R783-R786 R788 R957 R961 R968 R2854 R2868 R4000-R4002 R4004-R4009 R4011 R4012 R4100 R4102 R4103 R4105 R4114-R4119 R4200-R4212 R4300-R4326 R4329-R4332 R4334 R4336-R4346 R4510-R4535 R4538 R4541-R4543 R4546-R4557 R6308 R10871-R10873 R10875 R10877 R10879-R10892 R10894-R10896 R10921-R10931 R10933-R10943 R11047 R11064-R11107 R11114 R11118 R11119 R11170 R11174 R11179-R11182 R11187-R11190 R11193-R11195 R11197 R11198 R11200 R11201 R11203-R11206 R11208-R11214 R11251 R11260-R11264 R11268 R11269 R11271-R11278 R11282 R11284-R11287 R11289-R11303 = R0402
L16 PR137-PR139 PR153 PR164 PR6298 R237 R247 R248 R251 R262 R269 R672 R673 R4003 R11265 = R0805
L19 PR55 PR56 PR61 PR62 PR143 PR154 PR173 PR185 PR223 PR230-PR232 PR285 PR291 PR294 PR6125 PR6130 R11 R112 R135 R179 R180 R182 R185-R188 R192 R193 R198 R240 R252 R318 R338 R367 R388 R404 R406 R414 R419 R434 R550 R725 R745 R4010 R11131 R11257 = S0603
L69 RP2-RP5 = CHOKE-DLP11SN900HL2L-4P-1
LED1 LED2 = LEDLTST-S326KGJRKT-3P-SMT
MR1 = SOT23_123-2_8-1_9
PAD1 = SPAD-ZAB-1NP
PAD2 = SPAD-ZAB-2NP
PAD3 = SPAD-RE157X488NP
PAD4 = SPAD-RE157X1282NP
PAD5 = SPAD-ZAB-3NP
PAD6 PAD8 = SPAD-C298NP
PAD7 = SPAD-RE157X491NP
PAD9 = SPAD-C276NP
PAD10 = SPAD-RE157X1267NP
PAD11 = SPAD-RE531X205NP
PAD12 = SPAD-RE157X315NP
PAD13 = SPAD-C197NP
PAD14 = O-ZAB-1
PC138 PC204 PC224 PC284 PC328 PC6212 PC6224 PC6227 PC6229 = ECAP6_3X6_1-7_2
PD3 = D-DO-214AC
PD8 = D-TO277_213-6_1X4_3
PJ1 = 50458-00801-V02-8P-L
PJ3 = 50320-0040N-001-4P-L
PL1 PL11 PL13-PL15 PL18 PL6012 PL6013 = CHOKE-PCMC063T-3R3MN-SMT
PL2-PL5 = CHOKE-PCMC063T-R82MN-4P-SMT
PL9 PL10 = CHOKE-ETQP4LR36WFC-SMT
PL17 = L3_2X2_5-1_55
PQ1 PQ22 PQ27 PQ30 PQ33 PQ34 PQ41-PQ44 = SO-8FL-5P-OA
PQ3-PQ5 PQ7-PQ10 PQ12 PQ14-PQ19 PQ23 PQ40 PQ6057 PQ6058 PQ6065 PQ6066 Q1 Q5 Q15 Q17 Q18 Q20-Q22 Q24-Q26 Q28-Q31 Q36 Q38-Q42 Q59 Q75 Q4000 Q4001 Q4201 Q4203 Q4500 Q4501 Q4509 Q4510 Q6059 Q6060 = SOT23_213-3_3-2
PQ20 PQ21 PQ24-PQ26 PQ6053 PQ6054 = WDFN5-3_05X3_05-65
PQ6056 = POWER-5X6-1_27-7P
PR5 = R1206
PR12 PR25-PR30 PR32 PR33 PR37 PR38 PR42 PR43 PR46 PR47 PR50 PR52 PR68 PR69 PR81-PR83 PR87 PR94 PR109 PR110 PR117 PR122 PR136 PR160 PR162 PR163 PR167 PR170-PR172 PR175-PR178 PR181 PR191 PR228 PR229 PR237-PR240 PR252 PR254-PR257 PR263 PR264 PR267 PR273 PR274 PR277 PR279-PR281 PR286-PR288 PR290 PR292 PR306 PR307 PR311 PR317 PR321 PR345 PR6278 PR6282 PR6283 PR6285 PR6291-PR6294 PR6299 PR6300 R1 R2 R37 R66 R67 R102 R119 R164 R171 R175 R194 R224 R229 R235 R329 R336 R337 R340-R342 R348 R350 R353 R355 R371 R381 R384-R387 R392 R402 R403 R405 R408 R411 R412 R425 R437 R438 R442 R556 R560 R571 R602 R640 R647 R652 R653 R655 R659 R661 R668 R670 R676 R677 R688 R690 R693 R696 R718 R721 R742 R743 R749 R750 R759 R760 R782 R790-R792 R795-R797 R816-R821 R956 R958-R960 R2855 R2870 R2872 R4328 R4335 R10842-R10848 R11061 R11062 R11108 R11110-R11113 R11129 R11133 R11134 R11136-R11141 R11153 R11185 R11186 R11196 R11199 R11202 R11207 R11253-R11256 R11258 R11259 R11267 R11270 R11279-R11281 R11283 = S0402
PR169 PR213 = RC3216
PR212 PR1247-PR1250 PR6306 PR6307 R14 R15 R28 R221 R246 R339 R657 R948 R951 R11266 = S0805
PR6304 = SHORT3720
PU1 = QFN40-5X5-4-41P-ISL62771-SMT
PU2 PU6 = SOP8-6-1_27-9P
PU4 U12 = SOIC8-6-1_27
PU5 = QFN28-4X4-4-38P
PU7-PU9 PU13 = POWER-3_5X5-5-14P
PU10 PU11 PU20 = SON14-3X2-4-15P
PU14 = QFN13-2X3-5
PU15 PU22 = QFN23-4X4-5-25P
PU16 Q34 = TSOP6-2_8-95
PU18 = DFN10-3X3-5-11P-RT9296
PU19 = QFN20-3X3-4-21P-0_8H
PU21 = WQFN20-3X3-4-21P
PU6010 = QFN20-3X3-4-26P
Q2 Q3 Q23 Q32 Q37 Q43 Q56 Q4300-Q4302 = SC70-2_1-65-6P
Q6062 = POWER-3_3X3_3-65-5P-SMT
RP1 = 10P8R
SW1 SW2 = SW-TME-532-V-6P
SW4 = SW-DS-A40E-4P
TP12 TP14 TP17 TP20 TP22 TP34 TP44 TP62 TP64 TP65 TP75 TP77 TP89-TP94 TP153 TP154 TP157 TP158 TP4000 TP4104-TP4107 TP4300-TP4309 TP4333-TP4336 TP4362 TP4363 TP4366 TP4376-TP4387 TP4389 TP4390 TP4392-TP4397 = TP2650
TP19 TP23 TP29-TP31 TP63 TP74 TP76 TP84 TP88 TP95 TP108 TP109 TP143 TP144 TP150 TP4344 TP4354-TP4361 TP4367-TP4369 TP4372 TP4373 = TP2675
U1 = SOT23-2_8-95-6P
U6 U33 U43 = SOT353-1-2_125-65-5P
U8 U14 U37 U40 U47-U50 U4001 U4002 = SSOP5-P-A-TOSHIBA-B
U9 = TQFN32-3X6-4-41P-0_8H
U13 = QFN32-4X4-4-33P-0_9H
U15 U23 = QFN48-6X6-4-49P-ALC280
U16 U17 U4512 = MIC-KMM40301026-11DN-8P
U18 = QFN32-5X5-5-37P-0_85H
U19 = LGA16-3X3-5
U20 U25 U4511 = SOT23-5
U21 U24 = ESD10-4_1X2-8-11P
U22 = QFN16-3X3-5-22P-TPS2544RTER
U28 = QFN20-4X3-5-27P
U35 = BGA1356-INTEL-SKYLAKE-U
U36 U38 = SLP10-2_5X1-5-10P
U41 = SOIC8-8-1_27
U42 = TRF-N1010G-25P
U44 = QFN32-5X5-5-33P-0_85H
U45 = LQFP128-16X16-4-1_6H
U1006 = TQFN10-1_6X1_3-4-SMT
U3002 = BGA908-NVIDIA-N13P-GS-A1
U4509 U4513 = ESD-3_8X1-9P
VRAM3000-VRAM3007 = BGA170-HYNIX-H5GQ1H24MJR
Y1 Y4200 = XTL-3_2X2_5-2_2X1_7
Y2 = XTL-3_2X1_5-2_5-0_8H
Y4 = XTL-3_2X2_5-2_2X1_7-4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
10P8R
  rect 0.305x1.092 smd: 1(-1.27,-0.85) 2(-0.635,-0.85) 3(0,-0.85) 4(0.635,-0.85) 5(1.27,-0.85) 6(1.27,0.85) 7(0.635,0.85) 8(0,0.85) 9(-0.635,0.85) 10(-1.27,0.85)
50271-0040N-V01-4P-L
  rect 0.787x1.6 smd: 1(-1.875,2.9) 2(-0.625,2.9) 3(0.625,2.9) 4(1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
50320-0040N-001-4P-L
  round 1.295 hole 0.889: 1(-3.75,2.9) 2(-1.25,2.9) 3(1.25,2.9) 4(3.75,2.9)
50458-00801-V02-8P-L
  rect 0.559x1.295 smd: 1(-7,5.025) 2(-5,5.025) 3(-3,5.025) 4(-1,5.025) 5(1,5.025) 6(3,5.025) 7(5,5.025) 8(7,5.025)
  rect 1.295x2.057 smd: 9(-10.1,0) 10(10.1,0)
50503-0080N-001-8P-L
  rect 0.508x1.295 smd: 1(-3.5,1.4) 2(-2.5,1.4) 3(-1.5,1.4) 4(-0.5,1.4) 5(0.5,1.4) 6(1.5,1.4) 7(2.5,1.4) 8(3.5,1.4)
  rect 1.803x1.397 smd: 9(-5.65,-1.4) 10(5.65,-1.4)
50591-00401-001-4P-L
  rect 0.61x1.092 smd: 1(-1.5,2.15) 2(-0.5,2.15) 3(0.5,2.15) 4(1.5,2.15)
  rect 2.21x3.2 smd: 5(-4,0) 6(4,0)
51619-0260N-001-26P-L
  rect 0.305x1.295 smd: 1(-6.25,2.8) 2(-5.75,2.8) 3(-5.25,2.8) 4(-4.75,2.8) 5(-4.25,2.8) 6(-3.75,2.8) 7(-3.25,2.8) 8(-2.75,2.8) 9(-2.25,2.8) 10(-1.75,2.8) 11(-1.25,2.8) 12(-0.75,2.8) 13(-0.25,2.8) 14(0.25,2.8) 15(0.75,2.8) 16(1.25,2.8) 17(1.75,2.8) 18(2.25,2.8) 19(2.75,2.8) 20(3.25,2.8) 21(3.75,2.8) 22(4.25,2.8) 23(4.75,2.8) 24(5.25,2.8) 25(5.75,2.8) 26(6.25,2.8)
  rect 1.803x1.397 smd: 27(-7.9,0) 28(7.9,0)
88511-180N-18P-L
  rect 0.305x1.295 smd: 1(-4.25,2.8) 2(-3.75,2.8) 3(-3.25,2.8) 4(-2.75,2.8) 5(-2.25,2.8) 6(-1.75,2.8) 7(-1.25,2.8) 8(-0.75,2.8) 9(-0.25,2.8) 10(0.25,2.8) 11(0.75,2.8) 12(1.25,2.8) 13(1.75,2.8) 14(2.25,2.8) 15(2.75,2.8) 16(3.25,2.8) 17(3.75,2.8) 18(4.25,2.8)
  rect 1.803x1.397 smd: 19(-5.9,0) 20(5.9,0)
196153-28021-3-28P-L
  rect 0.61x1.092 smd: 1(-13.5,2.05) 2(-12.5,2.05) 3(-11.5,2.05) 4(-10.5,2.05) 5(-9.5,2.05) 6(-8.5,2.05) 7(-7.5,2.05) 8(-6.5,2.05) 9(-5.5,2.05) 10(-4.5,2.05) 11(-3.5,2.05) 12(-2.5,2.05) 13(-1.5,2.05) 14(-0.5,2.05) 15(0.5,2.05) 16(1.5,2.05) 17(2.5,2.05) 18(3.5,2.05) 19(4.5,2.05) 20(5.5,2.05) 21(6.5,2.05) 22(7.5,2.05) 23(8.5,2.05) 24(9.5,2.05) 25(10.5,2.05) 26(11.5,2.05) 27(12.5,2.05) 28(13.5,2.05)
  rect 2.159x2.997 smd: 29(-15.975,0) 30(15.975,0)
196241-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-1.75,2.7) 2(-1.25,2.7) 3(-0.75,2.7) 4(-0.25,2.7) 5(0.25,2.7) 6(0.75,2.7) 7(1.25,2.7) 8(1.75,2.7)
  rect 1.854x1.397 smd: 9(-3.425,0) 10(3.425,0)
BAT-AP-AAA-BAT-054-K01-2P-SMT
  round 1.397 hole 1.397 unplated: (0,8)
  round 0.991 hole 0.991 unplated: (0,-8)
  rect 3.505x3.988 smd: 1(15.25,0) 2(-16.35,0)
BGA170-HYNIX-H5GQ1H24MJR
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
BGA908-NVIDIA-N13P-GS-A1
  round 0.381 smd: A2(-13.7,-12.9) A3(-13.7,-12.1) A5(-13.7,-10.4) A6(-13.7,-9.6) A8(-13.7,-7.9) A9(-13.7,-7.1) A11(-13.7,-5.4) A12(-13.7,-4.6) A14(-13.7,-2.9) A15(-13.7,-2.1) A17(-13.7,-0.4) A18(-13.7,0.4) A20(-13.7,2.1) A21(-13.7,2.9) A23(-13.7,4.6) A24(-13.7,5.4) A26(-13.7,7.1) A27(-13.7,7.9) A29(-13.7,9.6) A30(-13.7,10.4) A32(-13.7,12.1) A33(-13.7,12.9) AA1(2.9,-13.7) AA2(2.9,-12.9) AA3(2.9,-12.1) AA4(2.9,-11.3) AA5(2.9,-10.5) AA6(2.9,-9.65) AA7(2.9,-8.8) AA8(2.9,-8) AA27(2.9,8) AA28(2.9,8.8) AA29(2.9,9.65) AA30(2.9,10.5) AA31(2.9,11.3) AA32(2.9,12.1) AA33(2.9,12.9) AA34(2.9,13.7) AB2(3.75,-12.9) AB3(3.75,-12.1) AB4(3.75,-11.3) AB5(3.75,-10.5) AB7(3.75,-8.8) AB8(3.75,-8) AB27(3.75,8) AB28(3.75,8.8) AB30(3.75,10.5) AB31(3.75,11.3) AB32(3.75,12.1) AB33(3.75,12.9) AC1(4.6,-13.7) AC2(4.6,-12.9) AC3(4.6,-12.1) AC4(4.6,-11.3) AC5(4.6,-10.5) AC6(4.6,-9.65) AC7(4.6,-8.8) AC8(4.6,-8) AC27(4.6,8) AC28(4.6,8.8) AC29(4.6,9.65) AC30(4.6,10.5) AC31(4.6,11.3) AC32(4.6,12.1) AC33(4.6,12.9) AC34(4.6,13.7) AD1(5.4,-13.7) AD2(5.4,-12.9) AD3(5.4,-12.1) AD4(5.4,-11.3) AD5(5.4,-10.5) AD6(5.4,-9.65) AD7(5.4,-8.8) AD8(5.4,-8) AD27(5.4,8) AD28(5.4,8.8) AD29(5.4,9.65) AD30(5.4,10.5) AD31(5.4,11.3) AD32(5.4,12.1) AD33(5.4,12.9) AD34(5.4,13.7) AE2(6.25,-12.9) AE3(6.25,-12.1) AE4(6.25,-11.3) AE5(6.25,-10.5) AE7(6.25,-8.8) AE8(6.25,-8) AE27(6.25,8) AE28(6.25,8.8) AE30(6.25,10.5) AE31(6.25,11.3) AE32(6.25,12.1) AE33(6.25,12.9) AF1(7.1,-13.7) AF2(7.1,-12.9) AF3(7.1,-12.1) AF4(7.1,-11.3) AF5(7.1,-10.5) AF6(7.1,-9.65) AF7(7.1,-8.8) AF8(7.1,-8) AF27(7.1,8) AF28(7.1,8.8) AF29(7.1,9.65) AF30(7.1,10.5) AF31(7.1,11.3) AF32(7.1,12.1) AF33(7.1,12.9) AF34(7.1,13.7) AG1(7.9,-13.7) AG2(7.9,-12.9) AG3(7.9,-12.1) AG4(7.9,-11.3) AG5(7.9,-10.5) AG6(7.9,-9.65) AG7(7.9,-8.8) AG8(8,-8) AG9(8,-7.1) AG10(8,-6.25) AG11(8,-5.4) AG12(8,-4.6) AG13(8,-3.75) AG14(8,-2.9) AG15(8,-2.1) AG16(8,-1.25) AG17(8,-0.4) AG18(8,0.4) AG19(8,1.25) AG20(8,2.1) AG21(8,2.9) AG22(8,3.75) AG23(8,4.6) AG24(8,5.4) AG25(8,6.25) AG26(8,7.1) AG27(8,8) AG28(7.9,8.8) AG29(7.9,9.65) AG30(7.9,10.5) AG31(7.9,11.3) AG32(7.9,12.1) AG33(7.9,12.9) AG34(7.9,13.7) AH2(8.75,-12.9) AH3(8.75,-12.1) AH4(8.75,-11.3) AH5(8.75,-10.5) AH6(8.75,-9.65) AH7(8.8,-8.8) AH8(8.8,-7.9) AH9(8.8,-7.1) AH10(8.8,-6.25) AH11(8.8,-5.4) AH12(8.8,-4.6) AH13(8.8,-3.75) AH14(8.8,-2.9) AH15(8.8,-2.1) AH16(8.8,-1.25) AH17(8.8,-0.4) AH18(8.8,0.4) AH19(8.8,1.25) AH20(8.8,2.1) AH21(8.8,2.9) AH22(8.8,3.75) AH23(8.8,4.6) AH24(8.8,5.4) AH25(8.8,6.25) AH26(8.8,7.1) AH27(8.8,7.9) AH28(8.8,8.8) AH29(8.75,9.65) AH30(8.75,10.5) AH31(8.75,11.3) AH32(8.75,12.1) AH33(8.75,12.9) AJ1(9.6,-13.7) AJ2(9.6,-12.9) AJ3(9.6,-12.1) AJ4(9.6,-11.3) AJ5(9.6,-10.5) AJ6(9.65,-9.65) AJ7(9.65,-8.75) AJ8(9.65,-7.9) AJ9(9.65,-7.1) AJ11(9.65,-5.4) AJ12(9.65,-4.6) AJ14(9.65,-2.9) AJ15(9.65,-2.1) AJ17(9.65,-0.4) AJ18(9.65,0.4) AJ20(9.65,2.1) AJ21(9.65,2.9) AJ23(9.65,4.6) AJ24(9.65,5.4) AJ26(9.65,7.1) AJ27(9.65,7.9) AJ28(9.65,8.75) AJ29(9.65,9.65) AJ30(9.6,10.5) AJ31(9.6,11.3) AJ32(9.6,12.1) AJ33(9.6,12.9) AJ34(9.6,13.7) AK1(10.4,-13.7) AK2(10.4,-12.9) AK3(10.4,-12.1) AK4(10.4,-11.3) AK5(10.5,-10.5) AK6(10.5,-9.6) AK7(10.5,-8.75) AK8(10.5,-7.9) AK9(10.5,-7.1) AK10(10.5,-6.25) AK11(10.5,-5.4) AK12(10.5,-4.6) AK13(10.5,-3.75) AK14(10.5,-2.9) AK15(10.5,-2.1) AK16(10.5,-1.25) AK17(10.5,-0.4) AK18(10.5,0.4) AK19(10.5,1.25) AK20(10.5,2.1) AK21(10.5,2.9) AK22(10.5,3.75) AK23(10.5,4.6) AK24(10.5,5.4) AK25(10.5,6.25) AK26(10.5,7.1) AK27(10.5,7.9) AK28(10.5,8.75) AK29(10.5,9.6) AK30(10.5,10.5) AK31(10.4,11.3) AK32(10.4,12.1) AK33(10.4,12.9) AK34(10.4,13.7) AL2(11.25,-12.9) AL3(11.25,-12.1) AL4(11.3,-11.3) AL5(11.3,-10.4) AL6(11.3,-9.6) AL7(11.3,-8.75) AL8(11.3,-7.9) AL9(11.3,-7.1) AL10(11.3,-6.25) AL11(11.3,-5.4) AL12(11.3,-4.6) AL13(11.3,-3.75) AL14(11.3,-2.9) AL15(11.3,-2.1) AL16(11.3,-1.25) AL17(11.3,-0.4) AL18(11.3,0.4) AL19(11.3,1.25) AL20(11.3,2.1) AL21(11.3,2.9) AL22(11.3,3.75) AL23(11.3,4.6) AL24(11.3,5.4) AL25(11.3,6.25) AL26(11.3,7.1) AL27(11.3,7.9) AL28(11.3,8.75) AL29(11.3,9.6) AL30(11.3,10.4) AL31(11.3,11.3) AL32(11.25,12.1) AL33(11.25,12.9) AM1(12.1,-13.7) AM2(12.1,-12.9) AM3(12.1,-12.1) AM4(12.1,-11.25) AM5(12.1,-10.4) AM6(12.1,-9.6) AM7(12.1,-8.75) AM8(12.1,-7.9) AM9(12.1,-7.1) AM10(12.1,-6.25) AM11(12.1,-5.4) AM12(12.1,-4.6) AM13(12.1,-3.75) AM14(12.1,-2.9) AM15(12.1,-2.1) AM16(12.1,-1.25) AM17(12.1,-0.4) AM18(12.1,0.4) AM19(12.1,1.25) AM20(12.1,2.1) AM21(12.1,2.9) AM22(12.1,3.75) AM23(12.1,4.6) AM24(12.1,5.4) AM25(12.1,6.25) AM26(12.1,7.1) AM27(12.1,7.9) AM28(12.1,8.75) AM29(12.1,9.6) AM30(12.1,10.4) AM31(12.1,11.25) AM32(12.1,12.1) AM33(12.1,12.9) AM34(12.1,13.7) AN1(12.9,-13.7) AN2(12.9,-12.9) AN3(12.9,-12.1) AN4(12.9,-11.25) AN5(12.9,-10.4) AN6(12.9,-9.6) AN7(12.9,-8.75) AN8(12.9,-7.9) AN9(12.9,-7.1) AN10(12.9,-6.25) AN11(12.9,-5.4) AN12(12.9,-4.6) AN13(12.9,-3.75) AN14(12.9,-2.9) AN15(12.9,-2.1) AN16(12.9,-1.25) AN17(12.9,-0.4) AN18(12.9,0.4) AN19(12.9,1.25) AN20(12.9,2.1) AN21(12.9,2.9) AN22(12.9,3.75) AN23(12.9,4.6) AN24(12.9,5.4) AN25(12.9,6.25) AN26(12.9,7.1) AN27(12.9,7.9) AN28(12.9,8.75) AN29(12.9,9.6) AN30(12.9,10.4) AN31(12.9,11.25) AN32(12.9,12.1) AN33(12.9,12.9) AN34(12.9,13.7) AP2(13.7,-12.9) AP3(13.7,-12.1) AP5(13.7,-10.4) AP6(13.7,-9.6) AP8(13.7,-7.9) AP9(13.7,-7.1) AP11(13.7,-5.4) AP12(13.7,-4.6) AP14(13.7,-2.9) AP15(13.7,-2.1) AP17(13.7,-0.4) AP18(13.7,0.4) AP20(13.7,2.1) AP21(13.7,2.9) AP23(13.7,4.6) AP24(13.7,5.4) AP26(13.7,7.1) AP27(13.7,7.9) AP29(13.7,9.6) AP30(13.7,10.4) AP32(13.7,12.1) AP33(13.7,12.9) B1(-12.9,-13.7) B2(-12.9,-12.9) B3(-12.9,-12.1) B4(-12.9,-11.25) B5(-12.9,-10.4) B6(-12.9,-9.6) B7(-12.9,-8.75) B8(-12.9,-7.9) B9(-12.9,-7.1) B10(-12.9,-6.25) B11(-12.9,-5.4) B12(-12.9,-4.6) B13(-12.9,-3.75) B14(-12.9,-2.9) B15(-12.9,-2.1) B16(-12.9,-1.25) B17(-12.9,-0.4) B18(-12.9,0.4) B19(-12.9,1.25) B20(-12.9,2.1) B21(-12.9,2.9) B22(-12.9,3.75) B23(-12.9,4.6) B24(-12.9,5.4) B25(-12.9,6.25) B26(-12.9,7.1) B27(-12.9,7.9) B28(-12.9,8.75) B29(-12.9,9.6) B30(-12.9,10.4) B31(-12.9,11.25) B32(-12.9,12.1) B33(-12.9,12.9) B34(-12.9,13.7) C1(-12.1,-13.7) C2(-12.1,-12.9) C3(-12.1,-12.1) C4(-12.1,-11.25) C5(-12.1,-10.4) C6(-12.1,-9.6) C7(-12.1,-8.75) C8(-12.1,-7.9) C9(-12.1,-7.1) C10(-12.1,-6.25) C11(-12.1,-5.4) C12(-12.1,-4.6) C13(-12.1,-3.75) C14(-12.1,-2.9) C15(-12.1,-2.1) C16(-12.1,-1.25) C17(-12.1,-0.4) C18(-12.1,0.4) C19(-12.1,1.25) C20(-12.1,2.1) C21(-12.1,2.9) C22(-12.1,3.75) C23(-12.1,4.6) C24(-12.1,5.4) C25(-12.1,6.25) C26(-12.1,7.1) C27(-12.1,7.9) C28(-12.1,8.75) C29(-12.1,9.6) C30(-12.1,10.4) C31(-12.1,11.25) C32(-12.1,12.1) C33(-12.1,12.9) C34(-12.1,13.7) D2(-11.25,-12.9) D3(-11.25,-12.1) D4(-11.3,-11.3) D5(-11.3,-10.4) D6(-11.3,-9.6) D7(-11.3,-8.75) D8(-11.3,-7.9) D9(-11.3,-7.1) D10(-11.3,-6.25) D11(-11.3,-5.4) D12(-11.3,-4.6) D13(-11.3,-3.75) D14(-11.3,-2.9) D15(-11.3,-2.1) D16(-11.3,-1.25) D17(-11.3,-0.4) D18(-11.3,0.4) D19(-11.3,1.25) D20(-11.3,2.1) D21(-11.3,2.9) D22(-11.3,3.75) D23(-11.3,4.6) D24(-11.3,5.4) D25(-11.3,6.25) D26(-11.3,7.1) D27(-11.3,7.9) D28(-11.3,8.75) D29(-11.3,9.6) D30(-11.3,10.4) D31(-11.3,11.3) D32(-11.25,12.1) D33(-11.25,12.9) E1(-10.4,-13.7) E2(-10.4,-12.9) E3(-10.4,-12.1) E4(-10.4,-11.3) E5(-10.5,-10.5) E6(-10.5,-9.6) E7(-10.5,-8.75) E8(-10.5,-7.9) E9(-10.5,-7.1) E10(-10.5,-6.25) E11(-10.5,-5.4) E12(-10.5,-4.6) E13(-10.5,-3.75) E14(-10.5,-2.9) E15(-10.5,-2.1) E16(-10.5,-1.25) E17(-10.5,-0.4) E18(-10.5,0.4) E19(-10.5,1.25) E20(-10.5,2.1) E21(-10.5,2.9) E22(-10.5,3.75) E23(-10.5,4.6) E24(-10.5,5.4) E25(-10.5,6.25) E26(-10.5,7.1) E27(-10.5,7.9) E28(-10.5,8.75) E29(-10.5,9.6) E30(-10.5,10.5) E31(-10.4,11.3) E32(-10.4,12.1) E33(-10.4,12.9) E34(-10.4,13.7) F1(-9.6,-13.7) F2(-9.6,-12.9) F3(-9.6,-12.1) F4(-9.6,-11.3) F5(-9.6,-10.5) F6(-9.65,-9.65) F7(-9.65,-8.75) F8(-9.65,-7.9) F9(-9.65,-7.1) F11(-9.65,-5.4) F12(-9.65,-4.6) F14(-9.65,-2.9) F15(-9.65,-2.1) F17(-9.65,-0.4) F18(-9.65,0.4) F20(-9.65,2.1) F21(-9.65,2.9) F23(-9.65,4.6) F24(-9.65,5.4) F26(-9.65,7.1) F27(-9.65,7.9) F28(-9.65,8.75) F29(-9.65,9.65) F30(-9.6,10.5) F31(-9.6,11.3) F32(-9.6,12.1) F33(-9.6,12.9) F34(-9.6,13.7) G2(-8.75,-12.9) G3(-8.75,-12.1) G4(-8.75,-11.3) G5(-8.75,-10.5) G6(-8.75,-9.65) G7(-8.8,-8.8) G8(-8.8,-7.9) G9(-8.8,-7.1) G10(-8.8,-6.25) G11(-8.8,-5.4) G12(-8.8,-4.6) G13(-8.8,-3.75) G14(-8.8,-2.9) G15(-8.8,-2.1) G16(-8.8,-1.25) G17(-8.8,-0.4) G18(-8.8,0.4) G19(-8.8,1.25) G20(-8.8,2.1) G21(-8.8,2.9) G22(-8.8,3.75) G23(-8.8,4.6) G24(-8.8,5.4) G25(-8.8,6.25) G26(-8.8,7.1) G27(-8.8,7.9) G28(-8.8,8.8) G29(-8.75,9.65) G30(-8.75,10.5) G31(-8.75,11.3) G32(-8.75,12.1) G33(-8.75,12.9) H1(-7.9,-13.7) H2(-7.9,-12.9) H3(-7.9,-12.1) H4(-7.9,-11.3) H5(-7.9,-10.5) H6(-7.9,-9.65) H7(-7.9,-8.8) H8(-8,-8) H9(-8,-7.1) H10(-8,-6.25) H11(-8,-5.4) H12(-8,-4.6) H13(-8,-3.75) H14(-8,-2.9) H15(-8,-2.1) H16(-8,-1.25) H17(-8,-0.4) H18(-8,0.4) H19(-8,1.25) H20(-8,2.1) H21(-8,2.9) H22(-8,3.75) H23(-8,4.6) H24(-8,5.4) H25(-8,6.25) H26(-8,7.1) H27(-8,8) H28(-7.9,8.8) H29(-7.9,9.65) H30(-7.9,10.5) H31(-7.9,11.3) H32(-7.9,12.1) H33(-7.9,12.9) H34(-7.9,13.7) J1(-7.1,-13.7) J2(-7.1,-12.9) J3(-7.1,-12.1) J4(-7.1,-11.3) J5(-7.1,-10.5) J6(-7.1,-9.65) J7(-7.1,-8.8) J8(-7.1,-8) J27(-7.1,8) J28(-7.1,8.8) J29(-7.1,9.65) J30(-7.1,10.5) J31(-7.1,11.3) J32(-7.1,12.1) J33(-7.1,12.9) J34(-7.1,13.7) K2(-6.25,-12.9) K3(-6.25,-12.1) K4(-6.25,-11.3) K5(-6.25,-10.5) K7(-6.25,-8.8) K8(-6.25,-8) K27(-6.25,8) K28(-6.25,8.8) K30(-6.25,10.5) K31(-6.25,11.3) K32(-6.25,12.1) K33(-6.25,12.9) L1(-5.4,-13.7) L2(-5.4,-12.9) L3(-5.4,-12.1) L4(-5.4,-11.3) L5(-5.4,-10.5) L6(-5.4,-9.65) L7(-5.4,-8.8) L8(-5.4,-8) L27(-5.4,8) L28(-5.4,8.8) L29(-5.4,9.65) L30(-5.4,10.5) L31(-5.4,11.3) L32(-5.4,12.1) L33(-5.4,12.9) L34(-5.4,13.7) M1(-4.6,-13.7) M2(-4.6,-12.9) M3(-4.6,-12.1) M4(-4.6,-11.3) M5(-4.6,-10.5) M6(-4.6,-9.65) M7(-4.6,-8.8) M8(-4.6,-8) M27(-4.6,8) M28(-4.6,8.8) M29(-4.6,9.65) M30(-4.6,10.5) M31(-4.6,11.3) M32(-4.6,12.1) M33(-4.6,12.9) M34(-4.6,13.7) N2(-3.75,-12.9) N3(-3.75,-12.1) N4(-3.75,-11.3) N5(-3.75,-10.5) N7(-3.75,-8.8) N8(-3.75,-8) N27(-3.75,8) N28(-3.75,8.8) N30(-3.75,10.5) N31(-3.75,11.3) N32(-3.75,12.1) N33(-3.75,12.9) P1(-2.9,-13.7) P2(-2.9,-12.9) P3(-2.9,-12.1) P4(-2.9,-11.3) P5(-2.9,-10.5) P6(-2.9,-9.65) P7(-2.9,-8.8) P8(-2.9,-8) P27(-2.9,8) P28(-2.9,8.8) P29(-2.9,9.65) P30(-2.9,10.5) P31(-2.9,11.3) P32(-2.9,12.1) P33(-2.9,12.9) P34(-2.9,13.7) R1(-2.1,-13.7) R2(-2.1,-12.9) R3(-2.1,-12.1) R4(-2.1,-11.3) R5(-2.1,-10.5) R6(-2.1,-9.65) R7(-2.1,-8.8) R8(-2.1,-8) R27(-2.1,8) R28(-2.1,8.8) R29(-2.1,9.65) R30(-2.1,10.5) R31(-2.1,11.3) R32(-2.1,12.1) R33(-2.1,12.9) R34(-2.1,13.7) T2(-1.25,-12.9) T3(-1.25,-12.1) T4(-1.25,-11.3) T5(-1.25,-10.5) T7(-1.25,-8.8) T8(-1.25,-8) T27(-1.25,8) T28(-1.25,8.8) T30(-1.25,10.5) T31(-1.25,11.3) T32(-1.25,12.1) T33(-1.25,12.9) U1(-0.4,-13.7) U2(-0.4,-12.9) U3(-0.4,-12.1) U4(-0.4,-11.3) U5(-0.4,-10.5) U6(-0.4,-9.65) U7(-0.4,-8.8) U8(-0.4,-8) U27(-0.4,8) U28(-0.4,8.8) U29(-0.4,9.65) U30(-0.4,10.5) U31(-0.4,11.3) U32(-0.4,12.1) U33(-0.4,12.9) U34(-0.4,13.7) V1(0.4,-13.7) V2(0.4,-12.9) V3(0.4,-12.1) V4(0.4,-11.3) V5(0.4,-10.5) V6(0.4,-9.65) V7(0.4,-8.8) V8(0.4,-8) V27(0.4,8) V28(0.4,8.8) V29(0.4,9.65) V30(0.4,10.5) V31(0.4,11.3) V32(0.4,12.1) V33(0.4,12.9) V34(0.4,13.7) W2(1.25,-12.9) W3(1.25,-12.1) W4(1.25,-11.3) W5(1.25,-10.5) W7(1.25,-8.8) W8(1.25,-8) W27(1.25,8) W28(1.25,8.8) W30(1.25,10.5) W31(1.25,11.3) W32(1.25,12.1) W33(1.25,12.9) Y1(2.1,-13.7) Y2(2.1,-12.9) Y3(2.1,-12.1) Y4(2.1,-11.3) Y5(2.1,-10.5) Y6(2.1,-9.65) Y7(2.1,-8.8) Y8(2.1,-8) Y27(2.1,8) Y28(2.1,8.8) Y29(2.1,9.65) Y30(2.1,10.5) Y31(2.1,11.3) Y32(2.1,12.1) Y33(2.1,12.9) Y34(2.1,13.7)
  round 0.4 smd: AA12(3.5,-5.5) AA13(3.5,-4.5) AA14(3.5,-3.5) AA15(3.5,-2.5) AA16(3.5,-1.5) AA17(3.5,-0.5) AA18(3.5,0.5) AA19(3.5,1.5) AA20(3.5,2.5) AA21(3.5,3.5) AA22(3.5,4.5) AA23(3.5,5.5) AB12(4.5,-5.5) AB13(4.5,-4.5) AB14(4.5,-3.5) AB15(4.5,-2.5) AB16(4.5,-1.5) AB17(4.5,-0.5) AB18(4.5,0.5) AB19(4.5,1.5) AB20(4.5,2.5) AB21(4.5,3.5) AB22(4.5,4.5) AB23(4.5,5.5) AC12(5.5,-5.5) AC13(5.5,-4.5) AC14(5.5,-3.5) AC15(5.5,-2.5) AC16(5.5,-1.5) AC17(5.5,-0.5) AC18(5.5,0.5) AC19(5.5,1.5) AC20(5.5,2.5) AC21(5.5,3.5) AC22(5.5,4.5) AC23(5.5,5.5) M12(-5.5,-5.5) M13(-5.5,-4.5) M14(-5.5,-3.5) M15(-5.5,-2.5) M16(-5.5,-1.5) M17(-5.5,-0.5) M18(-5.5,0.5) M19(-5.5,1.5) M20(-5.5,2.5) M21(-5.5,3.5) M22(-5.5,4.5) M23(-5.5,5.5) N12(-4.5,-5.5) N13(-4.5,-4.5) N14(-4.5,-3.5) N15(-4.5,-2.5) N16(-4.5,-1.5) N17(-4.5,-0.5) N18(-4.5,0.5) N19(-4.5,1.5) N20(-4.5,2.5) N21(-4.5,3.5) N22(-4.5,4.5) N23(-4.5,5.5) P12(-3.5,-5.5) P13(-3.5,-4.5) P14(-3.5,-3.5) P15(-3.5,-2.5) P16(-3.5,-1.5) P17(-3.5,-0.5) P18(-3.5,0.5) P19(-3.5,1.5) P20(-3.5,2.5) P21(-3.5,3.5) P22(-3.5,4.5) P23(-3.5,5.5) R12(-2.5,-5.5) R13(-2.5,-4.5) R14(-2.5,-3.5) R15(-2.5,-2.5) R16(-2.5,-1.5) R17(-2.5,-0.5) R18(-2.5,0.5) R19(-2.5,1.5) R20(-2.5,2.5) R21(-2.5,3.5) R22(-2.5,4.5) R23(-2.5,5.5) T12(-1.5,-5.5) T13(-1.5,-4.5) T14(-1.5,-3.5) T15(-1.5,-2.5) T16(-1.5,-1.5) T17(-1.5,-0.5) T18(-1.5,0.5) T19(-1.5,1.5) T20(-1.5,2.5) T21(-1.5,3.5) T22(-1.5,4.5) T23(-1.5,5.5) U12(-0.5,-5.5) U13(-0.5,-4.5) U14(-0.5,-3.5) U15(-0.5,-2.5) U16(-0.5,-1.5) U17(-0.5,-0.5) U18(-0.5,0.5) U19(-0.5,1.5) U20(-0.5,2.5) U21(-0.5,3.5) U22(-0.5,4.5) U23(-0.5,5.5) V12(0.5,-5.5) V13(0.5,-4.5) V14(0.5,-3.5) V15(0.5,-2.5) V16(0.5,-1.5) V17(0.5,-0.5) V18(0.5,0.5) V19(0.5,1.5) V20(0.5,2.5) V21(0.5,3.5) V22(0.5,4.5) V23(0.5,5.5) W12(1.5,-5.5) W13(1.5,-4.5) W14(1.5,-3.5) W15(1.5,-2.5) W16(1.5,-1.5) W17(1.5,-0.5) W18(1.5,0.5) W19(1.5,1.5) W20(1.5,2.5) W21(1.5,3.5) W22(1.5,4.5) W23(1.5,5.5) Y12(2.5,-5.5) Y13(2.5,-4.5) Y14(2.5,-3.5) Y15(2.5,-2.5) Y16(2.5,-1.5) Y17(2.5,-0.5) Y18(2.5,0.5) Y19(2.5,1.5) Y20(2.5,2.5) Y21(2.5,3.5) Y22(2.5,4.5) Y23(2.5,5.5)
BGA1356-INTEL-SKYLAKE-U
  round 0.356 smd: A3(-11.314,-19.349) A70(-11.314,19.852) B2(-10.832,-19.832) B71(-10.852,20.314) BA1(10.852,-20.314) BA71(10.852,20.314) BB2(11.314,-19.852) BB70(11.314,19.852) C1(-10.349,-20.314)
  round 0.33 smd: A4(-11.314,-18.699) A69(-11.314,19.202) AY1(10.202,-20.314) AY71(10.202,20.314) B3(-10.679,-19.197) B70(-10.685,19.685) BA2(10.685,-19.685) BA70(10.685,19.685) BB3(11.314,-19.202) BB69(11.314,19.202) C2(-10.197,-19.679) C71(-10.202,20.314) D1(-9.699,-20.314)
  round 0.305 smd: A5(-11.314,-18.048) A68(-11.314,18.552) AA2(-0.511,-19.339) AA4(-0.511,-18.363) AA63(-0.596,15.112) AA64(-0.596,15.763) AA65(-0.596,16.413) AA66(-0.596,17.063) AA67(-0.596,17.713) AA68(-0.596,18.364) AA69(-0.596,19.014) AA70(-0.596,19.664) AA71(-0.596,20.314) AB4(0.152,-18.363) AB6(-0.133,-17.585) AB7(-0.133,-16.935) AB8(-0.133,-16.285) AB9(-0.133,-15.635) AB10(-0.133,-14.984) AB11(-0.133,-14.334) AB12(-0.133,-13.684) AB13(-0.133,-13.034) AB15(-0.009,-12.188) AB16(-0.009,-11.538) AB17(-0.009,-10.888) AB18(-0.009,-10.237) AB19(-0.009,-9.587) AB20(-0.009,-8.937) AB21(-0.009,-8.287) AB62(-0.138,14.644) AC3(0.815,-18.689) AC63(0.319,15.112) AC64(0.319,15.763) AC65(0.319,16.413) AC66(0.319,17.063) AC67(0.319,17.713) AC68(0.319,18.364) AC69(0.319,19.014) AC70(0.319,19.664) AC71(0.319,20.314) AD4(1.478,-18.363) AD6(0.934,-17.585) AD7(0.934,-16.935) AD8(0.934,-16.285) AD9(0.934,-15.635) AD10(0.934,-14.984) AD11(0.934,-14.334) AD12(0.934,-13.684) AD13(0.934,-13.034) AD15(0.829,-12.188) AD16(0.829,-11.538) AD17(0.829,-10.888) AD18(0.829,-10.237) AD19(0.829,-9.587) AD20(0.829,-8.937) AD21(0.829,-8.287) AD62(0.776,14.644) AE62(1.69,14.644) AE63(1.233,15.112) AE64(1.233,15.763) AE65(1.233,16.413) AE66(1.233,17.063) AE67(1.233,17.713) AE68(1.233,18.364) AE69(1.233,19.014) AF2(2.141,-19.339) AF4(2.141,-18.363) AF6(2.001,-17.585) AF7(2.001,-16.935) AF8(2.001,-16.285) AF9(2.001,-15.635) AF10(2.001,-14.984) AF11(2.001,-14.334) AF12(2.001,-13.684) AF13(2.001,-13.034) AF15(1.668,-12.188) AF16(1.668,-11.538) AF17(1.668,-10.888) AF18(1.668,-10.237) AF19(1.668,-9.587) AF20(1.668,-8.937) AF21(1.668,-8.287) AF63(2.148,15.112) AF64(2.148,15.763) AF65(2.148,16.413) AF66(2.148,17.063) AF67(2.148,17.713) AF68(1.939,18.364) AF69(1.939,19.014) AG4(2.804,-18.363) AG15(2.506,-12.188) AG16(2.506,-11.538) AG17(2.506,-10.888) AG18(2.506,-10.237) AG19(2.506,-9.587) AG20(2.506,-8.937) AG21(2.506,-8.287) AG62(2.605,14.644) AG69(2.602,18.689) AH3(3.467,-18.689) AH6(3.067,-17.585) AH7(3.067,-16.935) AH8(3.067,-16.285) AH9(3.067,-15.635) AH10(3.067,-14.984) AH11(3.067,-14.334) AH12(3.067,-13.684) AH13(3.067,-13.034) AH63(3.062,15.112) AH64(3.062,15.763) AH65(3.062,16.413) AH66(3.062,17.063) AH67(3.062,17.713) AJ4(4.13,-18.363) AJ15(3.344,-12.188) AJ16(3.344,-11.538) AJ17(3.344,-10.888) AJ18(3.344,-10.237) AJ19(3.344,-9.587) AJ20(3.344,-8.937) AJ21(3.344,-8.287) AJ62(3.519,14.644) AK6(4.007,-17.585) AK7(4.007,-16.935) AK8(4.007,-16.285) AK9(4.007,-15.635) AK10(4.007,-14.984) AK11(4.007,-14.334) AK12(4.007,-13.684) AK13(4.007,-13.034) AK15(4.182,-12.188) AK16(4.182,-11.538) AK17(4.182,-10.888) AK18(4.182,-10.237) AK19(4.182,-9.587) AK20(4.182,-8.937) AK21(4.182,-8.287) AK22(4.009,-7.596) AK23(4.009,-6.681) AK25(4.009,-5.767) AK27(4.009,-4.852) AK28(4.009,-3.938) AK30(4.009,-3.024) AK32(4.009,-2.109) AK33(4.009,-1.195) AK35(4.009,-0.28) AK37(4.009,0.634) AK38(4.009,1.548) AK40(4.009,2.463) AK42(4.009,3.377) AK43(4.009,4.292) AK45(4.009,5.206) AK46(4.009,6.12) AK48(4.009,7.035) AK50(4.009,7.949) AK52(4.009,8.864) AK53(4.009,9.778) AK55(4.009,10.692) AK56(4.009,11.607) AK58(4.009,12.521) AK60(4.009,13.436) AK62(4.144,14.46) AK63(3.976,15.112) AK64(3.976,15.763) AK65(3.976,16.413) AK66(3.976,17.063) AK67(3.976,17.713) AK68(3.829,18.364) AK69(3.829,19.339) AL2(4.793,-19.339) AL4(4.793,-18.363) AL23(4.474,-7.138) AL25(4.474,-6.224) AL27(4.474,-5.31) AL28(4.474,-4.395) AL30(4.474,-3.481) AL32(4.474,-2.566) AL33(4.474,-1.652) AL35(4.474,-0.738) AL37(4.474,0.177) AL38(4.474,1.091) AL40(4.474,2.006) AL42(4.474,2.92) AL43(4.474,3.834) AL45(4.474,4.749) AL46(4.474,5.663) AL48(4.474,6.578) AL50(4.474,7.492) AL52(4.474,8.406) AL53(4.474,9.321) AL55(4.474,10.235) AL56(4.474,11.15) AL58(4.474,12.064) AL60(4.474,12.978) AL61(4.474,13.893) AL63(4.845,15.112) AL64(4.845,15.763) AL65(4.845,16.413) AL66(4.845,17.063) AM4(5.456,-18.363) AM5(4.946,-17.654) AM7(4.946,-16.74) AM8(4.946,-15.825) AM10(4.946,-14.911) AM11(4.946,-13.996) AM13(4.946,-13.082) AM15(4.946,-12.168) AM16(4.946,-11.253) AM18(4.946,-10.339) AM20(4.946,-9.424) AM21(4.946,-8.51) AM22(4.946,-7.596) AM23(4.946,-6.681) AM25(4.946,-5.767) AM27(4.946,-4.852) AM28(4.946,-3.938) AM30(4.946,-3.024) AM32(4.946,-2.109) AM33(4.946,-1.195) AM35(4.946,-0.28) AM37(4.946,0.634) AM38(4.946,1.548) AM40(4.946,2.463) AM42(4.946,3.377) AM43(4.946,4.292) AM45(4.946,5.206) AM46(4.946,6.12) AM48(4.946,7.035) AM50(4.946,7.949) AM52(4.946,8.864) AM53(4.946,9.778) AM55(4.946,10.692) AM56(4.946,11.607) AM58(4.946,12.521) AM60(4.946,13.436) AM61(4.946,14.35) AM68(5.056,18.039) AM69(5.056,18.689) AN3(6.119,-18.689) AN5(5.597,-17.654) AN7(5.597,-16.74) AN8(5.597,-15.825) AN10(5.597,-14.911) AN11(5.597,-13.996) AN13(5.597,-13.082) AN15(5.597,-12.168) AN16(5.597,-11.253) AN18(5.597,-10.339) AN20(5.597,-9.424) AN21(5.597,-8.51) AN22(5.597,-7.596) AN23(5.597,-6.681) AN25(5.597,-5.767) AN27(5.597,-4.852) AN28(5.597,-3.938) AN30(5.597,-3.024) AN32(5.597,-2.109) AN33(5.597,-1.195) AN35(5.597,-0.28) AN37(5.597,0.634) AN38(5.597,1.548) AN40(5.597,2.463) AN42(5.597,3.377) AN43(5.597,4.292) AN45(5.597,5.206) AN46(5.597,6.12) AN48(5.597,7.035) AN50(5.597,7.949) AN52(5.597,8.864) AN53(5.597,9.778) AN55(5.597,10.692) AN56(5.597,11.607) AN58(5.597,12.521) AN60(5.597,13.436) AN61(5.597,14.35) AN63(5.597,15.264) AN65(5.597,16.179) AN66(5.597,17.093) AN68(5.719,18.364) AN69(5.719,19.014) AP4(6.782,-18.363) AP5(6.247,-17.654) AP7(6.247,-16.74) AP8(6.247,-15.825) AP10(6.247,-14.911) AP11(6.247,-13.996) AP13(6.247,-13.082) AP15(6.247,-12.168) AP16(6.247,-11.253) AP18(6.247,-10.339) AP20(6.247,-9.424) AP21(6.247,-8.51) AP22(6.247,-7.596) AP23(6.247,-6.681) AP25(6.247,-5.767) AP27(6.247,-4.852) AP28(6.247,-3.938) AP30(6.247,-3.024) AP32(6.247,-2.109) AP33(6.247,-1.195) AP35(6.247,-0.28) AP37(6.247,0.634) AP38(6.247,1.548) AP40(6.247,2.463) AP42(6.247,3.377) AP43(6.247,4.292) AP45(6.247,5.206) AP46(6.247,6.12) AP48(6.247,7.035) AP50(6.247,7.949) AP52(6.247,8.864) AP53(6.247,9.778) AP55(6.247,10.692) AP56(6.247,11.607) AP58(6.247,12.521) AP60(6.247,13.436) AP61(6.247,14.35) AP63(6.247,15.264) AP65(6.247,16.179) AP66(6.247,17.093) AP68(6.332,18.039) AP70(6.332,19.258) AR5(6.897,-17.654) AR7(6.897,-16.74) AR8(6.897,-15.825) AR10(6.897,-14.911) AR11(6.897,-13.996) AR13(6.897,-13.082) AR15(6.897,-12.168) AR16(6.897,-11.253) AR18(6.897,-10.339) AR20(6.897,-9.424) AR21(6.897,-8.51) AR22(6.897,-7.596) AR23(6.897,-6.681) AR25(6.897,-5.767) AR27(6.897,-4.852) AR28(6.897,-3.938) AR30(6.897,-3.024) AR32(6.897,-2.109) AR33(6.897,-1.195) AR35(6.897,-0.28) AR37(6.897,0.634) AR38(6.897,1.548) AR40(6.897,2.463) AR42(6.897,3.377) AR43(6.897,4.292) AR45(6.897,5.206) AR46(6.897,6.12) AR48(6.897,7.035) AR50(6.897,7.949) AR52(6.897,8.864) AR53(6.897,9.778) AR55(6.897,10.692) AR56(6.897,11.607) AR58(6.897,12.521) AR60(6.897,13.436) AR61(6.897,14.35) AR63(6.897,15.264) AR65(6.897,16.179) AR66(6.897,17.093) AR68(6.945,18.364) AR69(6.945,19.014) AT2(7.445,-19.339) AT4(7.445,-18.363) AT5(7.547,-17.654) AT7(7.547,-16.74) AT8(7.547,-15.825) AT10(7.547,-14.911) AT11(7.547,-13.996) AT13(7.547,-13.082) AT15(7.547,-12.168) AT16(7.547,-11.253) AT18(7.547,-10.339) AT20(7.547,-9.424) AT21(7.547,-8.51) AT22(7.547,-7.596) AT23(7.547,-6.681) AT25(7.547,-5.767) AT27(7.547,-4.852) AT28(7.547,-3.938) AT30(7.547,-3.024) AT32(7.547,-2.109) AT33(7.547,-1.195) AT35(7.547,-0.28) AT37(7.547,0.634) AT38(7.547,1.548) AT40(7.547,2.463) AT42(7.547,3.377) AT43(7.547,4.292) AT45(7.547,5.206) AT46(7.547,6.12) AT48(7.547,7.035) AT50(7.547,7.949) AT52(7.547,8.864) AT53(7.547,9.778) AT55(7.547,10.692) AT56(7.547,11.607) AT58(7.547,12.521) AT60(7.547,13.436) AT61(7.547,14.35) AT63(7.547,15.264) AT65(7.547,16.179) AT66(7.547,17.093) AT68(7.509,18.039) AT69(7.509,18.689) AU4(8.108,-18.363) AU5(8.198,-17.654) AU7(8.198,-16.74) AU8(8.198,-15.825) AU10(8.198,-14.911) AU11(8.198,-13.996) AU13(8.198,-13.082) AU15(8.198,-12.168) AU16(8.198,-11.253) AU18(8.198,-10.339) AU20(8.198,-9.424) AU21(8.198,-8.51) AU22(8.198,-7.596) AU23(8.198,-6.681) AU25(8.198,-5.767) AU27(8.198,-4.852) AU28(8.198,-3.938) AU30(8.198,-3.024) AU32(8.198,-2.109) AU33(8.198,-1.195) AU35(8.198,-0.28) AU37(8.198,0.634) AU38(8.198,1.548) AU40(8.198,2.463) AU42(8.198,3.377) AU43(8.198,4.292) AU45(8.198,5.206) AU46(8.198,6.12) AU48(8.198,7.035) AU50(8.198,7.949) AU52(8.198,8.864) AU53(8.198,9.778) AU55(8.198,10.692) AU56(8.198,11.607) AU58(8.198,12.521) AU60(8.198,13.436) AU61(8.198,14.35) AU63(8.198,15.264) AU65(8.198,16.179) AU66(8.198,17.093) AV3(8.799,-18.689) AV68(8.711,18.029) AV69(8.901,19.014) AV70(8.901,19.664) AW1(9.551,-20.314) AW5(8.911,-17.781) AW6(9.038,-17.13) AW7(9.363,-16.564) AW8(9.038,-15.986) AW9(9.363,-15.416) AW10(9.038,-14.753) AW11(9.363,-14.143) AW12(9.038,-13.565) AW13(9.363,-12.995) AW14(9.038,-12.332) AW15(9.363,-11.723) AW16(9.038,-11.145) AW17(9.363,-10.575) AW18(9.038,-9.912) AW20(9.363,-9.302) AW21(9.038,-8.724) AW22(9.363,-8.154) AW23(9.038,-7.466) AW25(9.363,-6.828) AW26(9.038,-6.264) AW27(9.363,-5.601) AW28(9.038,-4.988) AW29(9.363,-4.374) AW30(9.038,-3.711) AW31(9.363,-3.148) AW32(9.038,-2.485) AW33(9.363,-1.847) AW34(9.038,-1.283) AW35(9.363,-0.62) AW36(9.038,-0.007) AW37(9.363,0.607) AW38(9.038,1.269) AW39(9.363,1.833) AW41(9.038,2.471) AW42(9.363,3.108) AW43(9.038,3.672) AW44(9.363,4.335) AW45(9.038,4.949) AW46(9.363,5.562) AW47(9.038,6.163) AW48(9.363,6.727) AW49(9.038,7.355) AW50(9.363,7.984) AW51(9.038,8.548) AW52(9.363,9.149) AW53(9.038,9.762) AW54(9.363,10.375) AW55(9.038,11.038) AW56(9.363,11.602) AW57(9.038,12.24) AW59(9.363,12.877) AW60(9.038,13.441) AW61(9.363,14.104) AW62(9.038,14.718) AW63(9.363,15.331) AW64(9.038,15.994) AW65(9.363,16.558) AW66(8.9,17.093) AW67(9.371,18.018) AW68(9.622,18.622) AW69(9.536,19.267) AW70(10.035,19.685) AW71(9.551,20.314) AY2(10.034,-19.685) AY3(10.028,-19.028) AY4(10.043,-18.274) AY5(9.689,-17.665) AY8(9.689,-15.986) AY12(9.689,-13.565) AY16(9.689,-11.145) AY21(9.689,-8.724) AY26(9.689,-6.264) AY27(10.014,-5.601) AY29(10.014,-4.374) AY30(9.689,-3.711) AY34(9.689,-1.283) AY35(10.014,-0.62) AY37(10.014,0.607) AY38(9.689,1.269) AY43(9.689,3.672) AY44(10.014,4.335) AY46(10.014,5.562) AY47(9.689,6.163) AY51(9.689,8.548) AY52(10.014,9.149) AY54(10.014,10.375) AY55(9.689,11.038) AY60(9.689,13.441) AY61(10.014,14.104) AY63(10.014,15.331) AY64(9.689,15.994) AY66(9.689,17.221) AY68(10.267,18.535) B5(-10.664,-18.048) B6(-10.339,-17.467) B10(-10.339,-14.989) B14(-10.339,-12.511) B18(-10.339,-10.033) B22(-10.339,-7.555) B26(-10.339,-5.077) B30(-10.339,-2.599) B34(-10.339,-0.121) B39(-10.339,2.357) B44(-10.339,4.835) B48(-10.339,7.313) B53(-10.339,9.791) B58(-10.339,12.269) B62(-10.339,14.747) B66(-10.339,17.226) B69(-10.685,19.035) BA3(10.685,-19.035) BA5(10.626,-17.715) BA8(10.339,-15.986) BA12(10.339,-13.565) BA16(10.339,-11.145) BA21(10.339,-8.724) BA23(10.258,-7.466) BA28(10.258,-4.988) BA32(10.258,-2.485) BA36(10.258,-0.007) BA41(10.258,2.471) BA45(10.258,4.949) BA49(10.339,7.355) BA53(10.258,9.762) BA57(10.258,12.24) BA62(10.258,14.718) BA68(10.685,19.035) BB4(11.314,-18.551) BB68(11.314,18.552) C4(-10.336,-18.615) C5(-10.014,-18.048) C7(-10.014,-16.791) C8(-10.339,-16.228) C9(-10.014,-15.664) C11(-10.014,-14.313) C12(-10.339,-13.75) C13(-10.014,-13.186) C15(-10.014,-11.835) C16(-10.339,-11.272) C17(-10.014,-10.708) C19(-10.014,-9.357) C20(-10.339,-8.794) C21(-10.014,-8.23) C23(-10.014,-6.879) C24(-10.339,-6.316) C25(-10.014,-5.752) C27(-10.014,-4.401) C28(-10.339,-3.838) C29(-10.014,-3.274) C31(-10.014,-1.923) C32(-10.339,-1.36) C33(-10.014,-0.796) C36(-10.014,0.555) C37(-10.339,1.118) C38(-10.014,1.682) C40(-10.014,3.033) C41(-10.339,3.596) C42(-10.014,4.16) C45(-10.014,5.511) C46(-10.339,6.074) C47(-10.014,6.638) C50(-10.014,7.989) C51(-10.339,8.552) C52(-10.014,9.116) C54(-10.014,10.467) C55(-10.339,11.03) C56(-10.014,11.594) C59(-10.014,12.945) C60(-10.339,13.508) C61(-10.014,14.072) C63(-10.014,15.423) C64(-10.339,15.987) C65(-10.014,16.55) C67(-10.299,18.485) C68(-9.622,18.622) C70(-10.034,19.685) D3(-9.608,-19.339) D4(-9.669,-18.691) D5(-9.363,-18.09) D6(-9.323,-17.441) D7(-9.363,-16.791) D8(-9.689,-16.228) D9(-9.363,-15.664) D10(-9.323,-14.989) D11(-9.363,-14.313) D12(-9.689,-13.75) D13(-9.363,-13.186) D14(-9.323,-12.511) D15(-9.363,-11.835) D16(-9.689,-11.272) D17(-9.363,-10.708) D18(-9.323,-10.033) D19(-9.363,-9.357) D20(-9.689,-8.794) D21(-9.363,-8.23) D22(-9.323,-7.555) D23(-9.363,-6.879) D24(-9.689,-6.316) D25(-9.363,-5.752) D26(-9.323,-5.077) D27(-9.363,-4.401) D28(-9.689,-3.838) D29(-9.363,-3.274) D30(-9.323,-2.599) D31(-9.363,-1.923) D32(-9.689,-1.36) D33(-9.363,-0.796) D34(-9.323,-0.121) D36(-9.363,0.555) D37(-9.689,1.118) D38(-9.363,1.682) D39(-9.323,2.357) D40(-9.363,3.033) D41(-9.689,3.596) D42(-9.363,4.16) D44(-9.323,4.835) D45(-9.363,5.511) D46(-9.689,6.074) D47(-9.363,6.638) D48(-9.323,7.313) D50(-9.363,7.989) D51(-9.689,8.552) D52(-9.363,9.116) D53(-9.323,9.791) D54(-9.363,10.467) D55(-9.689,11.03) D56(-9.363,11.594) D58(-9.323,12.269) D59(-9.363,12.945) D60(-9.689,13.508) D61(-9.363,14.072) D62(-9.323,14.747) D63(-9.363,15.423) D64(-9.689,15.987) D65(-9.363,16.55) D66(-9.323,17.226) D67(-10.014,17.899) D68(-9.535,19.267) D69(-8.971,18.562) D71(-9.551,20.314) E1(-9.04,-20.314) E2(-9.04,-19.664) E3(-9.04,-19.014) E5(-8.591,-17.654) E6(-8.591,-16.74) E8(-8.591,-15.825) E10(-8.591,-14.911) E11(-8.591,-13.996) E13(-8.591,-13.082) E15(-8.591,-12.168) E16(-8.591,-11.253) E18(-8.591,-10.339) E20(-8.591,-9.424) E21(-8.591,-8.51) E22(-8.591,-7.596) E23(-8.591,-6.681) E25(-8.591,-5.767) E27(-8.591,-4.852) E28(-8.591,-3.938) E30(-8.591,-3.024) E32(-8.591,-2.109) E33(-8.591,-1.195) E35(-8.591,-0.28) E37(-8.591,0.634) E38(-8.591,1.548) E40(-8.591,2.463) E42(-8.591,3.377) E43(-8.591,4.292) E45(-8.591,5.206) E46(-8.591,6.12) E48(-8.591,7.035) E50(-8.591,7.949) E52(-8.591,8.864) E53(-8.591,9.778) E55(-8.591,10.692) E56(-8.591,11.607) E58(-8.591,12.521) E60(-8.591,13.436) E61(-8.591,14.35) E63(-8.655,15.315) E65(-8.655,16.331) E66(-8.655,17.347) E68(-9.363,17.899) F2(-8.466,-19.339) F4(-8.466,-18.363) F5(-7.941,-17.654) F6(-7.941,-16.74) F8(-7.941,-15.825) F10(-7.941,-14.911) F11(-7.941,-13.996) F13(-7.941,-13.082) F15(-7.941,-12.168) F16(-7.941,-11.253) F18(-7.941,-10.339) F20(-7.941,-9.424) F21(-7.941,-8.51) F22(-7.941,-7.596) F23(-7.941,-6.681) F25(-7.941,-5.767) F27(-7.941,-4.852) F28(-7.941,-3.938) F30(-7.941,-3.024) F32(-7.941,-2.109) F33(-7.941,-1.195) F35(-7.941,-0.28) F37(-7.941,0.634) F38(-7.941,1.548) F40(-7.941,2.463) F42(-7.941,3.377) F43(-7.941,4.292) F45(-7.941,5.206) F46(-7.941,6.12) F48(-7.941,7.035) F50(-7.941,7.949) F52(-7.941,8.864) F53(-7.941,9.778) F55(-7.941,10.692) F56(-7.941,11.607) F58(-7.941,12.521) F60(-7.941,13.436) F61(-7.941,14.35) F63(-8.005,15.315) F65(-8.005,16.331) F66(-8.005,17.347) F68(-8.32,18.562) G4(-7.803,-18.363) G5(-7.291,-17.654) G6(-7.291,-16.74) G8(-7.291,-15.825) G10(-7.291,-14.911) G11(-7.291,-13.996) G13(-7.291,-13.082) G15(-7.291,-12.168) G16(-7.291,-11.253) G18(-7.291,-10.339) G20(-7.291,-9.424) G21(-7.291,-8.51) G22(-7.291,-7.596) G23(-7.291,-6.681) G25(-7.291,-5.767) G27(-7.291,-4.852) G28(-7.291,-3.938) G30(-7.291,-3.024) G32(-7.291,-2.109) G33(-7.291,-1.195) G35(-7.291,-0.28) G37(-7.291,0.634) G38(-7.291,1.548) G40(-7.291,2.463) G42(-7.291,3.377) G43(-7.291,4.292) G45(-7.291,5.206) G46(-7.291,6.12) G48(-7.291,7.035) G50(-7.291,7.949) G52(-7.291,8.864) G53(-7.291,9.778) G55(-7.291,10.692) G56(-7.291,11.607) G58(-7.291,12.521) G60(-7.291,13.436) G61(-7.291,14.35) G63(-7.354,15.315) G65(-7.354,16.331) G66(-7.354,17.347) G68(-7.66,18.364) G69(-7.66,19.014) H3(-7.14,-18.689) H5(-6.641,-17.654) H6(-6.641,-16.74) H8(-6.641,-15.825) H10(-6.641,-14.911) H11(-6.641,-13.996) H13(-6.641,-13.082) H15(-6.641,-12.168) H16(-6.641,-11.253) H18(-6.641,-10.339) H20(-6.641,-9.424) H21(-6.641,-8.51) H63(-6.704,15.315) H65(-6.704,16.331) H66(-6.704,17.347) H69(-7.096,18.689) J4(-6.477,-18.363) J5(-5.99,-17.654) J6(-5.99,-16.74) J8(-5.99,-15.825) J10(-5.99,-14.911) J11(-5.99,-13.996) J13(-5.99,-13.082) J22(-6.827,-7.138) J23(-6.827,-6.224) J25(-6.827,-5.31) J27(-6.827,-4.395) J28(-6.827,-3.481) J30(-6.827,-2.566) J32(-6.827,-1.652) J33(-6.827,-0.738) J35(-6.827,0.177) J37(-6.827,1.091) J38(-6.827,2.006) J40(-6.827,2.92) J42(-6.827,3.834) J43(-6.827,4.749) J45(-6.827,5.663) J46(-6.827,6.578) J48(-6.827,7.492) J50(-6.827,8.406) J52(-6.827,9.321) J53(-6.827,10.235) J55(-6.827,11.15) J56(-6.827,12.064) J58(-6.827,12.978) J60(-6.827,13.893) J68(-6.52,18.362) K15(-5.876,-12.188) K16(-5.876,-11.538) K17(-5.876,-10.888) K18(-5.876,-10.237) K19(-5.876,-9.587) K20(-5.876,-8.937) K21(-5.876,-8.287) K22(-6.362,-7.596) K23(-6.362,-6.681) K25(-6.362,-5.767) K27(-6.362,-4.852) K28(-6.362,-3.938) K30(-6.362,-3.024) K32(-6.362,-2.109) K33(-6.362,-1.195) K35(-6.362,-0.28) K37(-6.362,0.634) K38(-6.362,1.548) K40(-6.362,2.463) K42(-6.362,3.377) K43(-6.362,4.292) K45(-6.362,5.206) K46(-6.362,6.12) K48(-6.362,7.035) K50(-6.362,7.949) K52(-6.362,8.864) K53(-6.362,9.778) K55(-6.362,10.692) K56(-6.362,11.607) K58(-6.362,12.521) K60(-6.362,13.436) K61(-6.362,14.35) K63(-6.054,15.133) K64(-6.054,15.783) K65(-6.054,16.433) K66(-6.054,17.084) K67(-6.054,17.734) K68(-5.846,18.352) K70(-5.744,19.339) L2(-5.814,-19.339) L4(-5.814,-18.363) L6(-5.34,-17.585) L7(-5.34,-16.935) L8(-5.34,-16.285) L9(-5.34,-15.635) L10(-5.34,-14.984) L11(-5.34,-14.334) L12(-5.34,-13.684) L13(-5.34,-13.034) L15(-5.038,-12.188) L16(-5.038,-11.538) L17(-5.038,-10.888) L18(-5.038,-10.237) L19(-5.038,-9.587) L20(-5.038,-8.937) L21(-5.038,-8.287) L62(-5.625,14.644) L63(-5.168,15.112) L64(-5.168,15.763) L65(-5.168,16.413) L66(-5.168,17.063) L67(-5.168,17.713) L68(-5.168,18.364) L69(-5.168,19.014) L70(-5.168,19.664) L71(-5.168,20.314) M4(-5.151,-18.363) M62(-4.71,14.644) N3(-4.488,-18.689) N6(-4.4,-17.585) N7(-4.4,-16.935) N8(-4.4,-16.285) N9(-4.4,-15.635) N10(-4.4,-14.984) N11(-4.4,-14.334) N12(-4.4,-13.684) N13(-4.4,-13.034) N15(-4.2,-12.188) N16(-4.2,-11.538) N17(-4.2,-10.888) N18(-4.2,-10.237) N19(-4.2,-9.587) N20(-4.2,-8.937) N21(-4.2,-8.287) N63(-4.253,15.112) N64(-4.253,15.763) N65(-4.253,16.413) N66(-4.253,17.063) N67(-4.253,17.713) N68(-4.253,18.364) N69(-4.253,19.014) N70(-4.253,19.664) N71(-4.253,20.314) P4(-3.825,-18.363) P15(-3.362,-12.188) P16(-3.362,-11.538) P17(-3.362,-10.888) P18(-3.362,-10.237) P19(-3.362,-9.587) P20(-3.362,-8.937) P21(-3.362,-8.287) P62(-3.796,14.644) R6(-3.333,-17.585) R7(-3.333,-16.935) R8(-3.333,-16.285) R9(-3.333,-15.635) R10(-3.333,-14.984) R11(-3.333,-14.334) R12(-3.333,-13.684) R13(-3.333,-13.034) R63(-3.339,15.112) R64(-3.339,15.763) R65(-3.339,16.413) R66(-3.339,17.063) R67(-3.339,17.713) R68(-3.339,18.364) R69(-3.339,19.014) R70(-3.339,19.664) R71(-3.339,20.314) T2(-3.162,-19.339) T4(-3.162,-18.363) T15(-2.523,-12.188) T16(-2.523,-11.538) T17(-2.523,-10.888) T18(-2.523,-10.237) T19(-2.523,-9.587) T20(-2.523,-8.937) T21(-2.523,-8.287) T62(-2.882,14.644) U4(-2.499,-18.363) U6(-2.267,-17.585) U7(-2.267,-16.935) U8(-2.267,-16.285) U9(-2.267,-15.635) U10(-2.267,-14.984) U11(-2.267,-14.334) U12(-2.267,-13.684) U13(-2.267,-13.034) U63(-2.424,15.112) U64(-2.424,15.763) U65(-2.424,16.413) U66(-2.424,17.063) U67(-2.424,17.713) U68(-2.424,18.364) U69(-2.424,19.014) U70(-2.424,19.664) U71(-2.424,20.314) V3(-1.836,-18.689) V15(-1.685,-12.188) V16(-1.685,-11.538) V17(-1.685,-10.888) V18(-1.685,-10.237) V19(-1.685,-9.587) V20(-1.685,-8.937) V21(-1.685,-8.287) V62(-1.967,14.644) W4(-1.173,-18.363) W6(-1.2,-17.585) W7(-1.2,-16.935) W8(-1.2,-16.285) W9(-1.2,-15.635) W10(-1.2,-14.984) W11(-1.2,-14.334) W12(-1.2,-13.684) W13(-1.2,-13.034) W63(-1.51,15.112) W64(-1.51,15.763) W65(-1.51,16.413) W66(-1.51,17.063) W67(-1.51,17.713) W68(-1.51,18.364) W69(-1.51,19.014) W70(-1.51,19.664) W71(-1.51,20.314) Y15(-0.847,-12.188) Y16(-0.847,-11.538) Y17(-0.847,-10.888) Y18(-0.847,-10.237) Y19(-0.847,-9.587) Y20(-0.847,-8.937) Y21(-0.847,-8.287) Y62(-1.053,14.644)
  oval 0.343x0.254 smd: A6(-10.989,-17.467) A7(-11.314,-16.791) A9(-11.314,-15.664) A10(-10.989,-14.989) A11(-11.314,-14.313) A13(-11.314,-13.186) A14(-10.989,-12.511) A15(-11.314,-11.835) A17(-11.314,-10.708) A18(-10.989,-10.033) A19(-11.314,-9.357) A21(-11.314,-8.23) A22(-10.989,-7.555) A23(-11.314,-6.879) A25(-11.314,-5.752) A26(-10.989,-5.077) A27(-11.314,-4.401) A29(-11.314,-3.274) A30(-10.989,-2.599) A31(-11.314,-1.923) A33(-11.314,-0.796) A34(-10.989,-0.121) A36(-11.314,0.555) A38(-11.314,1.682) A39(-10.989,2.357) A40(-11.314,3.033) A42(-11.314,4.16) A44(-10.989,4.835) A45(-11.314,5.511) A47(-11.314,6.638) A48(-10.989,7.313) A50(-11.314,7.989) A52(-11.314,9.116) A53(-10.989,9.791) A54(-11.314,10.467) A56(-11.314,11.594) A58(-10.989,12.269) A59(-11.314,12.945) A61(-11.314,14.072) A62(-10.989,14.747) A63(-11.314,15.423) A65(-11.314,16.55) A66(-10.989,17.226) A67(-11.314,17.901) AY7(10.014,-16.551) AY9(10.014,-15.416) AY11(10.014,-14.13) AY13(10.014,-12.995) AY15(10.014,-11.71) AY17(10.014,-10.574) AY20(10.014,-9.289) AY22(10.014,-8.154) AY25(10.014,-6.828) AY31(10.014,-3.148) AY33(10.014,-1.847) AY39(10.014,1.834) AY42(10.014,3.109) AY48(10.014,6.789) AY50(10.014,7.922) AY56(10.014,11.602) AY59(10.014,12.877) AY65(10.014,16.558) AY67(10.014,17.901) B7(-10.664,-16.791) B9(-10.664,-15.664) B11(-10.664,-14.313) B13(-10.664,-13.186) B15(-10.664,-11.835) B17(-10.664,-10.708) B19(-10.664,-9.357) B21(-10.664,-8.23) B23(-10.664,-6.879) B25(-10.664,-5.752) B27(-10.664,-4.401) B29(-10.664,-3.274) B31(-10.664,-1.923) B33(-10.664,-0.796) B36(-10.664,0.555) B38(-10.664,1.682) B40(-10.664,3.033) B42(-10.664,4.16) B45(-10.664,5.511) B47(-10.664,6.638) B50(-10.664,7.989) B52(-10.664,9.116) B54(-10.664,10.467) B56(-10.664,11.594) B59(-10.664,12.945) B61(-10.664,14.072) B63(-10.664,15.423) B65(-10.664,16.55) B67(-10.664,17.901) BA4(10.689,-18.366) BA6(10.257,-17.173) BA7(10.664,-16.61) BA9(10.664,-15.416) BA10(10.257,-14.753) BA11(10.664,-14.189) BA13(10.664,-12.995) BA14(10.257,-12.332) BA15(10.664,-11.768) BA17(10.664,-10.574) BA18(10.257,-9.912) BA20(10.664,-9.348) BA22(10.664,-8.154) BA25(10.664,-6.828) BA26(10.339,-6.165) BA27(10.664,-5.502) BA29(10.664,-4.473) BA30(10.339,-3.811) BA31(10.664,-3.148) BA33(10.664,-1.847) BA34(10.339,-1.184) BA35(10.664,-0.521) BA37(10.664,0.507) BA38(10.339,1.17) BA39(10.664,1.834) BA42(10.664,3.109) BA43(10.339,3.771) BA44(10.664,4.434) BA46(10.664,5.463) BA47(10.339,6.126) BA48(10.664,6.789) BA50(10.664,7.922) BA51(10.339,8.585) BA52(10.664,9.248) BA54(10.664,10.276) BA55(10.339,10.939) BA56(10.664,11.602) BA59(10.664,12.877) BA60(10.339,13.54) BA61(10.664,14.203) BA63(10.664,15.232) BA64(10.339,15.895) BA65(10.664,16.558) BA66(10.339,17.221) BA67(10.664,17.901) BB5(11.314,-17.786) BB6(10.989,-17.173) BB7(11.314,-16.61) BB9(11.314,-15.416) BB10(10.989,-14.753) BB11(11.314,-14.189) BB13(11.314,-12.995) BB14(10.989,-12.332) BB15(11.314,-11.768) BB17(11.314,-10.574) BB18(10.989,-9.912) BB20(11.314,-9.348) BB22(11.314,-8.154) BB23(10.908,-7.466) BB25(11.314,-6.828) BB26(10.989,-6.165) BB27(11.314,-5.502) BB29(11.314,-4.473) BB30(10.989,-3.811) BB31(11.314,-3.148) BB32(10.908,-2.484) BB33(11.314,-1.847) BB34(10.989,-1.184) BB35(11.314,-0.521) BB37(11.314,0.507) BB38(10.989,1.17) BB39(11.314,1.834) BB41(10.908,2.471) BB42(11.314,3.109) BB43(10.989,3.771) BB44(11.314,4.434) BB46(11.314,5.463) BB47(10.989,6.126) BB48(11.314,6.789) BB50(11.314,7.922) BB51(10.989,8.585) BB52(11.314,9.248) BB54(11.314,10.276) BB55(10.989,10.939) BB56(11.314,11.602) BB57(10.908,12.24) BB59(11.314,12.877) BB60(10.989,13.54) BB61(11.314,14.203) BB63(11.314,15.232) BB64(10.989,15.895) BB65(11.314,16.558) BB66(10.989,17.221) BB67(11.314,17.901)
  oval 0.254x0.343 smd: AA1(-0.51,-19.989) AB1(0.153,-20.314) AB2(0.153,-19.664) AB3(0.153,-19.013) AC1(0.815,-19.989) AC2(0.815,-19.339) AD1(1.479,-20.314) AD2(1.479,-19.664) AD3(1.479,-19.013) AF1(2.141,-19.989) AF70(1.84,19.664) AF71(1.84,20.314) AG1(2.804,-20.314) AG2(2.804,-19.664) AG3(2.804,-19.013) AG70(2.503,19.339) AG71(2.503,19.989) AH1(3.467,-19.989) AH2(3.467,-19.339) AH68(3.166,18.363) AH69(3.166,19.014) AH70(3.166,19.664) AH71(3.166,20.314) AJ1(4.13,-20.314) AJ2(4.13,-19.664) AJ3(4.13,-19.013) AK70(3.829,19.989) AL1(4.793,-19.989) AL68(4.492,18.363) AL69(4.492,19.014) AL70(4.492,19.664) AL71(4.492,20.314) AM1(5.456,-20.314) AM2(5.456,-19.664) AM3(5.456,-19.013) AM70(5.155,19.339) AM71(5.155,19.989) AN1(6.119,-19.989) AN2(6.119,-19.339) AN70(5.818,19.664) AN71(5.818,20.314) AP1(6.782,-20.314) AP2(6.782,-19.664) AP3(6.782,-19.013) AR70(6.846,19.664) AR71(6.846,20.314) AT1(7.445,-19.989) AT70(7.509,19.339) AT71(7.509,19.989) AU1(8.108,-20.314) AU2(8.108,-19.664) AU3(8.108,-19.013) AU68(8.147,18.363) AU69(8.172,19.014) AU70(8.172,19.664) AU71(8.172,20.314) AV1(8.828,-20.314) AV2(8.799,-19.364) AV71(8.901,20.314) AW2(9.363,-19.689) AW3(9.363,-19.039) E70(-9.009,19.664) E71(-8.901,20.314) F1(-8.466,-19.989) F70(-8.32,19.212) F71(-8.384,19.862) G1(-7.803,-20.314) G2(-7.803,-19.664) G3(-7.803,-19.013) G70(-7.759,19.664) G71(-7.759,20.314) H1(-7.14,-19.989) H2(-7.14,-19.339) H70(-7.096,19.339) H71(-7.096,19.989) J1(-6.477,-20.314) J2(-6.477,-19.664) J3(-6.477,-19.013) J69(-6.433,19.014) J70(-6.433,19.664) J71(-6.433,20.314) K71(-5.744,19.989) L1(-5.814,-19.989) M1(-5.151,-20.314) M2(-5.151,-19.664) M3(-5.151,-19.013) N1(-4.488,-19.989) N2(-4.488,-19.339) P1(-3.825,-20.314) P2(-3.825,-19.664) P3(-3.825,-19.013) T1(-3.162,-19.989) U1(-2.499,-20.314) U2(-2.499,-19.664) U3(-2.499,-19.013) V1(-1.836,-19.989) V2(-1.836,-19.339) W1(-1.173,-20.314) W2(-1.173,-19.664) W3(-1.173,-19.013)
